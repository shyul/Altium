*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN10NH00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN10NH00 port1 port2
C1 port1 port2 1.84e-14
L2 port1 1 1.03e-8
R2 1 port2 1.80e-1
R3 port1 port2 3.23e+4
L4 port1 2 1.50e-7
R4 2 port2 84.5
L5 port1 3 4.39e-7
R5 3 port2 1.60e+3
L6 port1 4 7.33e-6
R6 4 port2 1.20e+5
.ENDS LQW04AN10NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN10NJ00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN10NJ00 port1 port2
C1 port1 port2 1.84e-14
L2 port1 1 1.03e-8
R2 1 port2 1.80e-1
R3 port1 port2 3.23e+4
L4 port1 2 1.50e-7
R4 2 port2 84.5
L5 port1 3 4.39e-7
R5 3 port2 1.60e+3
L6 port1 4 7.33e-6
R6 4 port2 1.20e+5
.ENDS LQW04AN10NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN11NH00
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN11NH00 port1 port2
C1 port1 port2 1.32e-14
L2 port1 1 1.12e-8
R2 1 port2 2.00e-1
R3 port1 port2 3.68e+4
L4 port1 2 1.69e-7
R4 2 port2 97.7
L5 port1 3 4.49e-7
R5 3 port2 1.64e+3
L6 port1 4 7.87e-6
R6 4 port2 1.48e+5
.ENDS LQW04AN11NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN11NJ00
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN11NJ00 port1 port2
C1 port1 port2 1.32e-14
L2 port1 1 1.12e-8
R2 1 port2 2.00e-1
R3 port1 port2 3.68e+4
L4 port1 2 1.69e-7
R4 2 port2 97.7
L5 port1 3 4.49e-7
R5 3 port2 1.64e+3
L6 port1 4 7.87e-6
R6 4 port2 1.48e+5
.ENDS LQW04AN11NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN12NH00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN12NH00 port1 port2
C1 port1 port2 1.63e-14
L2 port1 1 1.25e-8
R2 1 port2 2.00e-1
R3 port1 port2 3.59e+4
L4 port1 2 1.86e-7
R4 2 port2 106
L5 port1 3 5.12e-7
R5 3 port2 1.90e+3
L6 port1 4 1.06e-5
R6 4 port2 2.01e+5
.ENDS LQW04AN12NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN12NJ00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN12NJ00 port1 port2
C1 port1 port2 1.63e-14
L2 port1 1 1.25e-8
R2 1 port2 2.00e-1
R3 port1 port2 3.59e+4
L4 port1 2 1.86e-7
R4 2 port2 106
L5 port1 3 5.12e-7
R5 3 port2 1.90e+3
L6 port1 4 1.06e-5
R6 4 port2 2.01e+5
.ENDS LQW04AN12NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN13NH00
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN13NH00 port1 port2
C1 port1 port2 1.29e-14
L2 port1 1 1.36e-8
R2 1 port2 2.40e-1
R3 port1 port2 3.79e+4
L4 port1 2 2.10e-7
R4 2 port2 107
L5 port1 3 5.33e-7
R5 3 port2 1.67e+3
L6 port1 4 9.52e-6
R6 4 port2 1.79e+5
.ENDS LQW04AN13NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN13NJ00
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN13NJ00 port1 port2
C1 port1 port2 1.29e-14
L2 port1 1 1.36e-8
R2 1 port2 2.40e-1
R3 port1 port2 3.79e+4
L4 port1 2 2.10e-7
R4 2 port2 107
L5 port1 3 5.33e-7
R5 3 port2 1.67e+3
L6 port1 4 9.52e-6
R6 4 port2 1.79e+5
.ENDS LQW04AN13NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN14NH00
* Property : L = 14[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN14NH00 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 1.45e-8
R2 1 port2 2.40e-1
R3 port1 port2 3.31e+4
L4 port1 2 2.39e-7
R4 2 port2 56.1
L5 port1 3 2.87e-7
R5 3 port2 264
L6 port1 4 1.02e-6
R6 4 port2 9.34e+3
.ENDS LQW04AN14NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN14NJ00
* Property : L = 14[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN14NJ00 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 1.45e-8
R2 1 port2 2.40e-1
R3 port1 port2 3.31e+4
L4 port1 2 2.39e-7
R4 2 port2 56.1
L5 port1 3 2.87e-7
R5 3 port2 264
L6 port1 4 1.02e-6
R6 4 port2 9.34e+3
.ENDS LQW04AN14NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN15NH00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN15NH00 port1 port2
C1 port1 port2 1.60e-14
L2 port1 1 1.52e-8
R2 1 port2 3.40e-1
R3 port1 port2 4.27e+4
L4 port1 2 2.79e-7
R4 2 port2 230
L5 port1 3 7.80e-7
R5 3 port2 3.43e+3
L6 port1 4 1.57e-5
R6 4 port2 2.97e+5
.ENDS LQW04AN15NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN15NJ00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN15NJ00 port1 port2
C1 port1 port2 1.60e-14
L2 port1 1 1.52e-8
R2 1 port2 3.40e-1
R3 port1 port2 4.27e+4
L4 port1 2 2.79e-7
R4 2 port2 230
L5 port1 3 7.80e-7
R5 3 port2 3.43e+3
L6 port1 4 1.57e-5
R6 4 port2 2.97e+5
.ENDS LQW04AN15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN16NH00
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN16NH00 port1 port2
C1 port1 port2 1.73e-14
L2 port1 1 1.68e-8
R2 1 port2 2.70e-1
R3 port1 port2 3.81e+4
L4 port1 2 2.43e-7
R4 2 port2 124
L5 port1 3 6.34e-7
R5 3 port2 1.83e+3
L6 port1 4 7.48e-6
R6 4 port2 4.70e+4
.ENDS LQW04AN16NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN16NJ00
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN16NJ00 port1 port2
C1 port1 port2 1.73e-14
L2 port1 1 1.68e-8
R2 1 port2 2.70e-1
R3 port1 port2 3.81e+4
L4 port1 2 2.43e-7
R4 2 port2 124
L5 port1 3 6.34e-7
R5 3 port2 1.83e+3
L6 port1 4 7.48e-6
R6 4 port2 4.70e+4
.ENDS LQW04AN16NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN18NH00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN18NH00 port1 port2
C1 port1 port2 1.82e-14
L2 port1 1 1.84e-8
R2 1 port2 3.80e-1
R3 port1 port2 5.51e+4
L4 port1 2 3.22e-7
R4 2 port2 225
L5 port1 3 8.33e-7
R5 3 port2 3.40e+3
L6 port1 4 1.22e-5
R6 4 port2 2.31e+5
.ENDS LQW04AN18NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN18NJ00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN18NJ00 port1 port2
C1 port1 port2 1.82e-14
L2 port1 1 1.84e-8
R2 1 port2 3.80e-1
R3 port1 port2 5.51e+4
L4 port1 2 3.22e-7
R4 2 port2 225
L5 port1 3 8.33e-7
R5 3 port2 3.40e+3
L6 port1 4 1.22e-5
R6 4 port2 2.31e+5
.ENDS LQW04AN18NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN19NH00
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN19NH00 port1 port2
C1 port1 port2 1.84e-14
L2 port1 1 1.92e-8
R2 1 port2 7.30e-1
R3 port1 port2 5.07e+4
L4 port1 2 3.77e-7
R4 2 port2 405
L5 port1 3 1.16e-6
R5 3 port2 6.42e+3
L6 port1 4 2.88e-5
R6 4 port2 5.44e+5
.ENDS LQW04AN19NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN19NJ00
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN19NJ00 port1 port2
C1 port1 port2 1.84e-14
L2 port1 1 1.92e-8
R2 1 port2 7.30e-1
R3 port1 port2 5.07e+4
L4 port1 2 3.77e-7
R4 2 port2 405
L5 port1 3 1.16e-6
R5 3 port2 6.42e+3
L6 port1 4 2.88e-5
R6 4 port2 5.44e+5
.ENDS LQW04AN19NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N1C00
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N1C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 1.06e-9
R2 1 port2 2.00e-2
R3 port1 port2 9.02e+3
L4 port1 2 2.34e-8
R4 2 port2 20.6
L5 port1 3 6.60e-8
R5 3 port2 398
.ENDS LQW04AN1N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N1D00
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N1D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 1.06e-9
R2 1 port2 2.00e-2
R3 port1 port2 9.02e+3
L4 port1 2 2.34e-8
R4 2 port2 20.6
L5 port1 3 6.60e-8
R5 3 port2 398
.ENDS LQW04AN1N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N6C00
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N6C00 port1 port2
C1 port1 port2 7.85e-14
L2 port1 1 1.91e-9
R2 1 port2 4.00e-2
R3 port1 port2 5.27e+3
L4 port1 2 9.69e-9
R4 2 port2 2.49
L5 port1 3 2.75e-8
R5 3 port2 50.0
.ENDS LQW04AN1N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N6D00
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N6D00 port1 port2
C1 port1 port2 7.85e-14
L2 port1 1 1.91e-9
R2 1 port2 4.00e-2
R3 port1 port2 5.27e+3
L4 port1 2 9.69e-9
R4 2 port2 2.49
L5 port1 3 2.75e-8
R5 3 port2 50.0
.ENDS LQW04AN1N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N7C00
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N7C00 port1 port2
C1 port1 port2 7.33e-14
L2 port1 1 2.00e-9
R2 1 port2 4.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.25e-8
R4 2 port2 2.49
L5 port1 3 2.75e-8
R5 3 port2 50.0
.ENDS LQW04AN1N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N7D00
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N7D00 port1 port2
C1 port1 port2 7.33e-14
L2 port1 1 2.00e-9
R2 1 port2 4.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.25e-8
R4 2 port2 2.49
L5 port1 3 2.75e-8
R5 3 port2 50.0
.ENDS LQW04AN1N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N8C00
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N8C00 port1 port2
C1 port1 port2 1.04e-14
L2 port1 1 1.74e-9
R2 1 port2 4.00e-2
R3 port1 port2 1.91e+3
L4 port1 2 2.67e-8
R4 2 port2 1.74
L5 port1 3 4.58e-8
R5 3 port2 28.5
.ENDS LQW04AN1N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N8D00
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N8D00 port1 port2
C1 port1 port2 1.04e-14
L2 port1 1 1.74e-9
R2 1 port2 4.00e-2
R3 port1 port2 1.91e+3
L4 port1 2 2.67e-8
R4 2 port2 1.74
L5 port1 3 4.58e-8
R5 3 port2 28.5
.ENDS LQW04AN1N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N9C00
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N9C00 port1 port2
C1 port1 port2 6.68e-14
L2 port1 1 2.19e-9
R2 1 port2 8.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.22e-8
R4 2 port2 2.49
L5 port1 3 2.95e-8
R5 3 port2 65.9
.ENDS LQW04AN1N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN1N9D00
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN1N9D00 port1 port2
C1 port1 port2 6.68e-14
L2 port1 1 2.19e-9
R2 1 port2 8.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.22e-8
R4 2 port2 2.49
L5 port1 3 2.95e-8
R5 3 port2 65.9
.ENDS LQW04AN1N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN20NH00
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN20NH00 port1 port2
C1 port1 port2 1.35e-14
L2 port1 1 2.06e-8
R2 1 port2 4.00e-1
R3 port1 port2 5.64e+4
L4 port1 2 3.51e-7
R4 2 port2 245
L5 port1 3 9.15e-7
R5 3 port2 3.45e+3
L6 port1 4 1.38e-5
R6 4 port2 2.35e+5
L7 port1 5 5.57e-8
C7 5 6 1.19e-15
R7 6 port2 172
.ENDS LQW04AN20NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN20NJ00
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN20NJ00 port1 port2
C1 port1 port2 1.35e-14
L2 port1 1 2.06e-8
R2 1 port2 4.00e-1
R3 port1 port2 5.64e+4
L4 port1 2 3.51e-7
R4 2 port2 245
L5 port1 3 9.15e-7
R5 3 port2 3.45e+3
L6 port1 4 1.38e-5
R6 4 port2 2.35e+5
L7 port1 5 5.57e-8
C7 5 6 1.19e-15
R7 6 port2 172
.ENDS LQW04AN20NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN22NH00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN22NH00 port1 port2
C1 port1 port2 1.23e-14
L2 port1 1 2.27e-8
R2 1 port2 4.50e-1
R3 port1 port2 7.04e+4
L4 port1 2 3.64e-7
R4 2 port2 252
L5 port1 3 1.03e-6
R5 3 port2 4.46e+3
L6 port1 4 1.50e-5
R6 4 port2 2.84e+5
L7 port1 5 5.31e-8
C7 5 6 1.43e-15
R7 6 port2 221
.ENDS LQW04AN22NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN22NJ00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN22NJ00 port1 port2
C1 port1 port2 1.23e-14
L2 port1 1 2.27e-8
R2 1 port2 4.50e-1
R3 port1 port2 7.04e+4
L4 port1 2 3.64e-7
R4 2 port2 252
L5 port1 3 1.03e-6
R5 3 port2 4.46e+3
L6 port1 4 1.50e-5
R6 4 port2 2.84e+5
L7 port1 5 5.31e-8
C7 5 6 1.43e-15
R7 6 port2 221
.ENDS LQW04AN22NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN23NH00
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN23NH00 port1 port2
C1 port1 port2 1.12e-14
L2 port1 1 2.33e-8
R2 1 port2 8.00e-1
R3 port1 port2 6.79e+4
L4 port1 2 4.74e-7
R4 2 port2 477
L5 port1 3 1.41e-6
R5 3 port2 7.46e+3
L6 port1 4 1.46e-5
R6 4 port2 2.75e+5
L7 port1 5 2.67e-8
C7 5 6 3.10e-15
R7 6 port2 55.6
.ENDS LQW04AN23NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN23NJ00
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN23NJ00 port1 port2
C1 port1 port2 1.12e-14
L2 port1 1 2.33e-8
R2 1 port2 8.00e-1
R3 port1 port2 6.79e+4
L4 port1 2 4.74e-7
R4 2 port2 477
L5 port1 3 1.41e-6
R5 3 port2 7.46e+3
L6 port1 4 1.46e-5
R6 4 port2 2.75e+5
L7 port1 5 2.67e-8
C7 5 6 3.10e-15
R7 6 port2 55.6
.ENDS LQW04AN23NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN24NH00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN24NH00 port1 port2
C1 port1 port2 1.33e-14
L2 port1 1 2.41e-8
R2 1 port2 8.00e-1
R3 port1 port2 6.85e+4
L4 port1 2 4.71e-7
R4 2 port2 476
L5 port1 3 1.46e-6
R5 3 port2 7.63e+3
L6 port1 4 1.51e-5
R6 4 port2 2.85e+5
L7 port1 5 4.09e-8
C7 5 6 2.07e-15
R7 6 port2 129
.ENDS LQW04AN24NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN24NJ00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN24NJ00 port1 port2
C1 port1 port2 1.33e-14
L2 port1 1 2.41e-8
R2 1 port2 8.00e-1
R3 port1 port2 6.85e+4
L4 port1 2 4.71e-7
R4 2 port2 476
L5 port1 3 1.46e-6
R5 3 port2 7.63e+3
L6 port1 4 1.51e-5
R6 4 port2 2.85e+5
L7 port1 5 4.09e-8
C7 5 6 2.07e-15
R7 6 port2 129
.ENDS LQW04AN24NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN25NH00
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN25NH00 port1 port2
C1 port1 port2 1.36e-14
L2 port1 1 2.50e-8
R2 1 port2 8.00e-1
R3 port1 port2 5.88e+4
L4 port1 2 5.20e-7
R4 2 port2 526
L5 port1 3 1.38e-6
R5 3 port2 5.98e+3
L6 port1 4 1.47e-5
R6 4 port2 2.78e+5
L7 port1 5 2.86e-8
C7 5 6 2.92e-15
R7 6 port2 99.5
.ENDS LQW04AN25NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN25NJ00
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN25NJ00 port1 port2
C1 port1 port2 1.36e-14
L2 port1 1 2.50e-8
R2 1 port2 8.00e-1
R3 port1 port2 5.88e+4
L4 port1 2 5.20e-7
R4 2 port2 526
L5 port1 3 1.38e-6
R5 3 port2 5.98e+3
L6 port1 4 1.47e-5
R6 4 port2 2.78e+5
L7 port1 5 2.86e-8
C7 5 6 2.92e-15
R7 6 port2 99.5
.ENDS LQW04AN25NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN27NH00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN27NH00 port1 port2
C1 port1 port2 1.22e-14
L2 port1 1 2.75e-8
R2 1 port2 7.30e-1
R3 port1 port2 7.09e+4
L4 port1 2 5.58e-7
R4 2 port2 564
L5 port1 3 1.68e-6
R5 3 port2 8.33e+3
L6 port1 4 1.64e-5
R6 4 port2 3.09e+5
L7 port1 5 6.84e-8
C7 5 6 1.40e-15
R7 6 port2 186
.ENDS LQW04AN27NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN27NJ00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN27NJ00 port1 port2
C1 port1 port2 1.22e-14
L2 port1 1 2.75e-8
R2 1 port2 7.30e-1
R3 port1 port2 7.09e+4
L4 port1 2 5.58e-7
R4 2 port2 564
L5 port1 3 1.68e-6
R5 3 port2 8.33e+3
L6 port1 4 1.64e-5
R6 4 port2 3.09e+5
L7 port1 5 6.84e-8
C7 5 6 1.40e-15
R7 6 port2 186
.ENDS LQW04AN27NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N4C00
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N4C00 port1 port2
C1 port1 port2 5.31e-14
L2 port1 1 2.63e-9
R2 1 port2 5.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.50e-8
R4 2 port2 2.49
L5 port1 3 5.01e-8
R5 3 port2 102
.ENDS LQW04AN2N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N4D00
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N4D00 port1 port2
C1 port1 port2 5.31e-14
L2 port1 1 2.63e-9
R2 1 port2 5.00e-2
R3 port1 port2 6.05e+3
L4 port1 2 1.50e-8
R4 2 port2 2.49
L5 port1 3 5.01e-8
R5 3 port2 102
.ENDS LQW04AN2N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N5C00
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N5C00 port1 port2
C1 port1 port2 4.95e-14
L2 port1 1 2.81e-9
R2 1 port2 8.00e-2
R3 port1 port2 4.81e+3
L4 port1 2 1.64e-8
R4 2 port2 2.49
L5 port1 3 4.17e-8
R5 3 port2 84.9
.ENDS LQW04AN2N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N5D00
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N5D00 port1 port2
C1 port1 port2 4.95e-14
L2 port1 1 2.81e-9
R2 1 port2 8.00e-2
R3 port1 port2 4.81e+3
L4 port1 2 1.64e-8
R4 2 port2 2.49
L5 port1 3 4.17e-8
R5 3 port2 84.9
.ENDS LQW04AN2N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N6C00
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N6C00 port1 port2
C1 port1 port2 4.51e-14
L2 port1 1 2.88e-9
R2 1 port2 5.00e-2
R3 port1 port2 7.62e+3
L4 port1 2 3.37e-8
R4 2 port2 14.9
L5 port1 3 1.11e-7
R5 3 port2 389
.ENDS LQW04AN2N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N6D00
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N6D00 port1 port2
C1 port1 port2 4.51e-14
L2 port1 1 2.88e-9
R2 1 port2 5.00e-2
R3 port1 port2 7.62e+3
L4 port1 2 3.37e-8
R4 2 port2 14.9
L5 port1 3 1.11e-7
R5 3 port2 389
.ENDS LQW04AN2N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N7C00
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N7C00 port1 port2
C1 port1 port2 1.09e-14
L2 port1 1 2.74e-9
R2 1 port2 5.00e-2
R3 port1 port2 1.43e+4
L4 port1 2 4.64e-8
R4 2 port2 25.1
L5 port1 3 1.02e-7
R5 3 port2 417
.ENDS LQW04AN2N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N7D00
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N7D00 port1 port2
C1 port1 port2 1.09e-14
L2 port1 1 2.74e-9
R2 1 port2 5.00e-2
R3 port1 port2 1.43e+4
L4 port1 2 4.64e-8
R4 2 port2 25.1
L5 port1 3 1.02e-7
R5 3 port2 417
.ENDS LQW04AN2N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N8C00
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N8C00 port1 port2
C1 port1 port2 4.41e-14
L2 port1 1 3.02e-9
R2 1 port2 5.00e-2
R3 port1 port2 9.59e+3
L4 port1 2 2.33e-8
R4 2 port2 4.28
L5 port1 3 7.64e-8
R5 3 port2 236
.ENDS LQW04AN2N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N8D00
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N8D00 port1 port2
C1 port1 port2 4.41e-14
L2 port1 1 3.02e-9
R2 1 port2 5.00e-2
R3 port1 port2 9.59e+3
L4 port1 2 2.33e-8
R4 2 port2 4.28
L5 port1 3 7.64e-8
R5 3 port2 236
.ENDS LQW04AN2N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N9C00
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N9C00 port1 port2
C1 port1 port2 4.31e-14
L2 port1 1 3.02e-9
R2 1 port2 8.00e-2
R3 port1 port2 5.78e+3
L4 port1 2 1.92e-8
R4 2 port2 4.53
L5 port1 3 6.96e-8
R5 3 port2 146
.ENDS LQW04AN2N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN2N9D00
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN2N9D00 port1 port2
C1 port1 port2 4.31e-14
L2 port1 1 3.02e-9
R2 1 port2 8.00e-2
R3 port1 port2 5.78e+3
L4 port1 2 1.92e-8
R4 2 port2 4.53
L5 port1 3 6.96e-8
R5 3 port2 146
.ENDS LQW04AN2N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN33NH00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN33NH00 port1 port2
C1 port1 port2 1.50e-14
L2 port1 1 3.09e-8
R2 1 port2 7.30e-1
R3 port1 port2 7.09e+4
L4 port1 2 5.58e-7
R4 2 port2 564
L5 port1 3 1.68e-6
R5 3 port2 8.33e+3
L6 port1 4 1.64e-5
R6 4 port2 3.09e+5
L7 port1 5 6.84e-8
C7 5 6 1.68e-15
R7 6 port2 186
.ENDS LQW04AN33NH00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN33NJ00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN33NJ00 port1 port2
C1 port1 port2 1.50e-14
L2 port1 1 3.09e-8
R2 1 port2 7.30e-1
R3 port1 port2 7.09e+4
L4 port1 2 5.58e-7
R4 2 port2 564
L5 port1 3 1.68e-6
R5 3 port2 8.33e+3
L6 port1 4 1.64e-5
R6 4 port2 3.09e+5
L7 port1 5 6.84e-8
C7 5 6 1.68e-15
R7 6 port2 186
.ENDS LQW04AN33NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N0C00
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N0C00 port1 port2
C1 port1 port2 2.29e-14
L2 port1 1 3.13e-9
R2 1 port2 5.00e-2
R3 port1 port2 1.50e+4
L4 port1 2 4.69e-8
R4 2 port2 24.8
L5 port1 3 1.25e-7
R5 3 port2 470
.ENDS LQW04AN3N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N0D00
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N0D00 port1 port2
C1 port1 port2 2.29e-14
L2 port1 1 3.13e-9
R2 1 port2 5.00e-2
R3 port1 port2 1.50e+4
L4 port1 2 4.69e-8
R4 2 port2 24.8
L5 port1 3 1.25e-7
R5 3 port2 470
.ENDS LQW04AN3N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N1C00
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N1C00 port1 port2
C1 port1 port2 4.02e-14
L2 port1 1 3.24e-9
R2 1 port2 8.00e-2
R3 port1 port2 8.35e+3
L4 port1 2 2.36e-8
R4 2 port2 8.26
L5 port1 3 1.21e-7
R5 3 port2 471
.ENDS LQW04AN3N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N1D00
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N1D00 port1 port2
C1 port1 port2 4.02e-14
L2 port1 1 3.24e-9
R2 1 port2 8.00e-2
R3 port1 port2 8.35e+3
L4 port1 2 2.36e-8
R4 2 port2 8.26
L5 port1 3 1.21e-7
R5 3 port2 471
.ENDS LQW04AN3N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N2C00
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N2C00 port1 port2
C1 port1 port2 3.75e-14
L2 port1 1 3.55e-9
R2 1 port2 1.20e-1
R3 port1 port2 7.62e+3
L4 port1 2 2.55e-8
R4 2 port2 2.31
L5 port1 3 6.60e-8
R5 3 port2 149
.ENDS LQW04AN3N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N2D00
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N2D00 port1 port2
C1 port1 port2 3.75e-14
L2 port1 1 3.55e-9
R2 1 port2 1.20e-1
R3 port1 port2 7.62e+3
L4 port1 2 2.55e-8
R4 2 port2 2.31
L5 port1 3 6.60e-8
R5 3 port2 149
.ENDS LQW04AN3N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N3C00
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N3C00 port1 port2
C1 port1 port2 2.66e-14
L2 port1 1 3.45e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.57e+4
L4 port1 2 5.85e-8
R4 2 port2 40.8
L5 port1 3 1.32e-7
R5 3 port2 596
.ENDS LQW04AN3N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N3D00
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N3D00 port1 port2
C1 port1 port2 2.66e-14
L2 port1 1 3.45e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.57e+4
L4 port1 2 5.85e-8
R4 2 port2 40.8
L5 port1 3 1.32e-7
R5 3 port2 596
.ENDS LQW04AN3N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N4C00
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N4C00 port1 port2
C1 port1 port2 3.58e-14
L2 port1 1 3.64e-9
R2 1 port2 1.90e-1
R3 port1 port2 6.48e+3
L4 port1 2 7.59e-7
R4 2 port2 4.71e-4
L5 port1 3 6.47e-8
R5 3 port2 120
.ENDS LQW04AN3N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N4D00
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N4D00 port1 port2
C1 port1 port2 3.58e-14
L2 port1 1 3.64e-9
R2 1 port2 1.90e-1
R3 port1 port2 6.48e+3
L4 port1 2 7.59e-7
R4 2 port2 4.71e-4
L5 port1 3 6.47e-8
R5 3 port2 120
.ENDS LQW04AN3N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N6C00
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N6C00 port1 port2
C1 port1 port2 9.62e-15
L2 port1 1 3.62e-9
R2 1 port2 7.00e-2
R3 port1 port2 1.35e+4
L4 port1 2 5.53e-8
R4 2 port2 29.2
L5 port1 3 1.40e-7
R5 3 port2 519
.ENDS LQW04AN3N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N6D00
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N6D00 port1 port2
C1 port1 port2 9.62e-15
L2 port1 1 3.62e-9
R2 1 port2 7.00e-2
R3 port1 port2 1.35e+4
L4 port1 2 5.53e-8
R4 2 port2 29.2
L5 port1 3 1.40e-7
R5 3 port2 519
.ENDS LQW04AN3N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N7C00
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N7C00 port1 port2
C1 port1 port2 3.41e-14
L2 port1 1 4.37e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.05e+3
L4 port1 2 1.68e-8
R4 2 port2 1.18
L5 port1 3 5.74e-8
R5 3 port2 96.1
.ENDS LQW04AN3N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N7D00
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N7D00 port1 port2
C1 port1 port2 3.41e-14
L2 port1 1 4.37e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.05e+3
L4 port1 2 1.68e-8
R4 2 port2 1.18
L5 port1 3 5.74e-8
R5 3 port2 96.1
.ENDS LQW04AN3N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N8C00
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N8C00 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 4.37e-9
R2 1 port2 7.00e-3
R3 port1 port2 4.49e+3
L4 port1 2 1.04e-8
R4 2 port2 5.89e-1
L5 port1 3 7.40e-8
R5 3 port2 91.8
.ENDS LQW04AN3N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N8D00
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N8D00 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 4.37e-9
R2 1 port2 7.00e-3
R3 port1 port2 4.49e+3
L4 port1 2 1.04e-8
R4 2 port2 5.89e-1
L5 port1 3 7.40e-8
R5 3 port2 91.8
.ENDS LQW04AN3N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N9C00
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N9C00 port1 port2
C1 port1 port2 1.22e-14
L2 port1 1 3.94e-9
R2 1 port2 7.00e-2
R3 port1 port2 1.55e+4
L4 port1 2 6.71e-8
R4 2 port2 31.7
L5 port1 3 1.33e-7
R5 3 port2 392
.ENDS LQW04AN3N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN3N9D00
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN3N9D00 port1 port2
C1 port1 port2 1.22e-14
L2 port1 1 3.94e-9
R2 1 port2 7.00e-2
R3 port1 port2 1.55e+4
L4 port1 2 6.71e-8
R4 2 port2 31.7
L5 port1 3 1.33e-7
R5 3 port2 392
.ENDS LQW04AN3N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N0C00
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N0C00 port1 port2
C1 port1 port2 3.41e-14
L2 port1 1 4.68e-9
R2 1 port2 7.00e-3
R3 port1 port2 6.05e+3
L4 port1 2 1.64e-8
R4 2 port2 1.18
L5 port1 3 7.54e-8
R5 3 port2 116
.ENDS LQW04AN4N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N0D00
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N0D00 port1 port2
C1 port1 port2 3.41e-14
L2 port1 1 4.68e-9
R2 1 port2 7.00e-3
R3 port1 port2 6.05e+3
L4 port1 2 1.64e-8
R4 2 port2 1.18
L5 port1 3 7.54e-8
R5 3 port2 116
.ENDS LQW04AN4N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N1C00
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N1C00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 4.37e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.14e-7
R4 2 port2 22.7
L5 port1 3 1.38e-7
R5 3 port2 369
.ENDS LQW04AN4N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N1D00
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N1D00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 4.37e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.14e-7
R4 2 port2 22.7
L5 port1 3 1.38e-7
R5 3 port2 369
.ENDS LQW04AN4N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N2C00
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N2C00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 4.79e-9
R2 1 port2 7.00e-2
R3 port1 port2 8.95e+3
L4 port1 2 2.65e-8
R4 2 port2 1.73
L5 port1 3 7.53e-8
R5 3 port2 103
.ENDS LQW04AN4N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N2D00
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N2D00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 4.79e-9
R2 1 port2 7.00e-2
R3 port1 port2 8.95e+3
L4 port1 2 2.65e-8
R4 2 port2 1.73
L5 port1 3 7.53e-8
R5 3 port2 103
.ENDS LQW04AN4N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N3C00
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N3C00 port1 port2
C1 port1 port2 2.47e-14
L2 port1 1 4.28e-9
R2 1 port2 7.00e-2
R3 port1 port2 2.21e+4
L4 port1 2 6.50e-8
R4 2 port2 26.6
L5 port1 3 1.55e-7
R5 3 port2 497
L6 port1 4 2.70e-6
R6 4 port2 3.97e+4
.ENDS LQW04AN4N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N3D00
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N3D00 port1 port2
C1 port1 port2 2.47e-14
L2 port1 1 4.28e-9
R2 1 port2 7.00e-2
R3 port1 port2 2.21e+4
L4 port1 2 6.50e-8
R4 2 port2 26.6
L5 port1 3 1.55e-7
R5 3 port2 497
L6 port1 4 2.70e-6
R6 4 port2 3.97e+4
.ENDS LQW04AN4N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N4C00
* Property : L = 4.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N4C00 port1 port2
C1 port1 port2 1.96e-14
L2 port1 1 4.68e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.81e+3
L4 port1 2 4.86e-8
R4 2 port2 7.88
L5 port1 3 1.23e-7
R5 3 port2 293
.ENDS LQW04AN4N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N4D00
* Property : L = 4.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N4D00 port1 port2
C1 port1 port2 1.96e-14
L2 port1 1 4.68e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.81e+3
L4 port1 2 4.86e-8
R4 2 port2 7.88
L5 port1 3 1.23e-7
R5 3 port2 293
.ENDS LQW04AN4N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N5C00
* Property : L = 4.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N5C00 port1 port2
C1 port1 port2 1.92e-14
L2 port1 1 4.68e-9
R2 1 port2 1.00e-1
R3 port1 port2 7.62e+3
L4 port1 2 6.86e-8
R4 2 port2 13.7
L5 port1 3 1.10e-7
R5 3 port2 228
.ENDS LQW04AN4N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N5D00
* Property : L = 4.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N5D00 port1 port2
C1 port1 port2 1.92e-14
L2 port1 1 4.68e-9
R2 1 port2 1.00e-1
R3 port1 port2 7.62e+3
L4 port1 2 6.86e-8
R4 2 port2 13.7
L5 port1 3 1.10e-7
R5 3 port2 228
.ENDS LQW04AN4N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N6C00
* Property : L = 4.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N6C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 4.90e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.24e+4
L4 port1 2 7.02e-8
R4 2 port2 13.7
L5 port1 3 1.32e-7
R5 3 port2 369
.ENDS LQW04AN4N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N6D00
* Property : L = 4.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N6D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 4.90e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.24e+4
L4 port1 2 7.02e-8
R4 2 port2 13.7
L5 port1 3 1.32e-7
R5 3 port2 369
.ENDS LQW04AN4N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N7C00
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N7C00 port1 port2
C1 port1 port2 2.12e-14
L2 port1 1 4.71e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.59e+4
L4 port1 2 8.72e-8
R4 2 port2 60.8
L5 port1 3 2.02e-7
R5 3 port2 750
L6 port1 4 1.94e-7
R6 4 port2 5.19e+3
.ENDS LQW04AN4N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N7D00
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N7D00 port1 port2
C1 port1 port2 2.12e-14
L2 port1 1 4.71e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.59e+4
L4 port1 2 8.72e-8
R4 2 port2 60.8
L5 port1 3 2.02e-7
R5 3 port2 750
L6 port1 4 1.94e-7
R6 4 port2 5.19e+3
.ENDS LQW04AN4N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N8C00
* Property : L = 4.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N8C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 9.59e+3
L4 port1 2 1.16e-7
R4 2 port2 6.56
L5 port1 3 1.21e-7
R5 3 port2 286
.ENDS LQW04AN4N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N8D00
* Property : L = 4.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N8D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 9.59e+3
L4 port1 2 1.16e-7
R4 2 port2 6.56
L5 port1 3 1.21e-7
R5 3 port2 286
.ENDS LQW04AN4N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N9C00
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N9C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 5.52e+3
L4 port1 2 1.08e-7
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 233
.ENDS LQW04AN4N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN4N9D00
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN4N9D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 5.52e+3
L4 port1 2 1.08e-7
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 233
.ENDS LQW04AN4N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N0C00
* Property : L = 5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N0C00 port1 port2
C1 port1 port2 2.26e-14
L2 port1 1 5.25e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.32e+4
L4 port1 2 8.98e-8
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 386
.ENDS LQW04AN5N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N0D00
* Property : L = 5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N0D00 port1 port2
C1 port1 port2 2.26e-14
L2 port1 1 5.25e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.32e+4
L4 port1 2 8.98e-8
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 386
.ENDS LQW04AN5N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N1C00
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N1C00 port1 port2
C1 port1 port2 1.45e-14
L2 port1 1 5.14e-9
R2 1 port2 9.26e-2
R3 port1 port2 2.43e+4
L4 port1 2 7.78e-8
R4 2 port2 34.7
L5 port1 3 1.87e-7
R5 3 port2 623
L6 port1 4 4.41e-6
R6 4 port2 8.30e+4
.ENDS LQW04AN5N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N1D00
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N1D00 port1 port2
C1 port1 port2 1.45e-14
L2 port1 1 5.14e-9
R2 1 port2 9.26e-2
R3 port1 port2 2.43e+4
L4 port1 2 7.78e-8
R4 2 port2 34.7
L5 port1 3 1.87e-7
R5 3 port2 623
L6 port1 4 4.41e-6
R6 4 port2 8.30e+4
.ENDS LQW04AN5N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N2C00
* Property : L = 5.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N2C00 port1 port2
C1 port1 port2 1.88e-14
L2 port1 1 5.50e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 7.82e-8
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 300
.ENDS LQW04AN5N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N2D00
* Property : L = 5.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N2D00 port1 port2
C1 port1 port2 1.88e-14
L2 port1 1 5.50e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 7.82e-8
R4 2 port2 13.7
L5 port1 3 1.21e-7
R5 3 port2 300
.ENDS LQW04AN5N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N3C00
* Property : L = 5.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N3C00 port1 port2
C1 port1 port2 1.88e-14
L2 port1 1 5.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+3
L4 port1 2 7.82e-8
R4 2 port2 13.7
L5 port1 3 1.95e-7
R5 3 port2 369
.ENDS LQW04AN5N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N3D00
* Property : L = 5.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N3D00 port1 port2
C1 port1 port2 1.88e-14
L2 port1 1 5.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+3
L4 port1 2 7.82e-8
R4 2 port2 13.7
L5 port1 3 1.95e-7
R5 3 port2 369
.ENDS LQW04AN5N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N4C00
* Property : L = 5.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N4C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.21e+4
L4 port1 2 7.47e-8
R4 2 port2 13.7
L5 port1 3 1.45e-7
R5 3 port2 369
.ENDS LQW04AN5N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N4D00
* Property : L = 5.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N4D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.21e+4
L4 port1 2 7.47e-8
R4 2 port2 13.7
L5 port1 3 1.45e-7
R5 3 port2 369
.ENDS LQW04AN5N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N5C00
* Property : L = 5.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N5C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.89e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.35e+4
L4 port1 2 6.21e-8
R4 2 port2 13.7
L5 port1 3 1.86e-7
R5 3 port2 627
.ENDS LQW04AN5N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N5D00
* Property : L = 5.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N5D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 5.89e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.35e+4
L4 port1 2 6.21e-8
R4 2 port2 13.7
L5 port1 3 1.86e-7
R5 3 port2 627
.ENDS LQW04AN5N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N6C00
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N6C00 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 5.69e-9
R2 1 port2 8.00e-2
R3 port1 port2 2.26e+4
L4 port1 2 7.84e-8
R4 2 port2 32.5
L5 port1 3 1.85e-7
R5 3 port2 558
L6 port1 4 4.57e-6
R6 4 port2 8.62e+4
.ENDS LQW04AN5N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N6D00
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N6D00 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 5.69e-9
R2 1 port2 8.00e-2
R3 port1 port2 2.26e+4
L4 port1 2 7.84e-8
R4 2 port2 32.5
L5 port1 3 1.85e-7
R5 3 port2 558
L6 port1 4 4.57e-6
R6 4 port2 8.62e+4
.ENDS LQW04AN5N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N7C00
* Property : L = 5.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N7C00 port1 port2
C1 port1 port2 2.02e-14
L2 port1 1 6.03e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.42e+4
L4 port1 2 8.98e-8
R4 2 port2 13.7
L5 port1 3 1.38e-7
R5 3 port2 329
.ENDS LQW04AN5N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N7D00
* Property : L = 5.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N7D00 port1 port2
C1 port1 port2 2.02e-14
L2 port1 1 6.03e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.42e+4
L4 port1 2 8.98e-8
R4 2 port2 13.7
L5 port1 3 1.38e-7
R5 3 port2 329
.ENDS LQW04AN5N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N8C00
* Property : L = 5.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N8C00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 6.17e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.00e-8
R4 2 port2 13.7
L5 port1 3 1.44e-7
R5 3 port2 321
.ENDS LQW04AN5N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N8D00
* Property : L = 5.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N8D00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 6.17e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.00e-8
R4 2 port2 13.7
L5 port1 3 1.44e-7
R5 3 port2 321
.ENDS LQW04AN5N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N9C00
* Property : L = 5.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N9C00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.38e-8
R4 2 port2 13.7
L5 port1 3 1.41e-7
R5 3 port2 307
.ENDS LQW04AN5N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN5N9D00
* Property : L = 5.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN5N9D00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.38e-8
R4 2 port2 13.7
L5 port1 3 1.41e-7
R5 3 port2 307
.ENDS LQW04AN5N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N0C00
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N0C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.32e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.38e-7
R5 3 port2 307
.ENDS LQW04AN6N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N0D00
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N0D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.32e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.38e-7
R5 3 port2 307
.ENDS LQW04AN6N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N1C00
* Property : L = 6.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N1C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.48e-7
R5 3 port2 321
.ENDS LQW04AN6N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N1D00
* Property : L = 6.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N1D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 6.31e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.48e-7
R5 3 port2 321
.ENDS LQW04AN6N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N2C00
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N2C00 port1 port2
C1 port1 port2 1.86e-14
L2 port1 1 6.16e-9
R2 1 port2 1.30e-1
R3 port1 port2 3.93e+4
L4 port1 2 1.03e-7
R4 2 port2 71.9
L5 port1 3 2.87e-7
R5 3 port2 1.61e+3
L6 port1 4 1.23e-5
R6 4 port2 1.31e+5
.ENDS LQW04AN6N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N2D00
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N2D00 port1 port2
C1 port1 port2 1.86e-14
L2 port1 1 6.16e-9
R2 1 port2 1.30e-1
R3 port1 port2 3.93e+4
L4 port1 2 1.03e-7
R4 2 port2 71.9
L5 port1 3 2.87e-7
R5 3 port2 1.61e+3
L6 port1 4 1.23e-5
R6 4 port2 1.31e+5
.ENDS LQW04AN6N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N3C00
* Property : L = 6.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N3C00 port1 port2
C1 port1 port2 2.60e-14
L2 port1 1 6.61e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.41e-7
R5 3 port2 307
.ENDS LQW04AN6N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N3D00
* Property : L = 6.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N3D00 port1 port2
C1 port1 port2 2.60e-14
L2 port1 1 6.61e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 8.77e-8
R4 2 port2 17.6
L5 port1 3 1.41e-7
R5 3 port2 307
.ENDS LQW04AN6N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N4C00
* Property : L = 6.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N4C00 port1 port2
C1 port1 port2 2.92e-14
L2 port1 1 6.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.39e+4
L4 port1 2 8.57e-8
R4 2 port2 17.6
L5 port1 3 1.48e-7
R5 3 port2 307
.ENDS LQW04AN6N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N4D00
* Property : L = 6.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N4D00 port1 port2
C1 port1 port2 2.92e-14
L2 port1 1 6.76e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.39e+4
L4 port1 2 8.57e-8
R4 2 port2 17.6
L5 port1 3 1.48e-7
R5 3 port2 307
.ENDS LQW04AN6N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N5C00
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N5C00 port1 port2
C1 port1 port2 2.27e-14
L2 port1 1 6.92e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.00e+4
L4 port1 2 8.97e-8
R4 2 port2 17.6
L5 port1 3 1.58e-7
R5 3 port2 386
.ENDS LQW04AN6N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N5D00
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N5D00 port1 port2
C1 port1 port2 2.27e-14
L2 port1 1 6.92e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.00e+4
L4 port1 2 8.97e-8
R4 2 port2 17.6
L5 port1 3 1.58e-7
R5 3 port2 386
.ENDS LQW04AN6N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N6C00
* Property : L = 6.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N6C00 port1 port2
C1 port1 port2 2.93e-14
L2 port1 1 6.92e-9
R2 1 port2 1.30e-1
R3 port1 port2 8.16e+3
L4 port1 2 8.37e-8
R4 2 port2 17.6
L5 port1 3 1.44e-7
R5 3 port2 321
.ENDS LQW04AN6N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N6D00
* Property : L = 6.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N6D00 port1 port2
C1 port1 port2 2.93e-14
L2 port1 1 6.92e-9
R2 1 port2 1.30e-1
R3 port1 port2 8.16e+3
L4 port1 2 8.37e-8
R4 2 port2 17.6
L5 port1 3 1.44e-7
R5 3 port2 321
.ENDS LQW04AN6N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N7C00
* Property : L = 6.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N7C00 port1 port2
C1 port1 port2 2.86e-14
L2 port1 1 7.08e-9
R2 1 port2 1.30e-1
R3 port1 port2 9.37e+3
L4 port1 2 9.18e-8
R4 2 port2 17.6
L5 port1 3 1.55e-7
R5 3 port2 307
.ENDS LQW04AN6N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N7D00
* Property : L = 6.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N7D00 port1 port2
C1 port1 port2 2.86e-14
L2 port1 1 7.08e-9
R2 1 port2 1.30e-1
R3 port1 port2 9.37e+3
L4 port1 2 9.18e-8
R4 2 port2 17.6
L5 port1 3 1.55e-7
R5 3 port2 307
.ENDS LQW04AN6N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N8C00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N8C00 port1 port2
C1 port1 port2 1.41e-14
L2 port1 1 6.97e-9
R2 1 port2 1.00e-1
R3 port1 port2 2.65e+4
L4 port1 2 9.53e-8
R4 2 port2 40.1
L5 port1 3 2.71e-7
R5 3 port2 716
L6 port1 4 1.38e-6
R6 4 port2 9.57e+3
.ENDS LQW04AN6N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N8D00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N8D00 port1 port2
C1 port1 port2 1.41e-14
L2 port1 1 6.97e-9
R2 1 port2 1.00e-1
R3 port1 port2 2.65e+4
L4 port1 2 9.53e-8
R4 2 port2 40.1
L5 port1 3 2.71e-7
R5 3 port2 716
L6 port1 4 1.38e-6
R6 4 port2 9.57e+3
.ENDS LQW04AN6N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N9C00
* Property : L = 6.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N9C00 port1 port2
C1 port1 port2 2.22e-14
L2 port1 1 7.59e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.42e+4
L4 port1 2 9.84e-8
R4 2 port2 17.6
L5 port1 3 1.81e-7
R5 3 port2 307
.ENDS LQW04AN6N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN6N9D00
* Property : L = 6.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN6N9D00 port1 port2
C1 port1 port2 2.22e-14
L2 port1 1 7.59e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.42e+4
L4 port1 2 9.84e-8
R4 2 port2 17.6
L5 port1 3 1.81e-7
R5 3 port2 307
.ENDS LQW04AN6N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N0C00
* Property : L = 7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N0C00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 7.59e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.52e+4
L4 port1 2 9.62e-8
R4 2 port2 17.6
L5 port1 3 1.73e-7
R5 3 port2 307
.ENDS LQW04AN7N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N0D00
* Property : L = 7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N0D00 port1 port2
C1 port1 port2 2.21e-14
L2 port1 1 7.59e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.52e+4
L4 port1 2 9.62e-8
R4 2 port2 17.6
L5 port1 3 1.73e-7
R5 3 port2 307
.ENDS LQW04AN7N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N1C00
* Property : L = 7.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N1C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.10e+4
L4 port1 2 8.38e-8
R4 2 port2 17.6
L5 port1 3 1.77e-7
R5 3 port2 238
.ENDS LQW04AN7N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N1D00
* Property : L = 7.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N1D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.10e+4
L4 port1 2 8.38e-8
R4 2 port2 17.6
L5 port1 3 1.77e-7
R5 3 port2 238
.ENDS LQW04AN7N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N2C00
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N2C00 port1 port2
C1 port1 port2 2.37e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.42e+4
L4 port1 2 1.10e-7
R4 2 port2 17.6
L5 port1 3 1.58e-7
R5 3 port2 238
.ENDS LQW04AN7N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N2D00
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N2D00 port1 port2
C1 port1 port2 2.37e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.42e+4
L4 port1 2 1.10e-7
R4 2 port2 17.6
L5 port1 3 1.58e-7
R5 3 port2 238
.ENDS LQW04AN7N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N3C00
* Property : L = 7.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N3C00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.79e+4
L4 port1 2 1.00e-7
R4 2 port2 17.6
L5 port1 3 1.51e-7
R5 3 port2 238
.ENDS LQW04AN7N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N3D00
* Property : L = 7.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N3D00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 7.77e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.79e+4
L4 port1 2 1.00e-7
R4 2 port2 17.6
L5 port1 3 1.51e-7
R5 3 port2 238
.ENDS LQW04AN7N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N4C00
* Property : L = 7.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N4C00 port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 8.14e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.45e+4
L4 port1 2 5.77e-8
R4 2 port2 6.39
L5 port1 3 1.58e-7
R5 3 port2 238
.ENDS LQW04AN7N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N4D00
* Property : L = 7.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N4D00 port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 8.14e-9
R2 1 port2 1.00e-1
R3 port1 port2 1.45e+4
L4 port1 2 5.77e-8
R4 2 port2 6.39
L5 port1 3 1.58e-7
R5 3 port2 238
.ENDS LQW04AN7N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N5C00
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N5C00 port1 port2
C1 port1 port2 2.27e-14
L2 port1 1 7.58e-9
R2 1 port2 1.00e-1
R3 port1 port2 2.40e+4
L4 port1 2 1.02e-7
R4 2 port2 35.9
L5 port1 3 2.37e-7
R5 3 port2 626
L6 port1 4 4.19e-6
R6 4 port2 5.53e+4
.ENDS LQW04AN7N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N5D00
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N5D00 port1 port2
C1 port1 port2 2.27e-14
L2 port1 1 7.58e-9
R2 1 port2 1.00e-1
R3 port1 port2 2.40e+4
L4 port1 2 1.02e-7
R4 2 port2 35.9
L5 port1 3 2.37e-7
R5 3 port2 626
L6 port1 4 4.19e-6
R6 4 port2 5.53e+4
.ENDS LQW04AN7N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N6C00
* Property : L = 7.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N6C00 port1 port2
C1 port1 port2 2.37e-14
L2 port1 1 8.14e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.26e+4
L4 port1 2 1.23e-7
R4 2 port2 15.7
L5 port1 3 1.55e-7
R5 3 port2 238
.ENDS LQW04AN7N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N6D00
* Property : L = 7.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N6D00 port1 port2
C1 port1 port2 2.37e-14
L2 port1 1 8.14e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.26e+4
L4 port1 2 1.23e-7
R4 2 port2 15.7
L5 port1 3 1.55e-7
R5 3 port2 238
.ENDS LQW04AN7N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N7C00
* Property : L = 7.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N7C00 port1 port2
C1 port1 port2 2.26e-14
L2 port1 1 8.14e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.21e+4
L4 port1 2 1.20e-7
R4 2 port2 17.6
L5 port1 3 1.51e-7
R5 3 port2 238
.ENDS LQW04AN7N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N7D00
* Property : L = 7.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N7D00 port1 port2
C1 port1 port2 2.26e-14
L2 port1 1 8.14e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.21e+4
L4 port1 2 1.20e-7
R4 2 port2 17.6
L5 port1 3 1.51e-7
R5 3 port2 238
.ENDS LQW04AN7N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N8C00
* Property : L = 7.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N8C00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 8.33e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.48e-7
R4 2 port2 17.6
L5 port1 3 1.44e-7
R5 3 port2 212
.ENDS LQW04AN7N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N8D00
* Property : L = 7.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N8D00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 8.33e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.48e-7
R4 2 port2 17.6
L5 port1 3 1.44e-7
R5 3 port2 212
.ENDS LQW04AN7N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N9C00
* Property : L = 7.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N9C00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 8.52e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.18e+4
L4 port1 2 1.12e-7
R4 2 port2 17.6
L5 port1 3 1.99e-7
R5 3 port2 413
.ENDS LQW04AN7N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN7N9D00
* Property : L = 7.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN7N9D00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 8.52e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.18e+4
L4 port1 2 1.12e-7
R4 2 port2 17.6
L5 port1 3 1.99e-7
R5 3 port2 413
.ENDS LQW04AN7N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N0C00
* Property : L = 8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N0C00 port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.52e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.17e-7
R4 2 port2 14.0
L5 port1 3 1.66e-7
R5 3 port2 299
.ENDS LQW04AN8N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N0D00
* Property : L = 8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N0D00 port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.52e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.17e-7
R4 2 port2 14.0
L5 port1 3 1.66e-7
R5 3 port2 299
.ENDS LQW04AN8N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N1C00
* Property : L = 8.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N1C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 8.72e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.72e-7
R4 2 port2 17.2
L5 port1 3 1.29e-7
R5 3 port2 153
.ENDS LQW04AN8N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N1D00
* Property : L = 8.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N1D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 8.72e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.72e-7
R4 2 port2 17.2
L5 port1 3 1.29e-7
R5 3 port2 153
.ENDS LQW04AN8N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N2C00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N2C00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 8.29e-9
R2 1 port2 1.60e-1
R3 port1 port2 3.56e+4
L4 port1 2 1.36e-7
R4 2 port2 81.9
L5 port1 3 3.49e-7
R5 3 port2 1.51e+3
L6 port1 4 4.44e-6
R6 4 port2 3.65e+4
.ENDS LQW04AN8N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N2D00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N2D00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 8.29e-9
R2 1 port2 1.60e-1
R3 port1 port2 3.56e+4
L4 port1 2 1.36e-7
R4 2 port2 81.9
L5 port1 3 3.49e-7
R5 3 port2 1.51e+3
L6 port1 4 4.44e-6
R6 4 port2 3.65e+4
.ENDS LQW04AN8N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N3C00
* Property : L = 8.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N3C00 port1 port2
C1 port1 port2 2.84e-14
L2 port1 1 8.92e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 6.42e-8
R4 2 port2 5.88
L5 port1 3 1.35e-7
R5 3 port2 168
.ENDS LQW04AN8N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N3D00
* Property : L = 8.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N3D00 port1 port2
C1 port1 port2 2.84e-14
L2 port1 1 8.92e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 6.42e-8
R4 2 port2 5.88
L5 port1 3 1.35e-7
R5 3 port2 168
.ENDS LQW04AN8N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N4C00
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N4C00 port1 port2
C1 port1 port2 2.65e-14
L2 port1 1 9.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.53e-7
R4 2 port2 17.2
L5 port1 3 1.29e-7
R5 3 port2 153
.ENDS LQW04AN8N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N4D00
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N4D00 port1 port2
C1 port1 port2 2.65e-14
L2 port1 1 9.13e-9
R2 1 port2 1.60e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.53e-7
R4 2 port2 17.2
L5 port1 3 1.29e-7
R5 3 port2 153
.ENDS LQW04AN8N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N5C00
* Property : L = 8.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N5C00 port1 port2
C1 port1 port2 2.41e-14
L2 port1 1 9.34e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.07e-7
R4 2 port2 17.6
L5 port1 3 1.32e-7
R5 3 port2 172
.ENDS LQW04AN8N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N5D00
* Property : L = 8.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N5D00 port1 port2
C1 port1 port2 2.41e-14
L2 port1 1 9.34e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.07e-7
R4 2 port2 17.6
L5 port1 3 1.32e-7
R5 3 port2 172
.ENDS LQW04AN8N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N6C00
* Property : L = 8.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N6C00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.28e-7
R4 2 port2 17.6
L5 port1 3 1.15e-7
R5 3 port2 128
.ENDS LQW04AN8N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N6D00
* Property : L = 8.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N6D00 port1 port2
C1 port1 port2 2.31e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.28e-7
R4 2 port2 17.6
L5 port1 3 1.15e-7
R5 3 port2 128
.ENDS LQW04AN8N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N7C00
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N7C00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.21e-7
R4 2 port2 17.6
L5 port1 3 1.18e-7
R5 3 port2 128
.ENDS LQW04AN8N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N7D00
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N7D00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.21e-7
R4 2 port2 17.6
L5 port1 3 1.18e-7
R5 3 port2 128
.ENDS LQW04AN8N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N8C00
* Property : L = 8.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N8C00 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 6.76e-8
R4 2 port2 20.8
L5 port1 3 4.72e-7
R5 3 port2 973
.ENDS LQW04AN8N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N8D00
* Property : L = 8.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N8D00 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 9.13e-9
R2 1 port2 2.30e-1
R3 port1 port2 1.52e+4
L4 port1 2 6.76e-8
R4 2 port2 20.8
L5 port1 3 4.72e-7
R5 3 port2 973
.ENDS LQW04AN8N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N9C00
* Property : L = 8.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N9C00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 9.56e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.56e+4
L4 port1 2 1.31e-7
R4 2 port2 17.6
L5 port1 3 1.75e-7
R5 3 port2 261
.ENDS LQW04AN8N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN8N9D00
* Property : L = 8.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN8N9D00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 9.56e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.56e+4
L4 port1 2 1.31e-7
R4 2 port2 17.6
L5 port1 3 1.75e-7
R5 3 port2 261
.ENDS LQW04AN8N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N0C00
* Property : L = 9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N0C00 port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 9.78e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.21e+4
L4 port1 2 1.73e-7
R4 2 port2 17.6
L5 port1 3 1.63e-7
R5 3 port2 203
.ENDS LQW04AN9N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N0D00
* Property : L = 9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N0D00 port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 9.78e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.21e+4
L4 port1 2 1.73e-7
R4 2 port2 17.6
L5 port1 3 1.63e-7
R5 3 port2 203
.ENDS LQW04AN9N0D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N1C00
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N1C00 port1 port2
C1 port1 port2 1.98e-14
L2 port1 1 9.76e-9
R2 1 port2 1.10e-1
R3 port1 port2 2.89e+4
L4 port1 2 1.20e-7
R4 2 port2 38.4
L5 port1 3 2.64e-7
R5 3 port2 596
L6 port1 4 2.30e-6
R6 4 port2 1.60e+4
.ENDS LQW04AN9N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N1D00
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N1D00 port1 port2
C1 port1 port2 1.98e-14
L2 port1 1 9.76e-9
R2 1 port2 1.10e-1
R3 port1 port2 2.89e+4
L4 port1 2 1.20e-7
R4 2 port2 38.4
L5 port1 3 2.64e-7
R5 3 port2 596
L6 port1 4 2.30e-6
R6 4 port2 1.60e+4
.ENDS LQW04AN9N1D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N2C00
* Property : L = 9.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N2C00 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 1.02e-8
R2 1 port2 1.10e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.41e-7
R4 2 port2 17.6
L5 port1 3 1.83e-7
R5 3 port2 262
.ENDS LQW04AN9N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N2D00
* Property : L = 9.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N2D00 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 1.02e-8
R2 1 port2 1.10e-1
R3 port1 port2 1.52e+4
L4 port1 2 1.41e-7
R4 2 port2 17.6
L5 port1 3 1.83e-7
R5 3 port2 262
.ENDS LQW04AN9N2D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N3C00
* Property : L = 9.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N3C00 port1 port2
C1 port1 port2 1.87e-14
L2 port1 1 9.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.51e-7
R4 2 port2 17.6
L5 port1 3 1.63e-7
R5 3 port2 203
.ENDS LQW04AN9N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N3D00
* Property : L = 9.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N3D00 port1 port2
C1 port1 port2 1.87e-14
L2 port1 1 9.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.51e-7
R4 2 port2 17.6
L5 port1 3 1.63e-7
R5 3 port2 203
.ENDS LQW04AN9N3D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N4C00
* Property : L = 9.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N4C00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 9.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.40e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 223
.ENDS LQW04AN9N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N4D00
* Property : L = 9.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N4D00 port1 port2
C1 port1 port2 2.01e-14
L2 port1 1 9.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.40e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 223
.ENDS LQW04AN9N4D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N5C00
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N5C00 port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 1.02e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.69e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 199
.ENDS LQW04AN9N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N5D00
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N5D00 port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 1.02e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.52e+4
L4 port1 2 2.69e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 199
.ENDS LQW04AN9N5D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N6C00
* Property : L = 9.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N6C00 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.59e+4
L4 port1 2 1.95e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 223
.ENDS LQW04AN9N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N6D00
* Property : L = 9.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N6D00 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.59e+4
L4 port1 2 1.95e-7
R4 2 port2 17.6
L5 port1 3 1.67e-7
R5 3 port2 223
.ENDS LQW04AN9N6D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N7C00
* Property : L = 9.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N7C00 port1 port2
C1 port1 port2 2.36e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.96e+4
L4 port1 2 1.66e-7
R4 2 port2 17.6
L5 port1 3 2.05e-7
R5 3 port2 323
.ENDS LQW04AN9N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N7D00
* Property : L = 9.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N7D00 port1 port2
C1 port1 port2 2.36e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.96e+4
L4 port1 2 1.66e-7
R4 2 port2 17.6
L5 port1 3 2.05e-7
R5 3 port2 323
.ENDS LQW04AN9N7D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N8C00
* Property : L = 9.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N8C00 port1 port2
C1 port1 port2 2.36e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.91e+4
L4 port1 2 1.47e-7
R4 2 port2 17.6
L5 port1 3 1.83e-7
R5 3 port2 287
.ENDS LQW04AN9N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N8D00
* Property : L = 9.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N8D00 port1 port2
C1 port1 port2 2.36e-14
L2 port1 1 1.04e-8
R2 1 port2 1.80e-1
R3 port1 port2 1.91e+4
L4 port1 2 1.47e-7
R4 2 port2 17.6
L5 port1 3 1.83e-7
R5 3 port2 287
.ENDS LQW04AN9N8D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N9C00
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N9C00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 1.03e-8
R2 1 port2 1.80e-1
R3 port1 port2 3.23e+4
L4 port1 2 1.57e-7
R4 2 port2 84.5
L5 port1 3 4.93e-7
R5 3 port2 1.60e+3
L6 port1 4 7.33e-6
R6 4 port2 1.20e+5
.ENDS LQW04AN9N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN9N9D00
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN9N9D00 port1 port2
C1 port1 port2 2.11e-14
L2 port1 1 1.03e-8
R2 1 port2 1.80e-1
R3 port1 port2 3.23e+4
L4 port1 2 1.57e-7
R4 2 port2 84.5
L5 port1 3 4.93e-7
R5 3 port2 1.60e+3
L6 port1 4 7.33e-6
R6 4 port2 1.20e+5
.ENDS LQW04AN9N9D00
*----------------------------------------------------------------------
