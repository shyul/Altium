*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN10NG02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN10NG02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 1.17e-8
R2 1 port2 1.91e-1
R3 port1 port2 1.06e+4
L4 port1 2 2.34e-7
R4 2 port2 850
L5 port1 3 9.53e-8
R5 3 port2 47.3
L6 port1 4 9.15e-8
R6 4 port2 8.80
L7 port1 5 1.64e-9
C7 5 6 6.46e-14
R7 6 port2 3.13
L8 port1 7 8.03e-10
C8 7 8 5.80e-14
R8 8 port2 3.18
.ENDS LQG15HN10NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN10NH02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 1.17e-8
R2 1 port2 1.91e-1
R3 port1 port2 1.06e+4
L4 port1 2 2.34e-7
R4 2 port2 850
L5 port1 3 9.53e-8
R5 3 port2 47.3
L6 port1 4 9.15e-8
R6 4 port2 8.80
L7 port1 5 1.64e-9
C7 5 6 6.46e-14
R7 6 port2 3.13
L8 port1 7 8.03e-10
C8 7 8 5.80e-14
R8 8 port2 3.18
.ENDS LQG15HN10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN10NJ02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 1.17e-8
R2 1 port2 1.91e-1
R3 port1 port2 1.06e+4
L4 port1 2 2.34e-7
R4 2 port2 850
L5 port1 3 9.53e-8
R5 3 port2 47.3
L6 port1 4 9.15e-8
R6 4 port2 8.80
L7 port1 5 1.64e-9
C7 5 6 6.46e-14
R7 6 port2 3.13
L8 port1 7 8.03e-10
C8 7 8 5.80e-14
R8 8 port2 3.18
.ENDS LQG15HN10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN12NG02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN12NG02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-8
R2 1 port2 1.87e-1
R3 port1 port2 1.04e+4
L4 port1 2 2.57e-7
R4 2 port2 890
L5 port1 3 1.09e-7
R5 3 port2 54.4
L6 port1 4 7.27e-8
R6 4 port2 5.68
L7 port1 5 1.10e-9
C7 5 6 6.10e-14
R7 6 port2 2.06
L8 port1 7 7.15e-9
C8 7 8 1.86e-14
R8 8 port2 7.68
L9 port1 9 1.27e-9
C9 9 10 9.19e-14
R9 10 port2 3.18
.ENDS LQG15HN12NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN12NH02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-8
R2 1 port2 1.87e-1
R3 port1 port2 1.04e+4
L4 port1 2 2.57e-7
R4 2 port2 890
L5 port1 3 1.09e-7
R5 3 port2 54.4
L6 port1 4 7.27e-8
R6 4 port2 5.68
L7 port1 5 1.10e-9
C7 5 6 6.10e-14
R7 6 port2 2.06
L8 port1 7 7.15e-9
C8 7 8 1.86e-14
R8 8 port2 7.68
L9 port1 9 1.27e-9
C9 9 10 9.19e-14
R9 10 port2 3.18
.ENDS LQG15HN12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN12NJ02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-8
R2 1 port2 1.87e-1
R3 port1 port2 1.04e+4
L4 port1 2 2.57e-7
R4 2 port2 890
L5 port1 3 1.09e-7
R5 3 port2 54.4
L6 port1 4 7.27e-8
R6 4 port2 5.68
L7 port1 5 1.10e-9
C7 5 6 6.10e-14
R7 6 port2 2.06
L8 port1 7 7.15e-9
C8 7 8 1.86e-14
R8 8 port2 7.68
L9 port1 9 1.27e-9
C9 9 10 9.19e-14
R9 10 port2 3.18
.ENDS LQG15HN12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN15NG02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN15NG02 port1 port2
C1 port1 port2 6.17e-15
L2 port1 1 1.95e-8
R2 1 port2 2.05e-1
R3 port1 port2 1.28e+4
L4 port1 2 3.16e-7
R4 2 port2 1.12e+3
L5 port1 3 1.41e-7
R5 3 port2 75.0
L6 port1 4 7.79e-8
R6 4 port2 6.52
L7 port1 5 5.77e-10
C7 5 6 1.28e-13
R7 6 port2 1.03
L8 port1 7 2.60e-9
C8 7 8 5.37e-14
R8 8 port2 5.44
L9 port1 9 1.88e-8
C9 9 10 6.21e-15
R9 10 port2 297
.ENDS LQG15HN15NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN15NH02 port1 port2
C1 port1 port2 6.17e-15
L2 port1 1 1.95e-8
R2 1 port2 2.05e-1
R3 port1 port2 1.28e+4
L4 port1 2 3.16e-7
R4 2 port2 1.12e+3
L5 port1 3 1.41e-7
R5 3 port2 75.0
L6 port1 4 7.79e-8
R6 4 port2 6.52
L7 port1 5 5.77e-10
C7 5 6 1.28e-13
R7 6 port2 1.03
L8 port1 7 2.60e-9
C8 7 8 5.37e-14
R8 8 port2 5.44
L9 port1 9 1.88e-8
C9 9 10 6.21e-15
R9 10 port2 297
.ENDS LQG15HN15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN15NJ02 port1 port2
C1 port1 port2 6.17e-15
L2 port1 1 1.95e-8
R2 1 port2 2.05e-1
R3 port1 port2 1.28e+4
L4 port1 2 3.16e-7
R4 2 port2 1.12e+3
L5 port1 3 1.41e-7
R5 3 port2 75.0
L6 port1 4 7.79e-8
R6 4 port2 6.52
L7 port1 5 5.77e-10
C7 5 6 1.28e-13
R7 6 port2 1.03
L8 port1 7 2.60e-9
C8 7 8 5.37e-14
R8 8 port2 5.44
L9 port1 9 1.88e-8
C9 9 10 6.21e-15
R9 10 port2 297
.ENDS LQG15HN15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN18NG02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN18NG02 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.19e-8
R2 1 port2 2.76e-1
R3 port1 port2 1.72e+4
L4 port1 2 3.62e-7
R4 2 port2 1.35e+3
L5 port1 3 1.69e-7
R5 3 port2 88.2
L6 port1 4 1.29e-7
R6 4 port2 13.3
L7 port1 5 5.90e-10
C7 5 6 1.25e-13
R7 6 port2 1.33
L8 port1 7 4.83e-9
C8 7 8 3.98e-14
R8 8 port2 11.9
L9 port1 9 1.97e-8
C9 9 10 5.93e-15
R9 10 port2 311
.ENDS LQG15HN18NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN18NH02 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.19e-8
R2 1 port2 2.76e-1
R3 port1 port2 1.72e+4
L4 port1 2 3.62e-7
R4 2 port2 1.35e+3
L5 port1 3 1.69e-7
R5 3 port2 88.2
L6 port1 4 1.29e-7
R6 4 port2 13.3
L7 port1 5 5.90e-10
C7 5 6 1.25e-13
R7 6 port2 1.33
L8 port1 7 4.83e-9
C8 7 8 3.98e-14
R8 8 port2 11.9
L9 port1 9 1.97e-8
C9 9 10 5.93e-15
R9 10 port2 311
.ENDS LQG15HN18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN18NJ02 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.19e-8
R2 1 port2 2.76e-1
R3 port1 port2 1.72e+4
L4 port1 2 3.62e-7
R4 2 port2 1.35e+3
L5 port1 3 1.69e-7
R5 3 port2 88.2
L6 port1 4 1.29e-7
R6 4 port2 13.3
L7 port1 5 5.90e-10
C7 5 6 1.25e-13
R7 6 port2 1.33
L8 port1 7 4.83e-9
C8 7 8 3.98e-14
R8 8 port2 11.9
L9 port1 9 1.97e-8
C9 9 10 5.93e-15
R9 10 port2 311
.ENDS LQG15HN18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N0B02 port1 port2
C1 port1 port2 5.14e-16
L2 port1 1 7.61e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 2.30e-8
R4 2 port2 104
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.20e-8
C7 5 6 1.52e-15
R7 6 port2 130
.ENDS LQG15HN1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N0C02 port1 port2
C1 port1 port2 5.14e-16
L2 port1 1 7.61e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 2.30e-8
R4 2 port2 104
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.20e-8
C7 5 6 1.52e-15
R7 6 port2 130
.ENDS LQG15HN1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N0S02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N0S02 port1 port2
C1 port1 port2 5.14e-16
L2 port1 1 7.61e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 2.30e-8
R4 2 port2 104
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.20e-8
C7 5 6 1.52e-15
R7 6 port2 130
.ENDS LQG15HN1N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N1B02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 8.94e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 161
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 3.50e-8
C7 5 6 8.16e-17
R7 6 port2 46.1
.ENDS LQG15HN1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N1C02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 8.94e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 161
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 3.50e-8
C7 5 6 8.16e-17
R7 6 port2 46.1
.ENDS LQG15HN1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N1S02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N1S02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 8.94e-10
R2 1 port2 3.34e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 161
L5 port1 3 1.08e-8
R5 3 port2 5.92
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 3.50e-8
C7 5 6 8.16e-17
R7 6 port2 46.1
.ENDS LQG15HN1N1S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N2B02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 9.80e-10
R2 1 port2 1.60e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 165
L5 port1 3 1.16e-8
R5 3 port2 6.34
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.80e-10
C7 5 6 5.15e-14
R7 6 port2 2.91e-1
.ENDS LQG15HN1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N2C02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 9.80e-10
R2 1 port2 1.60e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 165
L5 port1 3 1.16e-8
R5 3 port2 6.34
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.80e-10
C7 5 6 5.15e-14
R7 6 port2 2.91e-1
.ENDS LQG15HN1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N2S02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N2S02 port1 port2
C1 port1 port2 4.08e-19
L2 port1 1 9.80e-10
R2 1 port2 1.60e-2
R3 port1 port2 2.73e+3
L4 port1 2 3.56e-8
R4 2 port2 165
L5 port1 3 1.16e-8
R5 3 port2 6.34
L6 port1 4 3.89e-7
R6 4 port2 71.4
L7 port1 5 8.80e-10
C7 5 6 5.15e-14
R7 6 port2 2.91e-1
.ENDS LQG15HN1N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N3B02 port1 port2
C1 port1 port2 5.26e-15
L2 port1 1 1.05e-9
R2 1 port2 2.91e-2
R3 port1 port2 3.28e+3
L4 port1 2 6.16e-8
R4 2 port2 338
L5 port1 3 1.99e-8
R5 3 port2 18.9
L6 port1 4 1.35e-7
R6 4 port2 48.3
L7 port1 5 8.98e-10
C7 5 6 5.18e-14
R7 6 port2 7.18e-1
.ENDS LQG15HN1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N3C02 port1 port2
C1 port1 port2 5.26e-15
L2 port1 1 1.05e-9
R2 1 port2 2.91e-2
R3 port1 port2 3.28e+3
L4 port1 2 6.16e-8
R4 2 port2 338
L5 port1 3 1.99e-8
R5 3 port2 18.9
L6 port1 4 1.35e-7
R6 4 port2 48.3
L7 port1 5 8.98e-10
C7 5 6 5.18e-14
R7 6 port2 7.18e-1
.ENDS LQG15HN1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N3S02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N3S02 port1 port2
C1 port1 port2 5.26e-15
L2 port1 1 1.05e-9
R2 1 port2 2.91e-2
R3 port1 port2 3.28e+3
L4 port1 2 6.16e-8
R4 2 port2 338
L5 port1 3 1.99e-8
R5 3 port2 18.9
L6 port1 4 1.35e-7
R6 4 port2 48.3
L7 port1 5 8.98e-10
C7 5 6 5.18e-14
R7 6 port2 7.18e-1
.ENDS LQG15HN1N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N5B02 port1 port2
C1 port1 port2 1.38e-14
L2 port1 1 1.26e-9
R2 1 port2 2.06e-2
R3 port1 port2 3.44e+3
L4 port1 2 3.89e-8
R4 2 port2 126
L5 port1 3 1.77e-8
R5 3 port2 8.06
L6 port1 4 4.38e-7
R6 4 port2 29.8
L7 port1 5 7.64e-10
C7 5 6 9.65e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N5C02 port1 port2
C1 port1 port2 1.38e-14
L2 port1 1 1.26e-9
R2 1 port2 2.06e-2
R3 port1 port2 3.44e+3
L4 port1 2 3.89e-8
R4 2 port2 126
L5 port1 3 1.77e-8
R5 3 port2 8.06
L6 port1 4 4.38e-7
R6 4 port2 29.8
L7 port1 5 7.64e-10
C7 5 6 9.65e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N5S02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N5S02 port1 port2
C1 port1 port2 1.38e-14
L2 port1 1 1.26e-9
R2 1 port2 2.06e-2
R3 port1 port2 3.44e+3
L4 port1 2 3.89e-8
R4 2 port2 126
L5 port1 3 1.77e-8
R5 3 port2 8.06
L6 port1 4 4.38e-7
R6 4 port2 29.8
L7 port1 5 7.64e-10
C7 5 6 9.65e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N5S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N6B02 port1 port2
C1 port1 port2 5.64e-16
L2 port1 1 1.35e-9
R2 1 port2 3.83e-2
R3 port1 port2 3.36e+3
L4 port1 2 3.63e-8
R4 2 port2 112
L5 port1 3 6.58e-8
R5 3 port2 24.9
L6 port1 4 2.35e-8
R6 4 port2 9.21
L7 port1 5 7.13e-10
C7 5 6 9.01e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N6C02 port1 port2
C1 port1 port2 5.64e-16
L2 port1 1 1.35e-9
R2 1 port2 3.83e-2
R3 port1 port2 3.36e+3
L4 port1 2 3.63e-8
R4 2 port2 112
L5 port1 3 6.58e-8
R5 3 port2 24.9
L6 port1 4 2.35e-8
R6 4 port2 9.21
L7 port1 5 7.13e-10
C7 5 6 9.01e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N6S02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N6S02 port1 port2
C1 port1 port2 5.64e-16
L2 port1 1 1.35e-9
R2 1 port2 3.83e-2
R3 port1 port2 3.36e+3
L4 port1 2 3.63e-8
R4 2 port2 112
L5 port1 3 6.58e-8
R5 3 port2 24.9
L6 port1 4 2.35e-8
R6 4 port2 9.21
L7 port1 5 7.13e-10
C7 5 6 9.01e-14
R7 6 port2 6.25e-1
.ENDS LQG15HN1N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N8B02 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 1.60e-9
R2 1 port2 3.19e-2
R3 port1 port2 3.95e+3
L4 port1 2 5.12e-8
R4 2 port2 209
L5 port1 3 2.33e-8
R5 3 port2 15.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 8.19e-10
C7 5 6 1.80e-13
R7 6 port2 9.90e-1
.ENDS LQG15HN1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N8C02 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 1.60e-9
R2 1 port2 3.19e-2
R3 port1 port2 3.95e+3
L4 port1 2 5.12e-8
R4 2 port2 209
L5 port1 3 2.33e-8
R5 3 port2 15.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 8.19e-10
C7 5 6 1.80e-13
R7 6 port2 9.90e-1
.ENDS LQG15HN1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN1N8S02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN1N8S02 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 1.60e-9
R2 1 port2 3.19e-2
R3 port1 port2 3.95e+3
L4 port1 2 5.12e-8
R4 2 port2 209
L5 port1 3 2.33e-8
R5 3 port2 15.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 8.19e-10
C7 5 6 1.80e-13
R7 6 port2 9.90e-1
.ENDS LQG15HN1N8S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN22NG02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN22NG02 port1 port2
C1 port1 port2 5.89e-14
L2 port1 1 2.63e-8
R2 1 port2 3.32e-1
R3 port1 port2 1.72e+4
L4 port1 2 4.16e-7
R4 2 port2 1.41e+3
L5 port1 3 2.08e-7
R5 3 port2 104
L6 port1 4 1.87e-7
R6 4 port2 19.7
L7 port1 5 1.26e-8
C7 5 6 1.03e-14
R7 6 port2 56.2
L8 port1 7 7.09e-10
C8 7 8 1.14e-13
R8 8 port2 9.39e-1
L9 port1 9 1.72e-8
C9 9 10 1.48e-14
R9 10 port2 31.3
.ENDS LQG15HN22NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN22NH02 port1 port2
C1 port1 port2 5.89e-14
L2 port1 1 2.63e-8
R2 1 port2 3.32e-1
R3 port1 port2 1.72e+4
L4 port1 2 4.16e-7
R4 2 port2 1.41e+3
L5 port1 3 2.08e-7
R5 3 port2 104
L6 port1 4 1.87e-7
R6 4 port2 19.7
L7 port1 5 1.26e-8
C7 5 6 1.03e-14
R7 6 port2 56.2
L8 port1 7 7.09e-10
C8 7 8 1.14e-13
R8 8 port2 9.39e-1
L9 port1 9 1.72e-8
C9 9 10 1.48e-14
R9 10 port2 31.3
.ENDS LQG15HN22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN22NJ02 port1 port2
C1 port1 port2 5.89e-14
L2 port1 1 2.63e-8
R2 1 port2 3.32e-1
R3 port1 port2 1.72e+4
L4 port1 2 4.16e-7
R4 2 port2 1.41e+3
L5 port1 3 2.08e-7
R5 3 port2 104
L6 port1 4 1.87e-7
R6 4 port2 19.7
L7 port1 5 1.26e-8
C7 5 6 1.03e-14
R7 6 port2 56.2
L8 port1 7 7.09e-10
C8 7 8 1.14e-13
R8 8 port2 9.39e-1
L9 port1 9 1.72e-8
C9 9 10 1.48e-14
R9 10 port2 31.3
.ENDS LQG15HN22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN27NG02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN27NG02 port1 port2
C1 port1 port2 4.79e-14
L2 port1 1 3.24e-8
R2 1 port2 4.18e-1
R3 port1 port2 6.26e+4
L4 port1 2 4.16e-7
R4 2 port2 1.58e+3
L5 port1 3 2.75e-7
R5 3 port2 143
L6 port1 4 2.25e-7
R6 4 port2 27.2
L7 port1 5 1.29e-8
C7 5 6 1.05e-14
R7 6 port2 64.5
L8 port1 7 2.40e-9
C8 7 8 3.85e-14
R8 8 port2 4.10
L9 port1 9 8.40e-9
C9 9 10 3.63e-14
R9 10 port2 25.4
L10 port1 11 8.66e-10
C10 11 12 7.75e-14
R10 12 port2 1.47
.ENDS LQG15HN27NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN27NH02 port1 port2
C1 port1 port2 4.79e-14
L2 port1 1 3.24e-8
R2 1 port2 4.18e-1
R3 port1 port2 6.26e+4
L4 port1 2 4.16e-7
R4 2 port2 1.58e+3
L5 port1 3 2.75e-7
R5 3 port2 143
L6 port1 4 2.25e-7
R6 4 port2 27.2
L7 port1 5 1.29e-8
C7 5 6 1.05e-14
R7 6 port2 64.5
L8 port1 7 2.40e-9
C8 7 8 3.85e-14
R8 8 port2 4.10
L9 port1 9 8.40e-9
C9 9 10 3.63e-14
R9 10 port2 25.4
L10 port1 11 8.66e-10
C10 11 12 7.75e-14
R10 12 port2 1.47
.ENDS LQG15HN27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN27NJ02 port1 port2
C1 port1 port2 4.79e-14
L2 port1 1 3.24e-8
R2 1 port2 4.18e-1
R3 port1 port2 6.26e+4
L4 port1 2 4.16e-7
R4 2 port2 1.58e+3
L5 port1 3 2.75e-7
R5 3 port2 143
L6 port1 4 2.25e-7
R6 4 port2 27.2
L7 port1 5 1.29e-8
C7 5 6 1.05e-14
R7 6 port2 64.5
L8 port1 7 2.40e-9
C8 7 8 3.85e-14
R8 8 port2 4.10
L9 port1 9 8.40e-9
C9 9 10 3.63e-14
R9 10 port2 25.4
L10 port1 11 8.66e-10
C10 11 12 7.75e-14
R10 12 port2 1.47
.ENDS LQG15HN27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N0B02 port1 port2
C1 port1 port2 1.18e-14
L2 port1 1 1.81e-9
R2 1 port2 5.80e-2
R3 port1 port2 4.04e+3
L4 port1 2 6.91e-8
R4 2 port2 282
L5 port1 3 2.18e-8
R5 3 port2 14.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 6.10e-10
C7 5 6 1.05e-13
R7 6 port2 8.64e-2
L8 port1 7 6.66e-8
C8 7 8 1.84e-15
R8 8 port2 193
.ENDS LQG15HN2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N0C02 port1 port2
C1 port1 port2 1.18e-14
L2 port1 1 1.81e-9
R2 1 port2 5.80e-2
R3 port1 port2 4.04e+3
L4 port1 2 6.91e-8
R4 2 port2 282
L5 port1 3 2.18e-8
R5 3 port2 14.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 6.10e-10
C7 5 6 1.05e-13
R7 6 port2 8.64e-2
L8 port1 7 6.66e-8
C8 7 8 1.84e-15
R8 8 port2 193
.ENDS LQG15HN2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N0S02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N0S02 port1 port2
C1 port1 port2 1.18e-14
L2 port1 1 1.81e-9
R2 1 port2 5.80e-2
R3 port1 port2 4.04e+3
L4 port1 2 6.91e-8
R4 2 port2 282
L5 port1 3 2.18e-8
R5 3 port2 14.0
L6 port1 4 7.27e-8
R6 4 port2 16.4
L7 port1 5 6.10e-10
C7 5 6 1.05e-13
R7 6 port2 8.64e-2
L8 port1 7 6.66e-8
C8 7 8 1.84e-15
R8 8 port2 193
.ENDS LQG15HN2N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N2B02 port1 port2
C1 port1 port2 5.51e-15
L2 port1 1 2.13e-9
R2 1 port2 4.61e-2
R3 port1 port2 4.97e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 2.68e-8
R5 3 port2 17.2
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 8.04e-10
C7 5 6 1.20e-13
R7 6 port2 4.86e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 58.3
.ENDS LQG15HN2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N2C02 port1 port2
C1 port1 port2 5.51e-15
L2 port1 1 2.13e-9
R2 1 port2 4.61e-2
R3 port1 port2 4.97e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 2.68e-8
R5 3 port2 17.2
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 8.04e-10
C7 5 6 1.20e-13
R7 6 port2 4.86e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 58.3
.ENDS LQG15HN2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N2S02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N2S02 port1 port2
C1 port1 port2 5.51e-15
L2 port1 1 2.13e-9
R2 1 port2 4.61e-2
R3 port1 port2 4.97e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 2.68e-8
R5 3 port2 17.2
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 8.04e-10
C7 5 6 1.20e-13
R7 6 port2 4.86e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 58.3
.ENDS LQG15HN2N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N4B02 port1 port2
C1 port1 port2 2.64e-14
L2 port1 1 2.36e-9
R2 1 port2 3.92e-2
R3 port1 port2 5.20e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 3.01e-8
R5 3 port2 19.3
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 7.68e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 24.3
.ENDS LQG15HN2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N4C02 port1 port2
C1 port1 port2 2.64e-14
L2 port1 1 2.36e-9
R2 1 port2 3.92e-2
R3 port1 port2 5.20e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 3.01e-8
R5 3 port2 19.3
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 7.68e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 24.3
.ENDS LQG15HN2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N4S02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N4S02 port1 port2
C1 port1 port2 2.64e-14
L2 port1 1 2.36e-9
R2 1 port2 3.92e-2
R3 port1 port2 5.20e+3
L4 port1 2 6.60e-8
R4 2 port2 282
L5 port1 3 3.01e-8
R5 3 port2 19.3
L6 port1 4 3.73e-8
R6 4 port2 7.15
L7 port1 5 7.68e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 8.19e-9
C8 7 8 1.64e-14
R8 8 port2 24.3
.ENDS LQG15HN2N4S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N7B02 port1 port2
C1 port1 port2 1.45e-16
L2 port1 1 2.65e-9
R2 1 port2 4.20e-2
R3 port1 port2 6.11e+3
L4 port1 2 6.45e-8
R4 2 port2 240
L5 port1 3 3.79e-8
R5 3 port2 24.3
L6 port1 4 3.40e-8
R6 4 port2 5.06
L7 port1 5 1.06e-9
C7 5 6 6.31e-14
R7 6 port2 7.52
L8 port1 7 8.19e-10
C8 7 8 1.64e-13
R8 8 port2 2.43
.ENDS LQG15HN2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N7C02 port1 port2
C1 port1 port2 1.45e-16
L2 port1 1 2.65e-9
R2 1 port2 4.20e-2
R3 port1 port2 6.11e+3
L4 port1 2 6.45e-8
R4 2 port2 240
L5 port1 3 3.79e-8
R5 3 port2 24.3
L6 port1 4 3.40e-8
R6 4 port2 5.06
L7 port1 5 1.06e-9
C7 5 6 6.31e-14
R7 6 port2 7.52
L8 port1 7 8.19e-10
C8 7 8 1.64e-13
R8 8 port2 2.43
.ENDS LQG15HN2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN2N7S02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN2N7S02 port1 port2
C1 port1 port2 1.45e-16
L2 port1 1 2.65e-9
R2 1 port2 4.20e-2
R3 port1 port2 6.11e+3
L4 port1 2 6.45e-8
R4 2 port2 240
L5 port1 3 3.79e-8
R5 3 port2 24.3
L6 port1 4 3.40e-8
R6 4 port2 5.06
L7 port1 5 1.06e-9
C7 5 6 6.31e-14
R7 6 port2 7.52
L8 port1 7 8.19e-10
C8 7 8 1.64e-13
R8 8 port2 2.43
.ENDS LQG15HN2N7S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN33NG02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN33NG02 port1 port2
C1 port1 port2 1.55e-14
L2 port1 1 3.98e-8
R2 1 port2 4.48e-1
R3 port1 port2 4.23e+4
L4 port1 2 5.36e-7
R4 2 port2 1.86e+3
L5 port1 3 3.46e-7
R5 3 port2 168
L6 port1 4 2.52e-7
R6 4 port2 30.5
L7 port1 5 2.95e-9
C7 5 6 4.59e-14
R7 6 port2 13.8
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 1.46e-8
C9 9 10 2.63e-14
R9 10 port2 39.4
L10 port1 11 6.57e-10
C10 11 12 1.07e-13
R10 12 port2 1.37
.ENDS LQG15HN33NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN33NH02 port1 port2
C1 port1 port2 1.55e-14
L2 port1 1 3.98e-8
R2 1 port2 4.48e-1
R3 port1 port2 4.23e+4
L4 port1 2 5.36e-7
R4 2 port2 1.86e+3
L5 port1 3 3.46e-7
R5 3 port2 168
L6 port1 4 2.52e-7
R6 4 port2 30.5
L7 port1 5 2.95e-9
C7 5 6 4.59e-14
R7 6 port2 13.8
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 1.46e-8
C9 9 10 2.63e-14
R9 10 port2 39.4
L10 port1 11 6.57e-10
C10 11 12 1.07e-13
R10 12 port2 1.37
.ENDS LQG15HN33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN33NJ02 port1 port2
C1 port1 port2 1.55e-14
L2 port1 1 3.98e-8
R2 1 port2 4.48e-1
R3 port1 port2 4.23e+4
L4 port1 2 5.36e-7
R4 2 port2 1.86e+3
L5 port1 3 3.46e-7
R5 3 port2 168
L6 port1 4 2.52e-7
R6 4 port2 30.5
L7 port1 5 2.95e-9
C7 5 6 4.59e-14
R7 6 port2 13.8
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 1.46e-8
C9 9 10 2.63e-14
R9 10 port2 39.4
L10 port1 11 6.57e-10
C10 11 12 1.07e-13
R10 12 port2 1.37
.ENDS LQG15HN33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN39NG02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN39NG02 port1 port2
C1 port1 port2 3.16e-14
L2 port1 1 4.79e-8
R2 1 port2 5.26e-1
R3 port1 port2 4.63e+4
L4 port1 2 6.01e-7
R4 2 port2 1.90e+3
L5 port1 3 4.26e-7
R5 3 port2 211
L6 port1 4 2.63e-7
R6 4 port2 29.1
L7 port1 5 4.57e-9
C7 5 6 3.41e-14
R7 6 port2 20.0
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 2.31e-8
C9 9 10 2.09e-14
R9 10 port2 55.7
L10 port1 11 6.87e-10
C10 11 12 1.12e-13
R10 12 port2 1.54
.ENDS LQG15HN39NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN39NH02 port1 port2
C1 port1 port2 3.16e-14
L2 port1 1 4.79e-8
R2 1 port2 5.26e-1
R3 port1 port2 4.63e+4
L4 port1 2 6.01e-7
R4 2 port2 1.90e+3
L5 port1 3 4.26e-7
R5 3 port2 211
L6 port1 4 2.63e-7
R6 4 port2 29.1
L7 port1 5 4.57e-9
C7 5 6 3.41e-14
R7 6 port2 20.0
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 2.31e-8
C9 9 10 2.09e-14
R9 10 port2 55.7
L10 port1 11 6.87e-10
C10 11 12 1.12e-13
R10 12 port2 1.54
.ENDS LQG15HN39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN39NJ02 port1 port2
C1 port1 port2 3.16e-14
L2 port1 1 4.79e-8
R2 1 port2 5.26e-1
R3 port1 port2 4.63e+4
L4 port1 2 6.01e-7
R4 2 port2 1.90e+3
L5 port1 3 4.26e-7
R5 3 port2 211
L6 port1 4 2.63e-7
R6 4 port2 29.1
L7 port1 5 4.57e-9
C7 5 6 3.41e-14
R7 6 port2 20.0
L8 port1 7 4.58e-9
C8 7 8 1.93e-14
R8 8 port2 30.4
L9 port1 9 2.31e-8
C9 9 10 2.09e-14
R9 10 port2 55.7
L10 port1 11 6.87e-10
C10 11 12 1.12e-13
R10 12 port2 1.54
.ENDS LQG15HN39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N0B02 port1 port2
C1 port1 port2 9.55e-15
L2 port1 1 2.99e-9
R2 1 port2 7.47e-2
R3 port1 port2 6.11e+3
L4 port1 2 7.41e-8
R4 2 port2 275
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 6.17e-14
R7 6 port2 6.25e-1
L8 port1 7 9.19e-8
C8 7 8 1.39e-15
R8 8 port2 441
.ENDS LQG15HN3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N0C02 port1 port2
C1 port1 port2 9.55e-15
L2 port1 1 2.99e-9
R2 1 port2 7.47e-2
R3 port1 port2 6.11e+3
L4 port1 2 7.41e-8
R4 2 port2 275
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 6.17e-14
R7 6 port2 6.25e-1
L8 port1 7 9.19e-8
C8 7 8 1.39e-15
R8 8 port2 441
.ENDS LQG15HN3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N0S02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N0S02 port1 port2
C1 port1 port2 9.55e-15
L2 port1 1 2.99e-9
R2 1 port2 7.47e-2
R3 port1 port2 6.11e+3
L4 port1 2 7.41e-8
R4 2 port2 275
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 6.17e-14
R7 6 port2 6.25e-1
L8 port1 7 9.19e-8
C8 7 8 1.39e-15
R8 8 port2 441
.ENDS LQG15HN3N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N3B02 port1 port2
C1 port1 port2 1.51e-14
L2 port1 1 3.43e-9
R2 1 port2 8.19e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.12e-8
R4 2 port2 331
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 7.42e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 279
.ENDS LQG15HN3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N3C02 port1 port2
C1 port1 port2 1.51e-14
L2 port1 1 3.43e-9
R2 1 port2 8.19e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.12e-8
R4 2 port2 331
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 7.42e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 279
.ENDS LQG15HN3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N3S02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N3S02 port1 port2
C1 port1 port2 1.51e-14
L2 port1 1 3.43e-9
R2 1 port2 8.19e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.12e-8
R4 2 port2 331
L5 port1 3 4.26e-8
R5 3 port2 27.2
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.15e-10
C7 5 6 7.42e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 279
.ENDS LQG15HN3N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N6B02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 3.68e-9
R2 1 port2 9.62e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.77e-8
R4 2 port2 380
L5 port1 3 4.56e-8
R5 3 port2 28.5
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.49e-10
C7 5 6 7.77e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 232
.ENDS LQG15HN3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N6C02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 3.68e-9
R2 1 port2 9.62e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.77e-8
R4 2 port2 380
L5 port1 3 4.56e-8
R5 3 port2 28.5
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.49e-10
C7 5 6 7.77e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 232
.ENDS LQG15HN3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N6S02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N6S02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 3.68e-9
R2 1 port2 9.62e-2
R3 port1 port2 6.26e+3
L4 port1 2 9.77e-8
R4 2 port2 380
L5 port1 3 4.56e-8
R5 3 port2 28.5
L6 port1 4 4.28e-8
R6 4 port2 6.37
L7 port1 5 7.49e-10
C7 5 6 7.77e-14
R7 6 port2 8.44e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 232
.ENDS LQG15HN3N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N9B02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 4.13e-9
R2 1 port2 8.00e-2
R3 port1 port2 6.26e+3
L4 port1 2 1.05e-7
R4 2 port2 407
L5 port1 3 4.78e-8
R5 3 port2 29.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 6.37e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 46.2
.ENDS LQG15HN3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N9C02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 4.13e-9
R2 1 port2 8.00e-2
R3 port1 port2 6.26e+3
L4 port1 2 1.05e-7
R4 2 port2 407
L5 port1 3 4.78e-8
R5 3 port2 29.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 6.37e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 46.2
.ENDS LQG15HN3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN3N9S02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN3N9S02 port1 port2
C1 port1 port2 1.66e-14
L2 port1 1 4.13e-9
R2 1 port2 8.00e-2
R3 port1 port2 6.26e+3
L4 port1 2 1.05e-7
R4 2 port2 407
L5 port1 3 4.78e-8
R5 3 port2 29.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 6.37e-10
C7 5 6 1.38e-13
R7 6 port2 4.43e-1
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 46.2
.ENDS LQG15HN3N9S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN47NG02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN47NG02 port1 port2
C1 port1 port2 1.26e-14
L2 port1 1 5.85e-8
R2 1 port2 5.38e-1
R3 port1 port2 5.70e+4
L4 port1 2 7.06e-7
R4 2 port2 2.28e+3
L5 port1 3 5.01e-7
R5 3 port2 248
L6 port1 4 2.76e-7
R6 4 port2 29.1
L7 port1 5 8.14e-9
C7 5 6 2.01e-14
R7 6 port2 34.8
L8 port1 7 5.38e-9
C8 7 8 2.27e-14
R8 8 port2 30.4
L9 port1 9 4.20e-8
C9 9 10 1.45e-14
R9 10 port2 90.3
L10 port1 11 9.06e-10
C10 11 12 9.74e-14
R10 12 port2 3.78
L11 port1 13 1.05e-9
C11 13 14 6.41e-14
R11 14 port2 2.12
.ENDS LQG15HN47NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN47NH02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN47NH02 port1 port2
C1 port1 port2 1.26e-14
L2 port1 1 5.85e-8
R2 1 port2 5.38e-1
R3 port1 port2 5.70e+4
L4 port1 2 7.06e-7
R4 2 port2 2.28e+3
L5 port1 3 5.01e-7
R5 3 port2 248
L6 port1 4 2.76e-7
R6 4 port2 29.1
L7 port1 5 8.14e-9
C7 5 6 2.01e-14
R7 6 port2 34.8
L8 port1 7 5.38e-9
C8 7 8 2.27e-14
R8 8 port2 30.4
L9 port1 9 4.20e-8
C9 9 10 1.45e-14
R9 10 port2 90.3
L10 port1 11 9.06e-10
C10 11 12 9.74e-14
R10 12 port2 3.78
L11 port1 13 1.05e-9
C11 13 14 6.41e-14
R11 14 port2 2.12
.ENDS LQG15HN47NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN47NJ02 port1 port2
C1 port1 port2 1.26e-14
L2 port1 1 5.85e-8
R2 1 port2 5.38e-1
R3 port1 port2 5.70e+4
L4 port1 2 7.06e-7
R4 2 port2 2.28e+3
L5 port1 3 5.01e-7
R5 3 port2 248
L6 port1 4 2.76e-7
R6 4 port2 29.1
L7 port1 5 8.14e-9
C7 5 6 2.01e-14
R7 6 port2 34.8
L8 port1 7 5.38e-9
C8 7 8 2.27e-14
R8 8 port2 30.4
L9 port1 9 4.20e-8
C9 9 10 1.45e-14
R9 10 port2 90.3
L10 port1 11 9.06e-10
C10 11 12 9.74e-14
R10 12 port2 3.78
L11 port1 13 1.05e-9
C11 13 14 6.41e-14
R11 14 port2 2.12
.ENDS LQG15HN47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N3B02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N3B02 port1 port2
C1 port1 port2 3.31e-14
L2 port1 1 4.53e-9
R2 1 port2 1.05e-1
R3 port1 port2 7.02e+3
L4 port1 2 1.32e-7
R4 2 port2 549
L5 port1 3 4.46e-8
R5 3 port2 27.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 1.13e-9
C7 5 6 4.90e-14
R7 6 port2 1.09
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 221
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N3C02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N3C02 port1 port2
C1 port1 port2 3.31e-14
L2 port1 1 4.53e-9
R2 1 port2 1.05e-1
R3 port1 port2 7.02e+3
L4 port1 2 1.32e-7
R4 2 port2 549
L5 port1 3 4.46e-8
R5 3 port2 27.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 1.13e-9
C7 5 6 4.90e-14
R7 6 port2 1.09
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 221
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N3S02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N3S02 port1 port2
C1 port1 port2 3.31e-14
L2 port1 1 4.53e-9
R2 1 port2 1.05e-1
R3 port1 port2 7.02e+3
L4 port1 2 1.32e-7
R4 2 port2 549
L5 port1 3 4.46e-8
R5 3 port2 27.9
L6 port1 4 5.15e-8
R6 4 port2 5.55
L7 port1 5 1.13e-9
C7 5 6 4.90e-14
R7 6 port2 1.09
L8 port1 7 6.97e-8
C8 7 8 1.84e-15
R8 8 port2 221
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N7B02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N7B02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.08e-9
R2 1 port2 1.13e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.36e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 6.99e-10
C7 5 6 7.59e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N7C02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N7C02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.08e-9
R2 1 port2 1.13e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.36e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 6.99e-10
C7 5 6 7.59e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN4N7S02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN4N7S02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.08e-9
R2 1 port2 1.13e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.36e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 6.99e-10
C7 5 6 7.59e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
L9 port1 9 7.17e-8
C9 9 10 1.24e-15
R9 10 port2 136
.ENDS LQG15HN4N7S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN56NG02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN56NG02 port1 port2
C1 port1 port2 4.57e-14
L2 port1 1 7.20e-8
R2 1 port2 6.47e-1
R3 port1 port2 5.70e+4
L4 port1 2 8.11e-7
R4 2 port2 2.56e+3
L5 port1 3 6.02e-7
R5 3 port2 298
L6 port1 4 3.39e-7
R6 4 port2 34.2
L7 port1 5 2.89e-8
C7 5 6 8.17e-15
R7 6 port2 103
L8 port1 7 5.02e-9
C8 7 8 2.12e-14
R8 8 port2 30.4
L9 port1 9 6.21e-8
C9 9 10 1.23e-14
R9 10 port2 119
L10 port1 11 5.10e-10
C10 11 12 1.51e-13
R10 12 port2 1.14
.ENDS LQG15HN56NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN56NH02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN56NH02 port1 port2
C1 port1 port2 4.57e-14
L2 port1 1 7.20e-8
R2 1 port2 6.47e-1
R3 port1 port2 5.70e+4
L4 port1 2 8.11e-7
R4 2 port2 2.56e+3
L5 port1 3 6.02e-7
R5 3 port2 298
L6 port1 4 3.39e-7
R6 4 port2 34.2
L7 port1 5 2.89e-8
C7 5 6 8.17e-15
R7 6 port2 103
L8 port1 7 5.02e-9
C8 7 8 2.12e-14
R8 8 port2 30.4
L9 port1 9 6.21e-8
C9 9 10 1.23e-14
R9 10 port2 119
L10 port1 11 5.10e-10
C10 11 12 1.51e-13
R10 12 port2 1.14
.ENDS LQG15HN56NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN56NJ02 port1 port2
C1 port1 port2 4.57e-14
L2 port1 1 7.20e-8
R2 1 port2 6.47e-1
R3 port1 port2 5.70e+4
L4 port1 2 8.11e-7
R4 2 port2 2.56e+3
L5 port1 3 6.02e-7
R5 3 port2 298
L6 port1 4 3.39e-7
R6 4 port2 34.2
L7 port1 5 2.89e-8
C7 5 6 8.17e-15
R7 6 port2 103
L8 port1 7 5.02e-9
C8 7 8 2.12e-14
R8 8 port2 30.4
L9 port1 9 6.21e-8
C9 9 10 1.23e-14
R9 10 port2 119
L10 port1 11 5.10e-10
C10 11 12 1.51e-13
R10 12 port2 1.14
.ENDS LQG15HN56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N1B02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N1B02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.45e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.61e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 7.84e-10
C7 5 6 8.51e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
.ENDS LQG15HN5N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N1C02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N1C02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.45e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.61e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 7.84e-10
C7 5 6 8.51e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
.ENDS LQG15HN5N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N1S02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N1S02 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 5.45e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.38e-7
R4 2 port2 575
L5 port1 3 5.61e-8
R5 3 port2 33.5
L6 port1 4 6.19e-8
R6 4 port2 6.67
L7 port1 5 7.84e-10
C7 5 6 8.51e-14
R7 6 port2 2.73
L8 port1 7 5.17e-8
C8 7 8 2.48e-15
R8 8 port2 164
.ENDS LQG15HN5N1S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N6B02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N6B02 port1 port2
C1 port1 port2 6.61e-15
L2 port1 1 6.11e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.01e-8
R5 3 port2 33.5
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 5.08e-1
L8 port1 7 2.71e-8
C8 7 8 4.52e-15
R8 8 port2 88.2
.ENDS LQG15HN5N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N6C02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N6C02 port1 port2
C1 port1 port2 6.61e-15
L2 port1 1 6.11e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.01e-8
R5 3 port2 33.5
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 5.08e-1
L8 port1 7 2.71e-8
C8 7 8 4.52e-15
R8 8 port2 88.2
.ENDS LQG15HN5N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN5N6S02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN5N6S02 port1 port2
C1 port1 port2 6.61e-15
L2 port1 1 6.11e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.01e-8
R5 3 port2 33.5
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 5.08e-1
L8 port1 7 2.71e-8
C8 7 8 4.52e-15
R8 8 port2 88.2
.ENDS LQG15HN5N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN68NG02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN68NG02 port1 port2
C1 port1 port2 2.34e-14
L2 port1 1 8.86e-8
R2 1 port2 7.26e-1
R3 port1 port2 2.79e+5
L4 port1 2 9.10e-7
R4 2 port2 2.87e+3
L5 port1 3 7.40e-7
R5 3 port2 359
L6 port1 4 3.81e-7
R6 4 port2 37.5
L7 port1 5 4.27e-8
C7 5 6 7.28e-15
R7 6 port2 132
L8 port1 7 6.03e-9
C8 7 8 2.22e-14
R8 8 port2 32.5
L9 port1 9 7.13e-8
C9 9 10 1.41e-14
R9 10 port2 119
L10 port1 11 5.34e-10
C10 11 12 1.58e-13
R10 12 port2 1.73
L11 port1 13 2.65e-9
C11 13 14 2.78e-14
R11 14 port2 2.36
.ENDS LQG15HN68NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN68NH02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN68NH02 port1 port2
C1 port1 port2 2.34e-14
L2 port1 1 8.86e-8
R2 1 port2 7.26e-1
R3 port1 port2 2.79e+5
L4 port1 2 9.10e-7
R4 2 port2 2.87e+3
L5 port1 3 7.40e-7
R5 3 port2 359
L6 port1 4 3.81e-7
R6 4 port2 37.5
L7 port1 5 4.27e-8
C7 5 6 7.28e-15
R7 6 port2 132
L8 port1 7 6.03e-9
C8 7 8 2.22e-14
R8 8 port2 32.5
L9 port1 9 7.13e-8
C9 9 10 1.41e-14
R9 10 port2 119
L10 port1 11 5.34e-10
C10 11 12 1.58e-13
R10 12 port2 1.73
L11 port1 13 2.65e-9
C11 13 14 2.78e-14
R11 14 port2 2.36
.ENDS LQG15HN68NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN68NJ02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN68NJ02 port1 port2
C1 port1 port2 2.34e-14
L2 port1 1 8.86e-8
R2 1 port2 7.26e-1
R3 port1 port2 2.79e+5
L4 port1 2 9.10e-7
R4 2 port2 2.87e+3
L5 port1 3 7.40e-7
R5 3 port2 359
L6 port1 4 3.81e-7
R6 4 port2 37.5
L7 port1 5 4.27e-8
C7 5 6 7.28e-15
R7 6 port2 132
L8 port1 7 6.03e-9
C8 7 8 2.22e-14
R8 8 port2 32.5
L9 port1 9 7.13e-8
C9 9 10 1.41e-14
R9 10 port2 119
L10 port1 11 5.34e-10
C10 11 12 1.58e-13
R10 12 port2 1.73
L11 port1 13 2.65e-9
C11 13 14 2.78e-14
R11 14 port2 2.36
.ENDS LQG15HN68NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N2B02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N2B02 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 6.74e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.59e-8
R5 3 port2 36.8
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N2C02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N2C02 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 6.74e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.59e-8
R5 3 port2 36.8
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N2S02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N2S02 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 6.74e-9
R2 1 port2 1.35e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.38e-7
R4 2 port2 512
L5 port1 3 6.59e-8
R5 3 port2 36.8
L6 port1 4 7.97e-8
R6 4 port2 8.80
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N8G02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N8G02 port1 port2
C1 port1 port2 3.02e-14
L2 port1 1 7.22e-9
R2 1 port2 1.52e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.51e-7
R4 2 port2 536
L5 port1 3 7.06e-8
R5 3 port2 35.1
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N8G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N8H02 port1 port2
C1 port1 port2 3.02e-14
L2 port1 1 7.22e-9
R2 1 port2 1.52e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.51e-7
R4 2 port2 536
L5 port1 3 7.06e-8
R5 3 port2 35.1
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN6N8J02 port1 port2
C1 port1 port2 3.02e-14
L2 port1 1 7.22e-9
R2 1 port2 1.52e-1
R3 port1 port2 8.06e+3
L4 port1 2 1.51e-7
R4 2 port2 536
L5 port1 3 7.06e-8
R5 3 port2 35.1
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 6.83e-10
C7 5 6 1.35e-13
R7 6 port2 1.61
L8 port1 7 2.84e-8
C8 7 8 4.73e-15
R8 8 port2 55.7
.ENDS LQG15HN6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN7N5G02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN7N5G02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.11e-9
R2 1 port2 1.70e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.82e-7
R4 2 port2 645
L5 port1 3 6.90e-8
R5 3 port2 34.3
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 9.03e-1
L8 port1 7 5.31e-8
C8 7 8 3.83e-15
R8 8 port2 45.0
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN7N5G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN7N5H02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.11e-9
R2 1 port2 1.70e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.82e-7
R4 2 port2 645
L5 port1 3 6.90e-8
R5 3 port2 34.3
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 9.03e-1
L8 port1 7 5.31e-8
C8 7 8 3.83e-15
R8 8 port2 45.0
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN7N5J02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.11e-9
R2 1 port2 1.70e-1
R3 port1 port2 8.44e+3
L4 port1 2 1.82e-7
R4 2 port2 645
L5 port1 3 6.90e-8
R5 3 port2 34.3
L6 port1 4 1.07e-7
R6 4 port2 11.3
L7 port1 5 5.81e-10
C7 5 6 1.15e-13
R7 6 port2 9.03e-1
L8 port1 7 5.31e-8
C8 7 8 3.83e-15
R8 8 port2 45.0
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN82NG02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN82NG02 port1 port2
C1 port1 port2 3.31e-15
L2 port1 1 1.04e-7
R2 1 port2 9.14e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.12e-6
R4 2 port2 3.22e+3
L5 port1 3 8.70e-7
R5 3 port2 422
L6 port1 4 4.58e-7
R6 4 port2 44.0
L7 port1 5 3.72e-8
C7 5 6 1.05e-14
R7 6 port2 103
L8 port1 7 7.09e-9
C8 7 8 2.49e-14
R8 8 port2 33.3
L9 port1 9 7.82e-8
C9 9 10 1.55e-14
R9 10 port2 119
L10 port1 11 1.25e-9
C10 11 12 8.48e-14
R10 12 port2 5.73
L11 port1 13 5.23e-10
C11 13 14 1.62e-13
R11 14 port2 1.32
.ENDS LQG15HN82NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN82NH02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN82NH02 port1 port2
C1 port1 port2 3.31e-15
L2 port1 1 1.04e-7
R2 1 port2 9.14e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.12e-6
R4 2 port2 3.22e+3
L5 port1 3 8.70e-7
R5 3 port2 422
L6 port1 4 4.58e-7
R6 4 port2 44.0
L7 port1 5 3.72e-8
C7 5 6 1.05e-14
R7 6 port2 103
L8 port1 7 7.09e-9
C8 7 8 2.49e-14
R8 8 port2 33.3
L9 port1 9 7.82e-8
C9 9 10 1.55e-14
R9 10 port2 119
L10 port1 11 1.25e-9
C10 11 12 8.48e-14
R10 12 port2 5.73
L11 port1 13 5.23e-10
C11 13 14 1.62e-13
R11 14 port2 1.32
.ENDS LQG15HN82NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN82NJ02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN82NJ02 port1 port2
C1 port1 port2 3.31e-15
L2 port1 1 1.04e-7
R2 1 port2 9.14e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.12e-6
R4 2 port2 3.22e+3
L5 port1 3 8.70e-7
R5 3 port2 422
L6 port1 4 4.58e-7
R6 4 port2 44.0
L7 port1 5 3.72e-8
C7 5 6 1.05e-14
R7 6 port2 103
L8 port1 7 7.09e-9
C8 7 8 2.49e-14
R8 8 port2 33.3
L9 port1 9 7.82e-8
C9 9 10 1.55e-14
R9 10 port2 119
L10 port1 11 1.25e-9
C10 11 12 8.48e-14
R10 12 port2 5.73
L11 port1 13 5.23e-10
C11 13 14 1.62e-13
R11 14 port2 1.32
.ENDS LQG15HN82NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN8N2G02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN8N2G02 port1 port2
C1 port1 port2 1.62e-14
L2 port1 1 9.35e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.01e+4
L4 port1 2 1.86e-7
R4 2 port2 724
L5 port1 3 7.57e-8
R5 3 port2 37.6
L6 port1 4 1.03e-7
R6 4 port2 10.1
L7 port1 5 6.52e-10
C7 5 6 1.29e-13
R7 6 port2 9.03e-1
L8 port1 7 1.13e-7
C8 7 8 1.56e-15
R8 8 port2 1.03e+3
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN8N2G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN8N2H02 port1 port2
C1 port1 port2 1.62e-14
L2 port1 1 9.35e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.01e+4
L4 port1 2 1.86e-7
R4 2 port2 724
L5 port1 3 7.57e-8
R5 3 port2 37.6
L6 port1 4 1.03e-7
R6 4 port2 10.1
L7 port1 5 6.52e-10
C7 5 6 1.29e-13
R7 6 port2 9.03e-1
L8 port1 7 1.13e-7
C8 7 8 1.56e-15
R8 8 port2 1.03e+3
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN8N2J02 port1 port2
C1 port1 port2 1.62e-14
L2 port1 1 9.35e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.01e+4
L4 port1 2 1.86e-7
R4 2 port2 724
L5 port1 3 7.57e-8
R5 3 port2 37.6
L6 port1 4 1.03e-7
R6 4 port2 10.1
L7 port1 5 6.52e-10
C7 5 6 1.29e-13
R7 6 port2 9.03e-1
L8 port1 7 1.13e-7
C8 7 8 1.56e-15
R8 8 port2 1.03e+3
L9 port1 9 5.29e-8
C9 9 10 2.54e-15
R9 10 port2 101
.ENDS LQG15HN8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN9N1G02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN9N1G02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.02e-8
R2 1 port2 1.70e-1
R3 port1 port2 9.25e+3
L4 port1 2 1.95e-7
R4 2 port2 675
L5 port1 3 8.69e-8
R5 3 port2 43.2
L6 port1 4 9.36e-8
R6 4 port2 9.00
L7 port1 5 8.40e-10
C7 5 6 1.20e-13
R7 6 port2 1.30
L8 port1 7 3.12e-8
C8 7 8 5.67e-15
R8 8 port2 220
.ENDS LQG15HN9N1G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN9N1H02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.02e-8
R2 1 port2 1.70e-1
R3 port1 port2 9.25e+3
L4 port1 2 1.95e-7
R4 2 port2 675
L5 port1 3 8.69e-8
R5 3 port2 43.2
L6 port1 4 9.36e-8
R6 4 port2 9.00
L7 port1 5 8.40e-10
C7 5 6 1.20e-13
R7 6 port2 1.30
L8 port1 7 3.12e-8
C8 7 8 5.67e-15
R8 8 port2 220
.ENDS LQG15HN9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HN9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HN9N1J02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.02e-8
R2 1 port2 1.70e-1
R3 port1 port2 9.25e+3
L4 port1 2 1.95e-7
R4 2 port2 675
L5 port1 3 8.69e-8
R5 3 port2 43.2
L6 port1 4 9.36e-8
R6 4 port2 9.00
L7 port1 5 8.40e-10
C7 5 6 1.20e-13
R7 6 port2 1.30
L8 port1 7 3.12e-8
C8 7 8 5.67e-15
R8 8 port2 220
.ENDS LQG15HN9N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR10G02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR10G02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.28e-7
R2 1 port2 9.57e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.26e-6
R4 2 port2 3.62e+3
L5 port1 3 9.54e-7
R5 3 port2 462
L6 port1 4 4.79e-7
R6 4 port2 46.1
L7 port1 5 8.32e-8
C7 5 6 6.20e-15
R7 6 port2 200
L8 port1 7 3.39e-8
C8 7 8 7.18e-15
R8 8 port2 136
L9 port1 9 1.36e-7
C9 9 10 1.18e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 6.15e-10
C11 13 14 1.38e-13
R11 14 port2 2.76
L12 port1 15 1.02e-9
C12 15 16 1.00e-13
R12 16 port2 2.44
.ENDS LQG15HNR10G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR10H02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR10H02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.28e-7
R2 1 port2 9.57e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.26e-6
R4 2 port2 3.62e+3
L5 port1 3 9.54e-7
R5 3 port2 462
L6 port1 4 4.79e-7
R6 4 port2 46.1
L7 port1 5 8.32e-8
C7 5 6 6.20e-15
R7 6 port2 200
L8 port1 7 3.39e-8
C8 7 8 7.18e-15
R8 8 port2 136
L9 port1 9 1.36e-7
C9 9 10 1.18e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 6.15e-10
C11 13 14 1.38e-13
R11 14 port2 2.76
L12 port1 15 1.02e-9
C12 15 16 1.00e-13
R12 16 port2 2.44
.ENDS LQG15HNR10H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR10J02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR10J02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.28e-7
R2 1 port2 9.57e-1
R3 port1 port2 1.06e+5
L4 port1 2 1.26e-6
R4 2 port2 3.62e+3
L5 port1 3 9.54e-7
R5 3 port2 462
L6 port1 4 4.79e-7
R6 4 port2 46.1
L7 port1 5 8.32e-8
C7 5 6 6.20e-15
R7 6 port2 200
L8 port1 7 3.39e-8
C8 7 8 7.18e-15
R8 8 port2 136
L9 port1 9 1.36e-7
C9 9 10 1.18e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 6.15e-10
C11 13 14 1.38e-13
R11 14 port2 2.76
L12 port1 15 1.02e-9
C12 15 16 1.00e-13
R12 16 port2 2.44
.ENDS LQG15HNR10J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR12G02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR12G02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.57e-7
R2 1 port2 1.03
R3 port1 port2 6.40e+4
L4 port1 2 1.62e-6
R4 2 port2 4.06e+3
L5 port1 3 1.32e-6
R5 3 port2 638
L6 port1 4 5.76e-7
R6 4 port2 55.4
L7 port1 5 9.34e-8
C7 5 6 6.95e-15
R7 6 port2 200
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 136
L9 port1 9 1.52e-7
C9 9 10 1.32e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 3.71e-10
C11 13 14 2.51e-13
R11 14 port2 1.00
.ENDS LQG15HNR12G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR12H02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR12H02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.57e-7
R2 1 port2 1.03
R3 port1 port2 6.40e+4
L4 port1 2 1.62e-6
R4 2 port2 4.06e+3
L5 port1 3 1.32e-6
R5 3 port2 638
L6 port1 4 5.76e-7
R6 4 port2 55.4
L7 port1 5 9.34e-8
C7 5 6 6.95e-15
R7 6 port2 200
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 136
L9 port1 9 1.52e-7
C9 9 10 1.32e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 3.71e-10
C11 13 14 2.51e-13
R11 14 port2 1.00
.ENDS LQG15HNR12H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HNR12J02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HNR12J02 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.57e-7
R2 1 port2 1.03
R3 port1 port2 6.40e+4
L4 port1 2 1.62e-6
R4 2 port2 4.06e+3
L5 port1 3 1.32e-6
R5 3 port2 638
L6 port1 4 5.76e-7
R6 4 port2 55.4
L7 port1 5 9.34e-8
C7 5 6 6.95e-15
R7 6 port2 200
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 136
L9 port1 9 1.52e-7
C9 9 10 1.32e-14
R9 10 port2 180
L10 port1 11 3.45e-9
C10 11 12 3.70e-14
R10 12 port2 28.7
L11 port1 13 3.71e-10
C11 13 14 2.51e-13
R11 14 port2 1.00
.ENDS LQG15HNR12J02
*----------------------------------------------------------------------
