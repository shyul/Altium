*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-05[uF]/100[V]
* Murata P/N :GQM1555C2A360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.14e-10
R03 N02 N03 7.33e-02
C04 N03 N04 1.19e-10
L04 N03 N04 1.80e-11
R04 N03 N04 7.40e+00
C05 N04 N05 4.14e-11
L05 N04 N05 2.11e-11
R05 N04 N05 9.76e+00
C06 N05 Port2 3.73e-11
L06 N05 Port2 1.18e-11
R06 N05 Port2 6.85e+00
.ENDS GQM1555C2A360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-05[uF]/100[V]
* Murata P/N :GQM1555C2A360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.14e-10
R03 N02 N03 7.33e-02
C04 N03 N04 1.19e-10
L04 N03 N04 1.80e-11
R04 N03 N04 7.40e+00
C05 N04 N05 4.14e-11
L05 N04 N05 2.11e-11
R05 N04 N05 9.76e+00
C06 N05 Port2 3.73e-11
L06 N05 Port2 1.18e-11
R06 N05 Port2 6.85e+00
.ENDS GQM1555C2A360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GQM1555C2A390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 7.57e-02
C04 N03 N04 1.36e-10
L04 N03 N04 1.72e-11
R04 N03 N04 7.57e+00
C05 N04 N05 5.15e-11
L05 N04 N05 1.86e-11
R05 N04 N05 9.33e+00
C06 N05 N06 1.20e-10
L06 N05 N06 4.02e-12
R06 N05 N06 2.60e+00
C07 N06 Port2 2.10e-11
L07 N06 Port2 1.48e-11
R07 N06 Port2 1.56e+01
.ENDS GQM1555C2A390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GQM1555C2A390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 7.57e-02
C04 N03 N04 1.36e-10
L04 N03 N04 1.72e-11
R04 N03 N04 7.57e+00
C05 N04 N05 5.15e-11
L05 N04 N05 1.86e-11
R05 N04 N05 9.33e+00
C06 N05 N06 1.20e-10
L06 N05 N06 4.02e-12
R06 N05 N06 2.60e+00
C07 N06 Port2 2.10e-11
L07 N06 Port2 1.48e-11
R07 N06 Port2 1.56e+01
.ENDS GQM1555C2A390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/100[V]
* Murata P/N :GQM1555C2A430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 6.99e-02
C04 N03 N04 1.38e-10
L04 N03 N04 1.85e-11
R04 N03 N04 7.62e+00
C05 N04 N05 5.54e-11
L05 N04 N05 1.88e-11
R05 N04 N05 9.02e+00
C06 N05 N06 7.57e-11
L06 N05 N06 6.97e-12
R06 N05 N06 4.05e+00
C07 N06 Port2 3.73e-11
L07 N06 Port2 9.31e-12
R07 N06 Port2 5.02e+00
.ENDS GQM1555C2A430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/100[V]
* Murata P/N :GQM1555C2A430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 6.99e-02
C04 N03 N04 1.38e-10
L04 N03 N04 1.85e-11
R04 N03 N04 7.62e+00
C05 N04 N05 5.54e-11
L05 N04 N05 1.88e-11
R05 N04 N05 9.02e+00
C06 N05 N06 7.57e-11
L06 N05 N06 6.97e-12
R06 N05 N06 4.05e+00
C07 N06 Port2 3.73e-11
L07 N06 Port2 9.31e-12
R07 N06 Port2 5.02e+00
.ENDS GQM1555C2A430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GQM1555C2A470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 7.18e-02
C04 N03 N04 1.67e-10
L04 N03 N04 1.67e-11
R04 N03 N04 6.65e+00
C05 N04 N05 6.61e-11
L05 N04 N05 1.74e-11
R05 N04 N05 7.81e+00
C06 N05 N06 1.65e-10
L06 N05 N06 3.47e-12
R06 N05 N06 1.97e+00
C07 N06 N07 4.70e-11
L07 N06 N07 7.73e-12
R07 N06 N07 4.74e+00
C08 N07 Port2 8.15e-11
L08 N07 Port2 3.63e-12
R08 N07 Port2 3.90e+00
.ENDS GQM1555C2A470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GQM1555C2A470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2A470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 7.18e-02
C04 N03 N04 1.67e-10
L04 N03 N04 1.67e-11
R04 N03 N04 6.65e+00
C05 N04 N05 6.61e-11
L05 N04 N05 1.74e-11
R05 N04 N05 7.81e+00
C06 N05 N06 1.65e-10
L06 N05 N06 3.47e-12
R06 N05 N06 1.97e+00
C07 N06 N07 4.70e-11
L07 N06 N07 7.73e-12
R07 N06 N07 4.74e+00
C08 N07 Port2 8.15e-11
L08 N07 Port2 3.63e-12
R08 N07 Port2 3.90e+00
.ENDS GQM1555C2A470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.07e-01
C04 N03 N04 3.15e-11
L04 N03 N04 2.00e-11
R04 N03 N04 2.49e+01
C05 N04 Port2 9.28e-12
L05 N04 Port2 3.41e-11
R05 N04 Port2 7.73e+01
.ENDS GQM1555C2D100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.07e-01
C04 N03 N04 3.15e-11
L04 N03 N04 2.00e-11
R04 N03 N04 2.49e+01
C05 N04 Port2 9.28e-12
L05 N04 Port2 3.41e-11
R05 N04 Port2 7.73e+01
.ENDS GQM1555C2D100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-05[uF]/200[V]
* Murata P/N :GQM1555C2D110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.92e-11
L04 N03 N04 1.72e-11
R04 N03 N04 1.95e+01
C05 N04 Port2 1.11e-11
L05 N04 Port2 2.88e-11
R05 N04 Port2 1.92e+01
.ENDS GQM1555C2D110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-05[uF]/200[V]
* Murata P/N :GQM1555C2D110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.92e-11
L04 N03 N04 1.72e-11
R04 N03 N04 1.95e+01
C05 N04 Port2 1.11e-11
L05 N04 Port2 2.88e-11
R05 N04 Port2 1.92e+01
.ENDS GQM1555C2D110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/200[V]
* Murata P/N :GQM1555C2D120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.01e-01
C04 N03 N04 3.54e-11
L04 N03 N04 2.03e-11
R04 N03 N04 1.99e+01
C05 N04 Port2 5.57e-12
L05 N04 Port2 5.73e-11
R05 N04 Port2 7.87e+01
.ENDS GQM1555C2D120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/200[V]
* Murata P/N :GQM1555C2D120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.01e-01
C04 N03 N04 3.54e-11
L04 N03 N04 2.03e-11
R04 N03 N04 1.99e+01
C05 N04 Port2 5.57e-12
L05 N04 Port2 5.73e-11
R05 N04 Port2 7.87e+01
.ENDS GQM1555C2D120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-05[uF]/200[V]
* Murata P/N :GQM1555C2D130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 9.60e-02
C04 N03 N04 4.15e-11
L04 N03 N04 1.91e-11
R04 N03 N04 1.71e+01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 3.43e+01
.ENDS GQM1555C2D130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-05[uF]/200[V]
* Murata P/N :GQM1555C2D130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 9.60e-02
C04 N03 N04 4.15e-11
L04 N03 N04 1.91e-11
R04 N03 N04 1.71e+01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 3.43e+01
.ENDS GQM1555C2D130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/200[V]
* Murata P/N :GQM1555C2D150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.03e-01
C04 N03 N04 6.07e-11
L04 N03 N04 1.52e-11
R04 N03 N04 1.03e+01
C05 N04 N05 2.50e-11
L05 N04 N05 1.59e-11
R05 N04 N05 1.72e+01
C06 N05 Port2 2.29e-11
L06 N05 Port2 1.12e-11
R06 N05 Port2 4.10e+01
.ENDS GQM1555C2D150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/200[V]
* Murata P/N :GQM1555C2D150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.03e-01
C04 N03 N04 6.07e-11
L04 N03 N04 1.52e-11
R04 N03 N04 1.03e+01
C05 N04 N05 2.50e-11
L05 N04 N05 1.59e-11
R05 N04 N05 1.72e+01
C06 N05 Port2 2.29e-11
L06 N05 Port2 1.12e-11
R06 N05 Port2 4.10e+01
.ENDS GQM1555C2D150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-05[uF]/200[V]
* Murata P/N :GQM1555C2D160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 8.32e-02
L04 N03 N04 4.92e-12
R04 N03 N04 1.05e-01
C05 N04 N05 4.89e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.60e+01
C06 N05 Port2 1.90e-11
L06 N05 Port2 2.23e-11
R06 N05 Port2 2.22e+01
.ENDS GQM1555C2D160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-05[uF]/200[V]
* Murata P/N :GQM1555C2D160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 8.32e-02
L04 N03 N04 4.92e-12
R04 N03 N04 1.05e-01
C05 N04 N05 4.89e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.60e+01
C06 N05 Port2 1.90e-11
L06 N05 Port2 2.23e-11
R06 N05 Port2 2.22e+01
.ENDS GQM1555C2D160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/200[V]
* Murata P/N :GQM1555C2D180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.02e-01
L04 N03 N04 3.13e-11
R04 N03 N04 8.54e+00
C05 N04 N05 7.53e-11
L05 N04 N05 1.45e-11
R05 N04 N05 1.11e+01
C06 N05 N06 3.27e-11
L06 N05 N06 1.40e-11
R06 N05 N06 1.66e+01
C07 N06 Port2 1.64e-11
L07 N06 Port2 1.85e-11
R07 N06 Port2 6.95e+00
.ENDS GQM1555C2D180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/200[V]
* Murata P/N :GQM1555C2D180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.02e-01
L04 N03 N04 3.13e-11
R04 N03 N04 8.54e+00
C05 N04 N05 7.53e-11
L05 N04 N05 1.45e-11
R05 N04 N05 1.11e+01
C06 N05 N06 3.27e-11
L06 N05 N06 1.40e-11
R06 N05 N06 1.66e+01
C07 N06 Port2 1.64e-11
L07 N06 Port2 1.85e-11
R07 N06 Port2 6.95e+00
.ENDS GQM1555C2D180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.29e-01
C04 N03 N04 2.45e-11
L04 N03 N04 2.90e-12
R04 N03 N04 6.67e+00
C05 N04 N05 8.86e-12
L05 N04 N05 5.21e-12
R05 N04 N05 1.51e+01
C06 N05 Port2 3.21e-13
L06 N05 Port2 1.21e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2D1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.29e-01
C04 N03 N04 2.45e-11
L04 N03 N04 2.90e-12
R04 N03 N04 6.67e+00
C05 N04 N05 8.86e-12
L05 N04 N05 5.21e-12
R05 N04 N05 1.51e+01
C06 N05 Port2 3.21e-13
L06 N05 Port2 1.21e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2D1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.44e-01
L04 N03 Port2 1.10e-11
R04 N03 Port2 2.48e-01
.ENDS GQM1555C2D1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.44e-01
L04 N03 Port2 1.10e-11
R04 N03 Port2 2.48e-01
.ENDS GQM1555C2D1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-10
R03 N02 N03 1.41e-01
L04 N03 Port2 1.16e-11
R04 N03 Port2 1.37e-01
.ENDS GQM1555C2D1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-10
R03 N02 N03 1.41e-01
L04 N03 Port2 1.16e-11
R04 N03 Port2 1.37e-01
.ENDS GQM1555C2D1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.73e-10
R03 N02 N03 1.37e-01
L04 N03 Port2 1.63e-11
R04 N03 Port2 2.41e-01
.ENDS GQM1555C2D1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.73e-10
R03 N02 N03 1.37e-01
L04 N03 Port2 1.63e-11
R04 N03 Port2 2.41e-01
.ENDS GQM1555C2D1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 1.32e-01
L04 N03 N04 3.98e-12
R04 N03 N04 3.37e-02
C05 N04 Port2 1.59e-10
L05 N04 Port2 2.00e-12
R05 N04 Port2 1.44e+00
.ENDS GQM1555C2D1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 1.32e-01
L04 N03 N04 3.98e-12
R04 N03 N04 3.37e-02
C05 N04 Port2 1.59e-10
L05 N04 Port2 2.00e-12
R05 N04 Port2 1.44e+00
.ENDS GQM1555C2D1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.31e-01
L04 N03 N04 1.12e-11
R04 N03 N04 8.03e-02
C05 N04 Port2 1.92e-10
L05 N04 Port2 1.70e-12
R05 N04 Port2 2.15e+00
.ENDS GQM1555C2D1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.31e-01
L04 N03 N04 1.12e-11
R04 N03 N04 8.03e-02
C05 N04 Port2 1.92e-10
L05 N04 Port2 1.70e-12
R05 N04 Port2 2.15e+00
.ENDS GQM1555C2D1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 1.30e-01
L04 N03 N04 3.36e-12
R04 N03 N04 7.59e-02
C05 N04 Port2 8.36e-11
L05 N04 Port2 3.77e-12
R05 N04 Port2 2.78e+00
.ENDS GQM1555C2D1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 1.30e-01
L04 N03 N04 3.36e-12
R04 N03 N04 7.59e-02
C05 N04 Port2 8.36e-11
L05 N04 Port2 3.77e-12
R05 N04 Port2 2.78e+00
.ENDS GQM1555C2D1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 8.99e-02
L04 N03 N04 2.14e-11
R04 N03 N04 2.48e+00
C05 N04 N05 9.40e-11
L05 N04 N05 1.42e-11
R05 N04 N05 8.83e+00
C06 N05 N06 3.46e-11
L06 N05 N06 1.63e-11
R06 N05 N06 1.19e+01
C07 N06 Port2 1.72e-10
L07 N06 Port2 1.65e-12
R07 N06 Port2 5.16e+01
.ENDS GQM1555C2D200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 8.99e-02
L04 N03 N04 2.14e-11
R04 N03 N04 2.48e+00
C05 N04 N05 9.40e-11
L05 N04 N05 1.42e-11
R05 N04 N05 8.83e+00
C06 N05 N06 3.46e-11
L06 N05 N06 1.63e-11
R06 N05 N06 1.19e+01
C07 N06 Port2 1.72e-10
L07 N06 Port2 1.65e-12
R07 N06 Port2 5.16e+01
.ENDS GQM1555C2D200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/200[V]
* Murata P/N :GQM1555C2D220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 8.45e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.55e-11
R04 N03 N04 9.39e+00
C05 N04 N05 2.76e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 1.59e-11
L06 N05 Port2 1.97e-11
R06 N05 Port2 2.00e+01
.ENDS GQM1555C2D220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/200[V]
* Murata P/N :GQM1555C2D220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 8.45e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.55e-11
R04 N03 N04 9.39e+00
C05 N04 N05 2.76e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 1.59e-11
L06 N05 Port2 1.97e-11
R06 N05 Port2 2.00e+01
.ENDS GQM1555C2D220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/200[V]
* Murata P/N :GQM1555C2D240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 7.93e-02
C04 N03 N04 9.33e-11
L04 N03 N04 1.58e-11
R04 N03 N04 9.62e+00
C05 N04 N05 3.99e-11
L05 N04 N05 1.54e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 2.61e-11
L06 N05 Port2 1.10e-11
R06 N05 Port2 1.22e+01
.ENDS GQM1555C2D240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/200[V]
* Murata P/N :GQM1555C2D240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 7.93e-02
C04 N03 N04 9.33e-11
L04 N03 N04 1.58e-11
R04 N03 N04 9.62e+00
C05 N04 N05 3.99e-11
L05 N04 N05 1.54e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 2.61e-11
L06 N05 Port2 1.10e-11
R06 N05 Port2 1.22e+01
.ENDS GQM1555C2D240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/200[V]
* Murata P/N :GQM1555C2D270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 8.28e-02
C04 N03 N04 9.36e-11
L04 N03 N04 1.77e-11
R04 N03 N04 9.60e+00
C05 N04 N05 3.36e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.40e+01
C06 N05 N06 3.97e-11
L06 N05 N06 8.89e-12
R06 N05 N06 7.08e+00
C07 N06 Port2 1.45e-11
L07 N06 Port2 2.04e-11
R07 N06 Port2 6.92e+01
.ENDS GQM1555C2D270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/200[V]
* Murata P/N :GQM1555C2D270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 8.28e-02
C04 N03 N04 9.36e-11
L04 N03 N04 1.77e-11
R04 N03 N04 9.60e+00
C05 N04 N05 3.36e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.40e+01
C06 N05 N06 3.97e-11
L06 N05 N06 8.89e-12
R06 N05 N06 7.08e+00
C07 N06 Port2 1.45e-11
L07 N06 Port2 2.04e-11
R07 N06 Port2 6.92e+01
.ENDS GQM1555C2D270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.23e-12
R04 N03 N04 4.08e-02
C05 N04 Port2 8.52e-11
L05 N04 Port2 3.54e-12
R05 N04 Port2 1.65e+00
.ENDS GQM1555C2D2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.23e-12
R04 N03 N04 4.08e-02
C05 N04 Port2 8.52e-11
L05 N04 Port2 3.54e-12
R05 N04 Port2 1.65e+00
.ENDS GQM1555C2D2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.48e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.32e-12
R04 N03 N04 7.80e-02
C05 N04 Port2 3.30e-11
L05 N04 Port2 9.53e-12
R05 N04 Port2 1.15e+01
.ENDS GQM1555C2D2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.48e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.32e-12
R04 N03 N04 7.80e-02
C05 N04 Port2 3.30e-11
L05 N04 Port2 9.53e-12
R05 N04 Port2 1.15e+01
.ENDS GQM1555C2D2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 1.17e-01
L04 N03 N04 8.86e-12
R04 N03 N04 3.02e-02
C05 N04 Port2 3.73e-12
L05 N04 Port2 6.06e-11
R05 N04 Port2 1.86e+02
.ENDS GQM1555C2D2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 1.17e-01
L04 N03 N04 8.86e-12
R04 N03 N04 3.02e-02
C05 N04 Port2 3.73e-12
L05 N04 Port2 6.06e-11
R05 N04 Port2 1.86e+02
.ENDS GQM1555C2D2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 1.18e-01
L04 N03 N04 3.13e-12
R04 N03 N04 5.13e-02
C05 N04 Port2 8.89e-11
L05 N04 Port2 3.55e-12
R05 N04 Port2 1.04e+00
.ENDS GQM1555C2D2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 1.18e-01
L04 N03 N04 3.13e-12
R04 N03 N04 5.13e-02
C05 N04 Port2 8.89e-11
L05 N04 Port2 3.55e-12
R05 N04 Port2 1.04e+00
.ENDS GQM1555C2D2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 8.20e-02
C04 N03 N04 1.02e-10
L04 N03 N04 1.82e-11
R04 N03 N04 1.22e+01
C05 N04 N05 3.87e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.80e+01
C06 N05 N06 4.21e-11
L06 N05 N06 9.31e-12
R06 N05 N06 1.02e+01
C07 N06 Port2 5.79e-12
L07 N06 Port2 5.00e-11
R07 N06 Port2 1.74e+02
.ENDS GQM1555C2D300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 8.20e-02
C04 N03 N04 1.02e-10
L04 N03 N04 1.82e-11
R04 N03 N04 1.22e+01
C05 N04 N05 3.87e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.80e+01
C06 N05 N06 4.21e-11
L06 N05 N06 9.31e-12
R06 N05 N06 1.02e+01
C07 N06 Port2 5.79e-12
L07 N06 Port2 5.00e-11
R07 N06 Port2 1.74e+02
.ENDS GQM1555C2D300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/200[V]
* Murata P/N :GQM1555C2D330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 7.91e-02
C04 N03 N04 1.20e-10
L04 N03 N04 1.68e-11
R04 N03 N04 9.65e+00
C05 N04 N05 4.56e-11
L05 N04 N05 1.85e-11
R05 N04 N05 1.60e+01
C06 N05 N06 1.30e-10
L06 N05 N06 3.26e-12
R06 N05 N06 4.56e+00
C07 N06 Port2 1.19e-11
L07 N06 Port2 2.56e-11
R07 N06 Port2 1.69e+01
.ENDS GQM1555C2D330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/200[V]
* Murata P/N :GQM1555C2D330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 7.91e-02
C04 N03 N04 1.20e-10
L04 N03 N04 1.68e-11
R04 N03 N04 9.65e+00
C05 N04 N05 4.56e-11
L05 N04 N05 1.85e-11
R05 N04 N05 1.60e+01
C06 N05 N06 1.30e-10
L06 N05 N06 3.26e-12
R06 N05 N06 4.56e+00
C07 N06 Port2 1.19e-11
L07 N06 Port2 2.56e-11
R07 N06 Port2 1.69e+01
.ENDS GQM1555C2D330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 1.16e-01
L04 N03 N04 1.01e-11
R04 N03 N04 9.34e-02
C05 N04 Port2 8.27e-12
L05 N04 Port2 3.54e-11
R05 N04 Port2 1.75e+02
.ENDS GQM1555C2D3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 1.16e-01
L04 N03 N04 1.01e-11
R04 N03 N04 9.34e-02
C05 N04 Port2 8.27e-12
L05 N04 Port2 3.54e-11
R05 N04 Port2 1.75e+02
.ENDS GQM1555C2D3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R0WB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R0WB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 1.16e-01
L04 N03 N04 1.01e-11
R04 N03 N04 9.34e-02
C05 N04 Port2 8.27e-12
L05 N04 Port2 3.54e-11
R05 N04 Port2 1.75e+02
.ENDS GQM1555C2D3R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 1.15e-01
L04 N03 N04 6.98e-12
R04 N03 N04 7.51e-02
C05 N04 Port2 6.18e-12
L05 N04 Port2 4.73e-11
R05 N04 Port2 1.58e+02
.ENDS GQM1555C2D3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 1.15e-01
L04 N03 N04 6.98e-12
R04 N03 N04 7.51e-02
C05 N04 Port2 6.18e-12
L05 N04 Port2 4.73e-11
R05 N04 Port2 1.58e+02
.ENDS GQM1555C2D3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.09e-01
L04 N03 N04 4.41e-12
R04 N03 N04 1.25e-01
C05 N04 Port2 8.28e-11
L05 N04 Port2 4.09e-12
R05 N04 Port2 1.83e+00
.ENDS GQM1555C2D3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.09e-01
L04 N03 N04 4.41e-12
R04 N03 N04 1.25e-01
C05 N04 Port2 8.28e-11
L05 N04 Port2 4.09e-12
R05 N04 Port2 1.83e+00
.ENDS GQM1555C2D3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 1.07e-01
L04 N03 N04 7.08e-12
R04 N03 N04 5.26e-02
C05 N04 Port2 8.89e-12
L05 N04 Port2 3.48e-11
R05 N04 Port2 1.04e+02
.ENDS GQM1555C2D3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/200[V]
* Murata P/N :GQM1555C2D3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 1.07e-01
L04 N03 N04 7.08e-12
R04 N03 N04 5.26e-02
C05 N04 Port2 8.89e-12
L05 N04 Port2 3.48e-11
R05 N04 Port2 1.04e+02
.ENDS GQM1555C2D3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.08e-01
L04 N03 N04 4.63e-12
R04 N03 N04 5.10e-02
C05 N04 Port2 4.63e-12
L05 N04 Port2 6.59e-11
R05 N04 Port2 2.20e+02
.ENDS GQM1555C2D4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.08e-01
L04 N03 N04 4.63e-12
R04 N03 N04 5.10e-02
C05 N04 Port2 4.63e-12
L05 N04 Port2 6.59e-11
R05 N04 Port2 2.20e+02
.ENDS GQM1555C2D4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.04e-01
L04 N03 N04 4.52e-12
R04 N03 N04 6.71e-02
C05 N04 Port2 6.91e-12
L05 N04 Port2 4.43e-11
R05 N04 Port2 1.11e+02
.ENDS GQM1555C2D4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.04e-01
L04 N03 N04 4.52e-12
R04 N03 N04 6.71e-02
C05 N04 Port2 6.91e-12
L05 N04 Port2 4.43e-11
R05 N04 Port2 1.11e+02
.ENDS GQM1555C2D4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 1.03e-01
L04 N03 N04 5.79e-12
R04 N03 N04 5.21e-02
C05 N04 Port2 6.16e-12
L05 N04 Port2 5.23e-11
R05 N04 Port2 1.33e+02
.ENDS GQM1555C2D4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 1.03e-01
L04 N03 N04 5.79e-12
R04 N03 N04 5.21e-02
C05 N04 Port2 6.16e-12
L05 N04 Port2 5.23e-11
R05 N04 Port2 1.33e+02
.ENDS GQM1555C2D4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.51e-10
R03 N02 N03 1.04e-01
L04 N03 N04 9.57e-12
R04 N03 N04 7.40e-02
C05 N04 Port2 1.75e-11
L05 N04 Port2 1.86e-11
R05 N04 Port2 4.84e+01
.ENDS GQM1555C2D5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.51e-10
R03 N02 N03 1.04e-01
L04 N03 N04 9.57e-12
R04 N03 N04 7.40e-02
C05 N04 Port2 1.75e-11
L05 N04 Port2 1.86e-11
R05 N04 Port2 4.84e+01
.ENDS GQM1555C2D5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R1BB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R1BB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 9.68e-02
L04 N03 N04 7.33e-12
R04 N03 N04 7.43e-02
C05 N04 Port2 1.01e-11
L05 N04 Port2 3.39e-11
R05 N04 Port2 9.92e+01
.ENDS GQM1555C2D5R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 9.68e-02
L04 N03 N04 7.33e-12
R04 N03 N04 7.43e-02
C05 N04 Port2 1.01e-11
L05 N04 Port2 3.39e-11
R05 N04 Port2 9.92e+01
.ENDS GQM1555C2D5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R6BB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R6BB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 9.30e-02
L04 N03 N04 6.17e-12
R04 N03 N04 9.96e-02
C05 N04 Port2 1.46e-11
L05 N04 Port2 2.53e-11
R05 N04 Port2 5.07e+01
.ENDS GQM1555C2D5R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/200[V]
* Murata P/N :GQM1555C2D5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 9.30e-02
L04 N03 N04 6.17e-12
R04 N03 N04 9.96e-02
C05 N04 Port2 1.46e-11
L05 N04 Port2 2.53e-11
R05 N04 Port2 5.07e+01
.ENDS GQM1555C2D5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R0BB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R0BB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 9.27e-02
L04 N03 N04 6.33e-12
R04 N03 N04 2.86e-01
C05 N04 Port2 1.75e-11
L05 N04 Port2 2.16e-11
R05 N04 Port2 3.67e+01
.ENDS GQM1555C2D6R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 9.27e-02
L04 N03 N04 6.33e-12
R04 N03 N04 2.86e-01
C05 N04 Port2 1.75e-11
L05 N04 Port2 2.16e-11
R05 N04 Port2 3.67e+01
.ENDS GQM1555C2D6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R2BB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R2BB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 9.50e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.50e-02
C05 N04 N05 3.06e-11
L05 N04 N05 1.29e-11
R05 N04 N05 2.65e+01
C06 N05 Port2 6.65e-11
L06 N05 Port2 4.60e-12
R06 N05 Port2 1.57e+00
.ENDS GQM1555C2D6R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 9.50e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.50e-02
C05 N04 N05 3.06e-11
L05 N04 N05 1.29e-11
R05 N04 N05 2.65e+01
C06 N05 Port2 6.65e-11
L06 N05 Port2 4.60e-12
R06 N05 Port2 1.57e+00
.ENDS GQM1555C2D6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R8BB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R8BB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 9.01e-02
L04 N03 N04 5.51e-12
R04 N03 N04 1.20e-01
C05 N04 N05 2.89e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.57e+01
C06 N05 Port2 1.32e-09
L06 N05 Port2 2.34e-13
R06 N05 Port2 4.03e-01
.ENDS GQM1555C2D6R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/200[V]
* Murata P/N :GQM1555C2D6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 9.01e-02
L04 N03 N04 5.51e-12
R04 N03 N04 1.20e-01
C05 N04 N05 2.89e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.57e+01
C06 N05 Port2 1.32e-09
L06 N05 Port2 2.34e-13
R06 N05 Port2 4.03e-01
.ENDS GQM1555C2D6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D7R0BB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D7R0BB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 9.22e-02
L04 N03 N04 5.29e-12
R04 N03 N04 8.25e-02
C05 N04 N05 2.24e-11
L05 N04 N05 1.95e-11
R05 N04 N05 3.33e+01
C06 N05 Port2 8.43e-12
L06 N05 Port2 3.05e-11
R06 N05 Port2 9.57e+01
.ENDS GQM1555C2D7R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 9.22e-02
L04 N03 N04 5.29e-12
R04 N03 N04 8.25e-02
C05 N04 N05 2.24e-11
L05 N04 N05 1.95e-11
R05 N04 N05 3.33e+01
C06 N05 Port2 8.43e-12
L06 N05 Port2 3.05e-11
R06 N05 Port2 9.57e+01
.ENDS GQM1555C2D7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/200[V]
* Murata P/N :GQM1555C2D7R5BB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D7R5BB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 8.40e-02
L04 N03 N04 8.22e-12
R04 N03 N04 3.63e-01
C05 N04 N05 2.62e-11
L05 N04 N05 1.80e-11
R05 N04 N05 2.76e+01
C06 N05 Port2 4.74e-12
L06 N05 Port2 4.61e-11
R06 N05 Port2 2.22e+02
.ENDS GQM1555C2D7R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/200[V]
* Murata P/N :GQM1555C2D7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 8.40e-02
L04 N03 N04 8.22e-12
R04 N03 N04 3.63e-01
C05 N04 N05 2.62e-11
L05 N04 N05 1.80e-11
R05 N04 N05 2.76e+01
C06 N05 Port2 4.74e-12
L06 N05 Port2 4.61e-11
R06 N05 Port2 2.22e+02
.ENDS GQM1555C2D7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R0BB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R0BB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.86e-02
L04 N03 N04 5.11e-12
R04 N03 N04 7.28e-02
C05 N04 N05 2.38e-11
L05 N04 N05 2.14e-11
R05 N04 N05 2.64e+01
C06 N05 Port2 5.20e-12
L06 N05 Port2 4.90e-11
R06 N05 Port2 5.45e+02
.ENDS GQM1555C2D8R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.86e-02
L04 N03 N04 5.11e-12
R04 N03 N04 7.28e-02
C05 N04 N05 2.38e-11
L05 N04 N05 2.14e-11
R05 N04 N05 2.64e+01
C06 N05 Port2 5.20e-12
L06 N05 Port2 4.90e-11
R06 N05 Port2 5.45e+02
.ENDS GQM1555C2D8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R2BB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R2BB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 7.06e-02
L04 N03 N04 3.73e-12
R04 N03 N04 8.84e-02
C05 N04 N05 2.15e-11
L05 N04 N05 2.39e-11
R05 N04 N05 3.13e+01
C06 N05 Port2 5.39e-12
L06 N05 Port2 5.40e-11
R06 N05 Port2 9.53e+01
.ENDS GQM1555C2D8R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 7.06e-02
L04 N03 N04 3.73e-12
R04 N03 N04 8.84e-02
C05 N04 N05 2.15e-11
L05 N04 N05 2.39e-11
R05 N04 N05 3.13e+01
C06 N05 Port2 5.39e-12
L06 N05 Port2 5.40e-11
R06 N05 Port2 9.53e+01
.ENDS GQM1555C2D8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D9R0BB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D9R0BB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 7.78e-02
L04 N03 N04 4.09e-12
R04 N03 N04 8.96e-02
C05 N04 N05 3.03e-11
L05 N04 N05 1.85e-11
R05 N04 N05 2.78e+01
C06 N05 Port2 8.58e-12
L06 N05 Port2 3.15e-11
R06 N05 Port2 4.69e+01
.ENDS GQM1555C2D9R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 7.78e-02
L04 N03 N04 4.09e-12
R04 N03 N04 8.96e-02
C05 N04 N05 3.03e-11
L05 N04 N05 1.85e-11
R05 N04 N05 2.78e+01
C06 N05 Port2 8.58e-12
L06 N05 Port2 3.15e-11
R06 N05 Port2 4.69e+01
.ENDS GQM1555C2D9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D9R1BB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D9R1BB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.85e-11
R03 N02 N03 7.73e-02
L04 N03 N04 5.77e-12
R04 N03 N04 2.78e-02
C05 N04 N05 2.23e-11
L05 N04 N05 2.58e-11
R05 N04 N05 3.45e+01
C06 N05 Port2 1.97e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.35e+02
.ENDS GQM1555C2D9R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.85e-11
R03 N02 N03 7.73e-02
L04 N03 N04 5.77e-12
R04 N03 N04 2.78e-02
C05 N04 N05 2.23e-11
L05 N04 N05 2.58e-11
R05 N04 N05 3.45e+01
C06 N05 Port2 1.97e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.35e+02
.ENDS GQM1555C2D9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR10BB01
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR10BB01 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 5.30e-10
R03 N02 N03 6.04e-01
C04 N03 Port2 3.22e-10
L04 N03 Port2 1.89e-13
R04 N03 Port2 1.44e-01
.ENDS GQM1555C2DR10BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR20BB01
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR20BB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.40e-10
R03 N02 N03 4.81e-01
C04 N03 Port2 2.71e-10
L04 N03 Port2 2.22e-13
R04 N03 Port2 5.32e-01
.ENDS GQM1555C2DR20BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR30BB01
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR30BB01 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.84e-10
R03 N02 N03 4.13e-01
C04 N03 Port2 1.07e-10
L04 N03 Port2 5.66e-13
R04 N03 Port2 6.90e-01
.ENDS GQM1555C2DR30BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR30CB01
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR30CB01 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.84e-10
R03 N02 N03 4.13e-01
C04 N03 Port2 1.07e-10
L04 N03 Port2 5.66e-13
R04 N03 Port2 6.90e-01
.ENDS GQM1555C2DR30CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR40BB01
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR40BB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.35e-10
R03 N02 N03 3.44e-01
C04 N03 N04 2.27e-11
L04 N03 N04 2.52e-12
R04 N03 N04 2.15e+00
C05 N04 Port2 3.33e-12
L05 N04 Port2 1.65e-11
R05 N04 Port2 1.00e+05
.ENDS GQM1555C2DR40BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR40CB01
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR40CB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.35e-10
R03 N02 N03 3.44e-01
C04 N03 N04 2.27e-11
L04 N03 N04 2.52e-12
R04 N03 N04 2.15e+00
C05 N04 Port2 3.33e-12
L05 N04 Port2 1.65e-11
R05 N04 Port2 1.00e+05
.ENDS GQM1555C2DR40CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR50BB01
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR50BB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.56e-10
R03 N02 N03 3.24e-01
C04 N03 N04 3.66e-11
L04 N03 N04 1.61e-12
R04 N03 N04 1.21e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.87e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR50BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR50CB01
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR50CB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.56e-10
R03 N02 N03 3.24e-01
C04 N03 N04 3.66e-11
L04 N03 N04 1.61e-12
R04 N03 N04 1.21e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.87e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR50CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR60BB01
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR60BB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 3.08e-01
C04 N03 N04 4.78e-11
L04 N03 N04 1.28e-12
R04 N03 N04 9.02e-01
C05 N04 Port2 5.48e-13
L05 N04 Port2 7.50e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR60BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR60CB01
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR60CB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 3.08e-01
C04 N03 N04 4.78e-11
L04 N03 N04 1.28e-12
R04 N03 N04 9.02e-01
C05 N04 Port2 5.48e-13
L05 N04 Port2 7.50e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR60CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR70BB01
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR70BB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 2.90e-01
C04 N03 N04 1.95e-11
L04 N03 N04 2.63e-12
R04 N03 N04 1.55e+00
C05 N04 Port2 1.03e-12
L05 N04 Port2 4.25e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR70BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR70CB01
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR70CB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 2.90e-01
C04 N03 N04 1.95e-11
L04 N03 N04 2.63e-12
R04 N03 N04 1.55e+00
C05 N04 Port2 1.03e-12
L05 N04 Port2 4.25e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR70CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR75BB01
* Property : C = 7.50e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR75BB01 Port1 Port2
C01 Port1 N01 7.50e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 2.83e-01
C04 N03 N04 3.84e-12
L04 N03 N04 1.60e-11
R04 N03 N04 9.17e+01
C05 N04 Port2 1.14e-12
L05 N04 Port2 4.21e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR75BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR75CB01
* Property : C = 7.50e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR75CB01 Port1 Port2
C01 Port1 N01 7.50e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 2.83e-01
C04 N03 N04 3.84e-12
L04 N03 N04 1.60e-11
R04 N03 N04 9.17e+01
C05 N04 Port2 1.14e-12
L05 N04 Port2 4.21e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR75CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR80BB01
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR80BB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 2.75e-01
C04 N03 N04 4.78e-12
L04 N03 N04 1.40e-11
R04 N03 N04 6.17e+01
C05 N04 N05 3.43e-11
L05 N04 N05 1.59e-12
R05 N04 N05 2.04e+01
C06 N05 Port2 5.29e-13
L06 N05 Port2 8.27e-11
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR80BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR80CB01
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR80CB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 2.75e-01
C04 N03 N04 4.78e-12
L04 N03 N04 1.40e-11
R04 N03 N04 6.17e+01
C05 N04 N05 3.43e-11
L05 N04 N05 1.59e-12
R05 N04 N05 2.04e+01
C06 N05 Port2 5.29e-13
L06 N05 Port2 8.27e-11
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR80CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR90BB01
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 2.53e-01
C04 N03 N04 4.19e-12
L04 N03 N04 1.65e-11
R04 N03 N04 7.26e+01
C05 N04 N05 3.13e-12
L05 N04 N05 1.73e-11
R05 N04 N05 1.05e+02
C06 N05 Port2 1.85e-13
L06 N05 Port2 1.24e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR90BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR90CB01
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR90CB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 2.53e-01
C04 N03 N04 4.19e-12
L04 N03 N04 1.65e-11
R04 N03 N04 7.26e+01
C05 N04 N05 3.13e-12
L05 N04 N05 1.73e-11
R05 N04 N05 1.05e+02
C06 N05 Port2 1.85e-13
L06 N05 Port2 1.24e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR90CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E100GB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875C2E100GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E100JB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875C2E100JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM1875C2E101FB12
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E101FB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.27e-10
R03 N02 N03 4.70e-02
C04 N03 N04 1.94e-12
L04 N03 N04 1.28e-10
C05 N04 N05 2.08e-10
L05 N04 N05 3.56e-11
R05 N04 N05 1.26e+01
C06 N05 N06 1.03e-10
L06 N05 N06 2.72e-11
R06 N05 N06 1.40e+01
C07 N06 N07 2.02e-10
L07 N06 N07 6.76e-12
R07 N06 N07 4.89e+00
C08 N07 N08 7.46e-11
L08 N07 N08 1.10e-11
R08 N07 N08 8.80e+00
C09 N08 N09 1.27e-10
L09 N08 N09 4.27e-12
R09 N08 N09 4.01e+00
C10 N09 Port2 4.33e-11
L10 N09 Port2 8.92e-12
R10 N09 Port2 1.01e+01
.ENDS GQM1875C2E101FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM1875C2E101GB12
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E101GB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.27e-10
R03 N02 N03 4.70e-02
C04 N03 N04 1.94e-12
L04 N03 N04 1.28e-10
C05 N04 N05 2.08e-10
L05 N04 N05 3.56e-11
R05 N04 N05 1.26e+01
C06 N05 N06 1.03e-10
L06 N05 N06 2.72e-11
R06 N05 N06 1.40e+01
C07 N06 N07 2.02e-10
L07 N06 N07 6.76e-12
R07 N06 N07 4.89e+00
C08 N07 N08 7.46e-11
L08 N07 N08 1.10e-11
R08 N07 N08 8.80e+00
C09 N08 N09 1.27e-10
L09 N08 N09 4.27e-12
R09 N08 N09 4.01e+00
C10 N09 Port2 4.33e-11
L10 N09 Port2 8.92e-12
R10 N09 Port2 1.01e+01
.ENDS GQM1875C2E101GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM1875C2E101JB12
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E101JB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.27e-10
R03 N02 N03 4.70e-02
C04 N03 N04 1.94e-12
L04 N03 N04 1.28e-10
C05 N04 N05 2.08e-10
L05 N04 N05 3.56e-11
R05 N04 N05 1.26e+01
C06 N05 N06 1.03e-10
L06 N05 N06 2.72e-11
R06 N05 N06 1.40e+01
C07 N06 N07 2.02e-10
L07 N06 N07 6.76e-12
R07 N06 N07 4.89e+00
C08 N07 N08 7.46e-11
L08 N07 N08 1.10e-11
R08 N07 N08 8.80e+00
C09 N08 N09 1.27e-10
L09 N08 N09 4.27e-12
R09 N08 N09 4.01e+00
C10 N09 Port2 4.33e-11
L10 N09 Port2 8.92e-12
R10 N09 Port2 1.01e+01
.ENDS GQM1875C2E101JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875C2E110GB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875C2E110GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875C2E110JB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875C2E110JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E120GB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 5.00e-02
C04 N03 N04 2.78e-11
L04 N03 N04 3.36e-11
R04 N03 N04 5.81e+01
C05 N04 Port2 7.18e-12
L05 N04 Port2 5.26e-11
R05 N04 Port2 1.19e+02
.ENDS GQM1875C2E120GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E120JB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E120JB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 5.00e-02
C04 N03 N04 2.78e-11
L04 N03 N04 3.36e-11
R04 N03 N04 5.81e+01
C05 N04 Port2 7.18e-12
L05 N04 Port2 5.26e-11
R05 N04 Port2 1.19e+02
.ENDS GQM1875C2E120JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E130GB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E130GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E130JB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E130JB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E130JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875C2E150GB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E150GB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E150GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875C2E150JB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E150JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E160GB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E160GB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 5.38e-02
L04 N03 N04 4.29e-12
R04 N03 N04 9.31e-02
C05 N04 N05 3.99e-11
L05 N04 N05 3.04e-11
R05 N04 N05 4.24e+01
C06 N05 N06 1.19e-11
L06 N05 N06 4.06e-11
R06 N05 N06 9.15e+01
C07 N06 Port2 1.38e-12
L07 N06 Port2 1.49e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E160GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E160JB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E160JB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 5.38e-02
L04 N03 N04 4.29e-12
R04 N03 N04 9.31e-02
C05 N04 N05 3.99e-11
L05 N04 N05 3.04e-11
R05 N04 N05 4.24e+01
C06 N05 N06 1.19e-11
L06 N05 N06 4.06e-11
R06 N05 N06 9.15e+01
C07 N06 Port2 1.38e-12
L07 N06 Port2 1.49e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E160JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E180GB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E180GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E180JB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E180JB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E180JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R0BB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R0BB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875C2E1R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R0CB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875C2E1R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R1BB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R1BB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875C2E1R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R1CB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R1CB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875C2E1R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R2BB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R2BB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875C2E1R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R2CB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875C2E1R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R3BB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R3BB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875C2E1R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R3CB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R3CB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875C2E1R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R5BB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R5BB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875C2E1R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R5CB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R5CB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875C2E1R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R6BB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875C2E1R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R6CB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R6CB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875C2E1R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R8BB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875C2E1R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875C2E1R8CB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E1R8CB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875C2E1R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E200GB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 4.19e-02
C04 N03 N04 4.39e-11
L04 N03 N04 3.40e-11
R04 N03 N04 3.45e+01
C05 N04 N05 1.96e-11
L05 N04 N05 3.01e-11
R05 N04 N05 6.32e+01
C06 N05 N06 3.82e-12
L06 N05 N06 6.50e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 1.77e-11
L07 N06 Port2 1.32e-11
R07 N06 Port2 4.74e+00
.ENDS GQM1875C2E200GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E200JB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E200JB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 4.19e-02
C04 N03 N04 4.39e-11
L04 N03 N04 3.40e-11
R04 N03 N04 3.45e+01
C05 N04 N05 1.96e-11
L05 N04 N05 3.01e-11
R05 N04 N05 6.32e+01
C06 N05 N06 3.82e-12
L06 N05 N06 6.50e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 1.77e-11
L07 N06 Port2 1.32e-11
R07 N06 Port2 4.74e+00
.ENDS GQM1875C2E200JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E220GB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E220GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E220JB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E220JB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E220JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875C2E240GB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E240GB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E240GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875C2E240JB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E240JB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E240JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E270GB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E270GB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E270GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E270JB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E270JB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E270JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R0BB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R0BB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875C2E2R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R0CB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875C2E2R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R2BB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R2BB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.65e-12
L04 N03 N04 1.40e-10
C05 N04 Port2 7.55e-11
L05 N04 Port2 3.95e-12
R05 N04 Port2 1.41e+00
.ENDS GQM1875C2E2R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R2CB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.65e-12
L04 N03 N04 1.40e-10
C05 N04 Port2 7.55e-11
L05 N04 Port2 3.95e-12
R05 N04 Port2 1.41e+00
.ENDS GQM1875C2E2R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R4BB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875C2E2R4BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R4CB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R4CB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875C2E2R4CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R7BB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R7BB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875C2E2R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R7CB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875C2E2R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E300GB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E300GB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E300GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E300JB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E300JB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E300JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E330GB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E330GB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-11
R03 N02 N03 3.55e-02
L04 N03 N04 6.26e-12
R04 N03 N04 9.41e-02
C05 N04 N05 8.02e-11
L05 N04 N05 3.16e-11
R05 N04 N05 2.62e+01
C06 N05 N06 3.07e-11
L06 N05 N06 3.21e-11
R06 N05 N06 3.80e+01
C07 N06 N07 4.37e-11
L07 N06 N07 1.12e-11
R07 N06 N07 1.87e+01
C08 N07 N08 6.42e-11
L08 N07 N08 5.08e-12
R08 N07 N08 1.87e+00
C09 N08 Port2 1.28e-12
L09 N08 Port2 1.90e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E330GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E330JB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E330JB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-11
R03 N02 N03 3.55e-02
L04 N03 N04 6.26e-12
R04 N03 N04 9.41e-02
C05 N04 N05 8.02e-11
L05 N04 N05 3.16e-11
R05 N04 N05 2.62e+01
C06 N05 N06 3.07e-11
L06 N05 N06 3.21e-11
R06 N05 N06 3.80e+01
C07 N06 N07 4.37e-11
L07 N06 N07 1.12e-11
R07 N06 N07 1.87e+01
C08 N07 N08 6.42e-11
L08 N07 N08 5.08e-12
R08 N07 N08 1.87e+00
C09 N08 Port2 1.28e-12
L09 N08 Port2 1.90e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E330JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E360GB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E360GB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 3.96e-02
L04 N03 N04 9.17e-12
R04 N03 N04 1.92e-02
C05 N04 N05 8.47e-11
L05 N04 N05 3.28e-11
R05 N04 N05 2.32e+01
C06 N05 N06 3.85e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.61e+01
C07 N06 N07 7.33e-11
L07 N06 N07 7.24e-12
R07 N06 N07 9.34e+00
C08 N07 N08 2.63e-11
L08 N07 N08 1.24e-11
R08 N07 N08 2.40e+01
C09 N08 Port2 2.88e-12
L09 N08 Port2 6.10e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E360GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E360JB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E360JB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 3.96e-02
L04 N03 N04 9.17e-12
R04 N03 N04 1.92e-02
C05 N04 N05 8.47e-11
L05 N04 N05 3.28e-11
R05 N04 N05 2.32e+01
C06 N05 N06 3.85e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.61e+01
C07 N06 N07 7.33e-11
L07 N06 N07 7.24e-12
R07 N06 N07 9.34e+00
C08 N07 N08 2.63e-11
L08 N07 N08 1.24e-11
R08 N07 N08 2.40e+01
C09 N08 Port2 2.88e-12
L09 N08 Port2 6.10e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E360JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM1875C2E390GB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E390GB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.48e-12
R04 N03 N04 3.44e-02
C05 N04 N05 1.17e-10
L05 N04 N05 2.55e-11
R05 N04 N05 1.94e+01
C06 N05 N06 4.09e-11
L06 N05 N06 2.81e-11
R06 N05 N06 2.80e+01
C07 N06 N07 6.70e-11
L07 N06 N07 8.43e-12
R07 N06 N07 1.13e+01
C08 N07 N08 1.69e-11
L08 N07 N08 2.03e-11
R08 N07 N08 4.01e+01
C09 N08 Port2 1.67e-12
L09 N08 Port2 1.21e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E390GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM1875C2E390JB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E390JB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.48e-12
R04 N03 N04 3.44e-02
C05 N04 N05 1.17e-10
L05 N04 N05 2.55e-11
R05 N04 N05 1.94e+01
C06 N05 N06 4.09e-11
L06 N05 N06 2.81e-11
R06 N05 N06 2.80e+01
C07 N06 N07 6.70e-11
L07 N06 N07 8.43e-12
R07 N06 N07 1.13e+01
C08 N07 N08 1.69e-11
L08 N07 N08 2.03e-11
R08 N07 N08 4.01e+01
C09 N08 Port2 1.67e-12
L09 N08 Port2 1.21e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E390JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R0BB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R0BB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 1.20e-01
L04 N03 N04 9.29e-13
R04 N03 N04 8.76e-02
C05 N04 N05 1.75e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 3.69e-11
L06 N05 Port2 8.38e-12
R06 N05 Port2 2.40e+00
.ENDS GQM1875C2E3R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R0CB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 1.20e-01
L04 N03 N04 9.29e-13
R04 N03 N04 8.76e-02
C05 N04 N05 1.75e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 3.69e-11
L06 N05 Port2 8.38e-12
R06 N05 Port2 2.40e+00
.ENDS GQM1875C2E3R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R3BB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R3BB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875C2E3R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R3CB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R3CB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875C2E3R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R6BB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R6BB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875C2E3R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R6CB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R6CB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875C2E3R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R9BB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R9BB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875C2E3R9BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875C2E3R9CB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E3R9CB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875C2E3R9CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E430GB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E430GB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 3.88e-02
L04 N03 N04 7.18e-12
R04 N03 N04 1.80e-02
C05 N04 N05 1.04e-10
L05 N04 N05 3.16e-11
R05 N04 N05 2.24e+01
C06 N05 N06 4.71e-11
L06 N05 N06 2.74e-11
R06 N05 N06 2.74e+01
C07 N06 N07 8.17e-11
L07 N06 N07 7.71e-12
R07 N06 N07 9.84e+00
C08 N07 N08 2.46e-11
L08 N07 N08 1.61e-11
R08 N07 N08 2.66e+01
C09 N08 N09 5.12e-12
L09 N08 N09 4.95e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 5.74e-12
L10 N09 Port2 4.14e-11
R10 N09 Port2 3.55e+01
.ENDS GQM1875C2E430GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E430JB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E430JB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 3.88e-02
L04 N03 N04 7.18e-12
R04 N03 N04 1.80e-02
C05 N04 N05 1.04e-10
L05 N04 N05 3.16e-11
R05 N04 N05 2.24e+01
C06 N05 N06 4.71e-11
L06 N05 N06 2.74e-11
R06 N05 N06 2.74e+01
C07 N06 N07 8.17e-11
L07 N06 N07 7.71e-12
R07 N06 N07 9.84e+00
C08 N07 N08 2.46e-11
L08 N07 N08 1.61e-11
R08 N07 N08 2.66e+01
C09 N08 N09 5.12e-12
L09 N08 N09 4.95e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 5.74e-12
L10 N09 Port2 4.14e-11
R10 N09 Port2 3.55e+01
.ENDS GQM1875C2E430JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E470GB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E470GB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.42e-11
R03 N02 N03 3.20e-02
L04 N03 N04 6.62e-11
R04 N03 N04 1.34e+01
C05 N04 N05 1.14e-10
L05 N04 N05 3.12e-11
R05 N04 N05 1.86e+01
C06 N05 N06 4.96e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.38e+01
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 9.46e+00
C08 N07 N08 3.07e-11
L08 N07 N08 1.36e-11
R08 N07 N08 2.58e+01
C09 N08 Port2 2.04e-12
L09 N08 Port2 1.16e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E470GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E470JB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E470JB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.42e-11
R03 N02 N03 3.20e-02
L04 N03 N04 6.62e-11
R04 N03 N04 1.34e+01
C05 N04 N05 1.14e-10
L05 N04 N05 3.12e-11
R05 N04 N05 1.86e+01
C06 N05 N06 4.96e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.38e+01
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 9.46e+00
C08 N07 N08 3.07e-11
L08 N07 N08 1.36e-11
R08 N07 N08 2.58e+01
C09 N08 Port2 2.04e-12
L09 N08 Port2 1.16e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E470JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R0BB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.89e-12
R04 N03 N04 1.78e-01
C05 N04 N05 1.90e-12
L05 N04 N05 1.55e-10
C06 N05 Port2 2.50e-11
L06 N05 Port2 1.30e-11
R06 N05 Port2 8.12e+00
.ENDS GQM1875C2E4R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R0CB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R0CB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.89e-12
R04 N03 N04 1.78e-01
C05 N04 N05 1.90e-12
L05 N04 N05 1.55e-10
C06 N05 Port2 2.50e-11
L06 N05 Port2 1.30e-11
R06 N05 Port2 8.12e+00
.ENDS GQM1875C2E4R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R3BB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R3BB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875C2E4R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R3CB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875C2E4R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R7BB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R7BB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875C2E4R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R7CB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875C2E4R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E560FB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E560FB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.64e-14
R03 N02 N03 5.39e-02
C04 N03 N04 1.35e-10
L04 N03 N04 3.13e-11
R04 N03 N04 1.68e+01
C05 N04 N05 5.58e-11
L05 N04 N05 2.94e-11
R05 N04 N05 2.34e+01
C06 N05 N06 9.39e-11
L06 N05 N06 8.48e-12
R06 N05 N06 9.53e+00
C07 N06 N07 3.31e-11
L07 N06 N07 1.48e-11
R07 N06 N07 2.12e+01
C08 N07 Port2 6.05e-13
L08 N07 Port2 2.54e-10
R08 N07 Port2 7.76e+07
.ENDS GQM1875C2E560FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E560GB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E560GB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.64e-14
R03 N02 N03 5.39e-02
C04 N03 N04 1.35e-10
L04 N03 N04 3.13e-11
R04 N03 N04 1.68e+01
C05 N04 N05 5.58e-11
L05 N04 N05 2.94e-11
R05 N04 N05 2.34e+01
C06 N05 N06 9.39e-11
L06 N05 N06 8.48e-12
R06 N05 N06 9.53e+00
C07 N06 N07 3.31e-11
L07 N06 N07 1.48e-11
R07 N06 N07 2.12e+01
C08 N07 Port2 6.05e-13
L08 N07 Port2 2.54e-10
R08 N07 Port2 7.76e+07
.ENDS GQM1875C2E560GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E560JB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E560JB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.64e-14
R03 N02 N03 5.39e-02
C04 N03 N04 1.35e-10
L04 N03 N04 3.13e-11
R04 N03 N04 1.68e+01
C05 N04 N05 5.58e-11
L05 N04 N05 2.94e-11
R05 N04 N05 2.34e+01
C06 N05 N06 9.39e-11
L06 N05 N06 8.48e-12
R06 N05 N06 9.53e+00
C07 N06 N07 3.31e-11
L07 N06 N07 1.48e-11
R07 N06 N07 2.12e+01
C08 N07 Port2 6.05e-13
L08 N07 Port2 2.54e-10
R08 N07 Port2 7.76e+07
.ENDS GQM1875C2E560JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R0BB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875C2E5R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R0CB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875C2E5R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R1CB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875C2E5R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R1DB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R1DB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875C2E5R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R6CB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R6CB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875C2E5R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R6DB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R6DB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875C2E5R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E680FB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E680FB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 5.20e-02
C04 N03 N04 1.67e-10
L04 N03 N04 3.04e-11
R04 N03 N04 1.40e+01
C05 N04 N05 7.07e-11
L05 N04 N05 2.77e-11
R05 N04 N05 1.79e+01
C06 N05 N06 1.14e-10
L06 N05 N06 8.26e-12
R06 N05 N06 5.90e+00
C07 N06 N07 4.78e-11
L07 N06 N07 1.21e-11
R07 N06 N07 1.21e+01
C08 N07 N08 9.96e-11
L08 N07 N08 3.83e-12
R08 N07 N08 5.27e+00
C09 N08 Port2 1.36e-12
L09 N08 Port2 1.57e-10
R09 N08 Port2 1.58e+08
.ENDS GQM1875C2E680FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E680GB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E680GB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 5.20e-02
C04 N03 N04 1.67e-10
L04 N03 N04 3.04e-11
R04 N03 N04 1.40e+01
C05 N04 N05 7.07e-11
L05 N04 N05 2.77e-11
R05 N04 N05 1.79e+01
C06 N05 N06 1.14e-10
L06 N05 N06 8.26e-12
R06 N05 N06 5.90e+00
C07 N06 N07 4.78e-11
L07 N06 N07 1.21e-11
R07 N06 N07 1.21e+01
C08 N07 N08 9.96e-11
L08 N07 N08 3.83e-12
R08 N07 N08 5.27e+00
C09 N08 Port2 1.36e-12
L09 N08 Port2 1.57e-10
R09 N08 Port2 1.58e+08
.ENDS GQM1875C2E680GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E680JB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E680JB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 5.20e-02
C04 N03 N04 1.67e-10
L04 N03 N04 3.04e-11
R04 N03 N04 1.40e+01
C05 N04 N05 7.07e-11
L05 N04 N05 2.77e-11
R05 N04 N05 1.79e+01
C06 N05 N06 1.14e-10
L06 N05 N06 8.26e-12
R06 N05 N06 5.90e+00
C07 N06 N07 4.78e-11
L07 N06 N07 1.21e-11
R07 N06 N07 1.21e+01
C08 N07 N08 9.96e-11
L08 N07 N08 3.83e-12
R08 N07 N08 5.27e+00
C09 N08 Port2 1.36e-12
L09 N08 Port2 1.57e-10
R09 N08 Port2 1.58e+08
.ENDS GQM1875C2E680JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R0CB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875C2E6R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R0DB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R0DB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875C2E6R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R2CB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R2CB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875C2E6R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R2DB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R2DB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875C2E6R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R8CB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R8CB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875C2E6R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R8DB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875C2E6R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R0CB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875C2E7R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R0DB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875C2E7R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R5CB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R5CB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875C2E7R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R5DB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875C2E7R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E820FB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E820FB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.75e-10
R03 N02 N03 4.78e-02
C04 N03 N04 2.13e-10
L04 N03 N04 2.81e-11
R04 N03 N04 1.37e+01
C05 N04 N05 9.45e-11
L05 N04 N05 2.43e-11
R05 N04 N05 1.42e+01
C06 N05 N06 2.16e-10
L06 N05 N06 5.12e-12
R06 N05 N06 4.43e+00
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 7.30e+00
C08 N07 N08 2.29e-10
L08 N07 N08 1.94e-12
R08 N07 N08 2.78e+00
C09 N08 Port2 6.61e-11
L09 N08 Port2 4.86e-12
R09 N08 Port2 1.13e+01
.ENDS GQM1875C2E820FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E820GB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E820GB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.75e-10
R03 N02 N03 4.78e-02
C04 N03 N04 2.13e-10
L04 N03 N04 2.81e-11
R04 N03 N04 1.37e+01
C05 N04 N05 9.45e-11
L05 N04 N05 2.43e-11
R05 N04 N05 1.42e+01
C06 N05 N06 2.16e-10
L06 N05 N06 5.12e-12
R06 N05 N06 4.43e+00
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 7.30e+00
C08 N07 N08 2.29e-10
L08 N07 N08 1.94e-12
R08 N07 N08 2.78e+00
C09 N08 Port2 6.61e-11
L09 N08 Port2 4.86e-12
R09 N08 Port2 1.13e+01
.ENDS GQM1875C2E820GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E820JB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E820JB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.75e-10
R03 N02 N03 4.78e-02
C04 N03 N04 2.13e-10
L04 N03 N04 2.81e-11
R04 N03 N04 1.37e+01
C05 N04 N05 9.45e-11
L05 N04 N05 2.43e-11
R05 N04 N05 1.42e+01
C06 N05 N06 2.16e-10
L06 N05 N06 5.12e-12
R06 N05 N06 4.43e+00
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 7.30e+00
C08 N07 N08 2.29e-10
L08 N07 N08 1.94e-12
R08 N07 N08 2.78e+00
C09 N08 Port2 6.61e-11
L09 N08 Port2 4.86e-12
R09 N08 Port2 1.13e+01
.ENDS GQM1875C2E820JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E8R0CB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E8R0CB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875C2E8R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E8R0DB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875C2E8R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E8R2CB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E8R2CB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875C2E8R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E8R2DB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E8R2DB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875C2E8R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E9R0CB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E9R0CB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875C2E9R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E9R0DB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875C2E9R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E9R1CB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E9R1CB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875C2E9R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E9R1DB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875C2E9R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E100GB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875G2E100GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E100JB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875G2E100JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E100RB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E100RB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875G2E100RB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875G2E110FB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E110FB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875G2E110FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875G2E110GB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875G2E110GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875G2E110JB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875G2E110JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E120FB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E120FB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 5.00e-02
C04 N03 N04 2.78e-11
L04 N03 N04 3.36e-11
R04 N03 N04 5.81e+01
C05 N04 Port2 7.18e-12
L05 N04 Port2 5.26e-11
R05 N04 Port2 1.19e+02
.ENDS GQM1875G2E120FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E120GB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 5.00e-02
C04 N03 N04 2.78e-11
L04 N03 N04 3.36e-11
R04 N03 N04 5.81e+01
C05 N04 Port2 7.18e-12
L05 N04 Port2 5.26e-11
R05 N04 Port2 1.19e+02
.ENDS GQM1875G2E120GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E120JB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E120JB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 5.00e-02
C04 N03 N04 2.78e-11
L04 N03 N04 3.36e-11
R04 N03 N04 5.81e+01
C05 N04 Port2 7.18e-12
L05 N04 Port2 5.26e-11
R05 N04 Port2 1.19e+02
.ENDS GQM1875G2E120JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875G2E130FB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E130FB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E130FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875G2E130GB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E130GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875G2E130JB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E130JB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E130JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875G2E150FB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E150FB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E150FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875G2E150GB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E150GB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E150GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875G2E150JB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E150JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM1875G2E160FB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E160FB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 5.38e-02
L04 N03 N04 4.29e-12
R04 N03 N04 9.31e-02
C05 N04 N05 3.99e-11
L05 N04 N05 3.04e-11
R05 N04 N05 4.24e+01
C06 N05 N06 1.19e-11
L06 N05 N06 4.06e-11
R06 N05 N06 9.15e+01
C07 N06 Port2 1.38e-12
L07 N06 Port2 1.49e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E160FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM1875G2E160GB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E160GB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 5.38e-02
L04 N03 N04 4.29e-12
R04 N03 N04 9.31e-02
C05 N04 N05 3.99e-11
L05 N04 N05 3.04e-11
R05 N04 N05 4.24e+01
C06 N05 N06 1.19e-11
L06 N05 N06 4.06e-11
R06 N05 N06 9.15e+01
C07 N06 Port2 1.38e-12
L07 N06 Port2 1.49e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E160GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM1875G2E160JB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E160JB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 5.38e-02
L04 N03 N04 4.29e-12
R04 N03 N04 9.31e-02
C05 N04 N05 3.99e-11
L05 N04 N05 3.04e-11
R05 N04 N05 4.24e+01
C06 N05 N06 1.19e-11
L06 N05 N06 4.06e-11
R06 N05 N06 9.15e+01
C07 N06 Port2 1.38e-12
L07 N06 Port2 1.49e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E160JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875G2E180FB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E180FB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E180FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875G2E180GB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E180GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875G2E180JB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E180JB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E180JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R0BB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R0BB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875G2E1R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R0CB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875G2E1R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R0DB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R0DB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875G2E1R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R0WB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R0WB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-10
R03 N02 N03 2.80e-01
L04 N03 N04 2.14e-12
R04 N03 N04 5.33e-01
C05 N04 Port2 4.62e-10
L05 N04 Port2 7.16e-13
.ENDS GQM1875G2E1R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R1BB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R1BB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875G2E1R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R1CB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R1CB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875G2E1R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R1DB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R1DB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875G2E1R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R1WB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R1WB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.23e-10
R03 N02 N03 2.70e-01
L04 N03 N04 2.20e-12
R04 N03 N04 2.90e-01
C05 N04 Port2 1.40e-11
L05 N04 Port2 1.80e-11
.ENDS GQM1875G2E1R1WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R2BB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R2BB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875G2E1R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R2CB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875G2E1R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R2DB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R2DB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875G2E1R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R2WB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R2WB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875G2E1R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R3BB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R3BB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875G2E1R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R3CB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R3CB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875G2E1R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R3DB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R3DB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875G2E1R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R3WB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R3WB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.43e-12
R04 N03 N04 1.89e-01
C05 N04 Port2 9.44e-12
L05 N04 Port2 2.63e-11
.ENDS GQM1875G2E1R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R5BB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R5BB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875G2E1R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R5CB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R5CB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875G2E1R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R5DB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R5DB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875G2E1R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R5WB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R5WB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.30e-12
R04 N03 N04 3.04e-01
C05 N04 Port2 5.85e-12
L05 N04 Port2 4.24e-11
.ENDS GQM1875G2E1R5WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R6BB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875G2E1R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R6CB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R6CB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875G2E1R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R6DB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R6DB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875G2E1R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R6WB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R6WB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875G2E1R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R8BB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875G2E1R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R8CB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R8CB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875G2E1R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R8DB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R8DB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875G2E1R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R8WB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R8WB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875G2E1R8WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E200GB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 4.19e-02
C04 N03 N04 4.39e-11
L04 N03 N04 3.40e-11
R04 N03 N04 3.45e+01
C05 N04 N05 1.96e-11
L05 N04 N05 3.01e-11
R05 N04 N05 6.32e+01
C06 N05 N06 3.82e-12
L06 N05 N06 6.50e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 1.77e-11
L07 N06 Port2 1.32e-11
R07 N06 Port2 4.74e+00
.ENDS GQM1875G2E200GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E200JB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E200JB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 4.19e-02
C04 N03 N04 4.39e-11
L04 N03 N04 3.40e-11
R04 N03 N04 3.45e+01
C05 N04 N05 1.96e-11
L05 N04 N05 3.01e-11
R05 N04 N05 6.32e+01
C06 N05 N06 3.82e-12
L06 N05 N06 6.50e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 1.77e-11
L07 N06 Port2 1.32e-11
R07 N06 Port2 4.74e+00
.ENDS GQM1875G2E200JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E220FB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E220FB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E220FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E220GB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E220GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E220JB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E220JB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E220JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875G2E240FB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E240FB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E240FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875G2E240GB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E240GB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E240GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875G2E240JB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E240JB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E240JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875G2E270FB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E270FB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E270FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875G2E270GB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E270GB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E270GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875G2E270JB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E270JB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E270JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R0BB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R0BB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875G2E2R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R0CB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875G2E2R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R0DB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R0DB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875G2E2R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R0WB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R0WB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875G2E2R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R2BB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R2BB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.65e-12
L04 N03 N04 1.40e-10
C05 N04 Port2 7.55e-11
L05 N04 Port2 3.95e-12
R05 N04 Port2 1.41e+00
.ENDS GQM1875G2E2R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R2CB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.65e-12
L04 N03 N04 1.40e-10
C05 N04 Port2 7.55e-11
L05 N04 Port2 3.95e-12
R05 N04 Port2 1.41e+00
.ENDS GQM1875G2E2R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R4BB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875G2E2R4BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R4CB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R4CB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875G2E2R4CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R4DB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R4DB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875G2E2R4DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R4WB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R4WB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875G2E2R4WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R7BB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R7BB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875G2E2R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R7CB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875G2E2R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R7DB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R7DB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875G2E2R7DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R7WB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R7WB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.19e-12
R04 N03 N04 2.76e-02
C05 N04 N05 2.52e-12
L05 N04 N05 9.86e-11
C06 N05 Port2 1.46e-10
L06 N05 Port2 2.40e-12
R06 N05 Port2 4.01e-01
.ENDS GQM1875G2E2R7WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E300FB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E300FB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875G2E300FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E300GB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E300GB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875G2E300GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E300JB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E300JB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875G2E300JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R0BB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R0BB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 1.20e-01
L04 N03 N04 9.29e-13
R04 N03 N04 8.76e-02
C05 N04 N05 1.75e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 3.69e-11
L06 N05 Port2 8.38e-12
R06 N05 Port2 2.40e+00
.ENDS GQM1875G2E3R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R0CB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 1.20e-01
L04 N03 N04 9.29e-13
R04 N03 N04 8.76e-02
C05 N04 N05 1.75e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 3.69e-11
L06 N05 Port2 8.38e-12
R06 N05 Port2 2.40e+00
.ENDS GQM1875G2E3R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R3BB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R3BB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875G2E3R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R3CB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R3CB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875G2E3R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R3DB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R3DB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875G2E3R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R3WB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R3WB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.20e-01
L04 N03 N04 1.05e-12
R04 N03 N04 9.87e-02
C05 N04 N05 1.65e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 7.01e-11
L06 N05 Port2 5.20e-12
R06 N05 Port2 1.14e+00
.ENDS GQM1875G2E3R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R6BB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R6BB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875G2E3R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R6CB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R6CB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875G2E3R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R6DB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R6DB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875G2E3R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R6WB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R6WB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.24e-12
R04 N03 N04 4.08e-02
C05 N04 N05 1.32e-12
L05 N04 N05 1.89e-10
C06 N05 Port2 7.54e-11
L06 N05 Port2 4.65e-12
R06 N05 Port2 1.44e+00
.ENDS GQM1875G2E3R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R9BB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R9BB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875G2E3R9BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R9CB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R9CB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875G2E3R9CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R9DB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R9DB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875G2E3R9DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R9WB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R9WB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.28e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.39e-12
R04 N03 N04 2.13e-02
C05 N04 N05 1.43e-12
L05 N04 N05 1.83e-10
C06 N05 Port2 8.07e-11
L06 N05 Port2 4.34e-12
R06 N05 Port2 1.37e+00
.ENDS GQM1875G2E3R9WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R0BB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.89e-12
R04 N03 N04 1.78e-01
C05 N04 N05 1.90e-12
L05 N04 N05 1.55e-10
C06 N05 Port2 2.50e-11
L06 N05 Port2 1.30e-11
R06 N05 Port2 8.12e+00
.ENDS GQM1875G2E4R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R0CB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R0CB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.89e-12
R04 N03 N04 1.78e-01
C05 N04 N05 1.90e-12
L05 N04 N05 1.55e-10
C06 N05 Port2 2.50e-11
L06 N05 Port2 1.30e-11
R06 N05 Port2 8.12e+00
.ENDS GQM1875G2E4R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R3BB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R3BB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875G2E4R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R3CB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875G2E4R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R3DB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R3DB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875G2E4R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R3WB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R3WB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875G2E4R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R7BB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R7BB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875G2E4R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R7CB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875G2E4R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R7DB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R7DB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875G2E4R7DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R7WB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R7WB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.84e-12
R04 N03 N04 1.73e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 6.30e-12
L06 N05 N06 5.93e-11
R06 N05 N06 1.70e+02
C07 N06 Port2 1.72e-09
L07 N06 Port2 3.09e-13
R07 N06 Port2 6.18e-02
.ENDS GQM1875G2E4R7WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R0BB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875G2E5R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R0CB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875G2E5R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R0DB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R0DB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875G2E5R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R0WB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R0WB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875G2E5R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R1BB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R1BB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875G2E5R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R1CB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875G2E5R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R1DB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R1DB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875G2E5R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R1WB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R1WB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875G2E5R1WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R6BB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R6BB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875G2E5R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R6CB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R6CB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875G2E5R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R6DB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R6DB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875G2E5R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R6WB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R6WB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875G2E5R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R0BB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R0BB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875G2E6R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R0CB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875G2E6R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R0DB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R0DB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875G2E6R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R0WB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R0WB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875G2E6R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R2BB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R2BB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875G2E6R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R2CB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R2CB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875G2E6R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R2DB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R2DB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875G2E6R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R2WB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R2WB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875G2E6R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R8BB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R8BB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875G2E6R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R8CB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R8CB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875G2E6R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R8DB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875G2E6R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R8WB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R8WB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.61e-12
R04 N03 N04 4.91e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.20e-10
C06 N05 N06 2.69e-10
L06 N05 N06 1.39e-12
R06 N05 N06 1.19e+00
C07 N06 Port2 9.47e-12
L07 N06 Port2 5.74e-11
R07 N06 Port2 6.46e+01
.ENDS GQM1875G2E6R8WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R0BB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R0BB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875G2E7R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R0CB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875G2E7R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R0DB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875G2E7R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R0WB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R0WB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875G2E7R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R5BB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R5BB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875G2E7R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R5CB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R5CB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875G2E7R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R5DB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875G2E7R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875G2E7R5WB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E7R5WB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875G2E7R5WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R0BB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R0BB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875G2E8R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R0CB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R0CB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875G2E8R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R0DB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875G2E8R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R0WB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R0WB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875G2E8R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R2BB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R2BB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875G2E8R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R2CB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R2CB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875G2E8R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R2DB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R2DB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875G2E8R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R2WB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R2WB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875G2E8R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R0BB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R0BB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875G2E9R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R0CB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R0CB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875G2E9R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R0DB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875G2E9R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R0WB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R0WB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875G2E9R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R1BB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R1BB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875G2E9R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R1CB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R1CB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875G2E9R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R1DB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875G2E9R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R1WB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R1WB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875G2E9R1WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.98e-12
R04 N03 N04 6.02e-02
C05 N04 N05 1.33e-10
L05 N04 N05 1.15e-11
R05 N04 N05 1.41e+01
C06 N05 N06 1.61e-12
L06 N05 N06 2.04e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 1.14e-11
L07 N06 Port2 2.63e-11
R07 N06 Port2 1.50e+01
.ENDS GQM1882C1H100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.98e-12
R04 N03 N04 6.02e-02
C05 N04 N05 1.33e-10
L05 N04 N05 1.15e-11
R05 N04 N05 1.41e+01
C06 N05 N06 1.61e-12
L06 N05 N06 2.04e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 1.14e-11
L07 N06 Port2 2.63e-11
R07 N06 Port2 1.50e+01
.ENDS GQM1882C1H100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM1882C1H101GB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H101GB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 4.50e-02
C04 N03 N04 6.66e-10
L04 N03 N04 2.12e-11
R04 N03 N04 4.30e+00
C05 N04 N05 1.40e-10
L05 N04 N05 1.26e-11
R05 N04 N05 3.45e+00
C06 N05 N06 2.71e-11
L06 N05 N06 1.94e-11
R06 N05 N06 1.08e+01
C07 N06 N07 2.81e-11
L07 N06 N07 1.17e-11
R07 N06 N07 4.03e+00
C08 N07 Port2 9.41e-13
L08 N07 Port2 2.90e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H101GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM1882C1H101JB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 4.50e-02
C04 N03 N04 6.66e-10
L04 N03 N04 2.12e-11
R04 N03 N04 4.30e+00
C05 N04 N05 1.40e-10
L05 N04 N05 1.26e-11
R05 N04 N05 3.45e+00
C06 N05 N06 2.71e-11
L06 N05 N06 1.94e-11
R06 N05 N06 1.08e+01
C07 N06 N07 2.81e-11
L07 N06 N07 1.17e-11
R07 N06 N07 4.03e+00
C08 N07 Port2 9.41e-13
L08 N07 Port2 2.90e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H101JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 9.57e-02
L04 N03 N04 1.47e-11
R04 N03 N04 1.51e-02
C05 N04 N05 1.74e-10
L05 N04 N05 9.73e-12
R05 N04 N05 1.17e+01
C06 N05 N06 4.93e-12
L06 N05 N06 4.41e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 9.78e-13
L07 N06 Port2 2.03e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 9.57e-02
L04 N03 N04 1.47e-11
R04 N03 N04 1.51e-02
C05 N04 N05 1.74e-10
L05 N04 N05 9.73e-12
R05 N04 N05 1.17e+01
C06 N05 N06 4.93e-12
L06 N05 N06 4.41e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 9.78e-13
L07 N06 Port2 2.03e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 7.17e-02
L04 N03 N04 4.49e-12
R04 N03 N04 6.06e-02
C05 N04 N05 2.34e-10
L05 N04 N05 7.95e-12
R05 N04 N05 9.73e+00
C06 N05 N06 1.18e-11
L06 N05 N06 2.14e-11
R06 N05 N06 6.55e+00
C07 N06 Port2 1.54e-12
L07 N06 Port2 1.24e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 7.17e-02
L04 N03 N04 4.49e-12
R04 N03 N04 6.06e-02
C05 N04 N05 2.34e-10
L05 N04 N05 7.95e-12
R05 N04 N05 9.73e+00
C06 N05 N06 1.18e-11
L06 N05 N06 2.14e-11
R06 N05 N06 6.55e+00
C07 N06 Port2 1.54e-12
L07 N06 Port2 1.24e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 7.34e-02
L04 N03 N04 4.70e-12
R04 N03 N04 1.73e-02
C05 N04 N05 2.27e-10
L05 N04 N05 8.82e-12
R05 N04 N05 8.80e+00
C06 N05 N06 1.43e-12
L06 N05 N06 1.92e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 4.59e-12
L07 N06 Port2 3.84e-11
R07 N06 Port2 9.06e+00
.ENDS GQM1882C1H130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 7.34e-02
L04 N03 N04 4.70e-12
R04 N03 N04 1.73e-02
C05 N04 N05 2.27e-10
L05 N04 N05 8.82e-12
R05 N04 N05 8.80e+00
C06 N05 N06 1.43e-12
L06 N05 N06 1.92e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 4.59e-12
L07 N06 Port2 3.84e-11
R07 N06 Port2 9.06e+00
.ENDS GQM1882C1H130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GQM1882C1H150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.67e-12
R04 N03 N04 7.68e-02
C05 N04 N05 1.94e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.92e-11
L06 N05 N06 1.68e-11
R06 N05 N06 3.54e+00
C07 N06 Port2 8.75e-13
L07 N06 Port2 3.41e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GQM1882C1H150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.67e-12
R04 N03 N04 7.68e-02
C05 N04 N05 1.94e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.92e-11
L06 N05 N06 1.68e-11
R06 N05 N06 3.54e+00
C07 N06 Port2 8.75e-13
L07 N06 Port2 3.41e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 6.79e-02
L04 N03 N04 2.42e-12
R04 N03 N04 2.13e-02
C05 N04 N05 2.54e-10
L05 N04 N05 9.21e-12
R05 N04 N05 9.68e+00
C06 N05 N06 5.78e-12
L06 N05 N06 5.78e-11
R06 N05 N06 2.17e+01
C07 N06 Port2 9.56e-13
L07 N06 Port2 2.75e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 6.79e-02
L04 N03 N04 2.42e-12
R04 N03 N04 2.13e-02
C05 N04 N05 2.54e-10
L05 N04 N05 9.21e-12
R05 N04 N05 9.68e+00
C06 N05 N06 5.78e-12
L06 N05 N06 5.78e-11
R06 N05 N06 2.17e+01
C07 N06 Port2 9.56e-13
L07 N06 Port2 2.75e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GQM1882C1H180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.00e-10
R03 N02 N03 7.67e-02
C04 N03 N04 2.74e-10
L04 N03 N04 9.50e-12
R04 N03 N04 9.28e+00
C05 N04 Port2 2.00e-12
L05 N04 Port2 1.87e-10
R05 N04 Port2 2.24e+02
.ENDS GQM1882C1H180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GQM1882C1H180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.00e-10
R03 N02 N03 7.67e-02
C04 N03 N04 2.74e-10
L04 N03 N04 9.50e-12
R04 N03 N04 9.28e+00
C05 N04 Port2 2.00e-12
L05 N04 Port2 1.87e-10
R05 N04 Port2 2.24e+02
.ENDS GQM1882C1H180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.14e-02
C04 N03 N04 3.56e-10
L04 N03 N04 8.32e-12
R04 N03 N04 6.73e+00
C05 N04 N05 3.71e-12
L05 N04 N05 9.09e-11
R05 N04 N05 6.24e+01
C06 N05 Port2 1.26e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1882C1H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.14e-02
C04 N03 N04 3.56e-10
L04 N03 N04 8.32e-12
R04 N03 N04 6.73e+00
C05 N04 N05 3.71e-12
L05 N04 N05 9.09e-11
R05 N04 N05 6.24e+01
C06 N05 Port2 1.26e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1882C1H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 6.50e-02
L04 N03 N04 5.72e-12
R04 N03 N04 3.85e-01
L05 N04 N05 6.99e-12
R05 N04 N05 6.47e-02
C06 N05 N06 3.05e-10
L06 N05 N06 1.06e-11
R06 N05 N06 8.17e+00
C07 N06 N07 2.05e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 7.98e-13
L08 N07 Port2 4.02e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 6.50e-02
L04 N03 N04 5.72e-12
R04 N03 N04 3.85e-01
L05 N04 N05 6.99e-12
R05 N04 N05 6.47e-02
C06 N05 N06 3.05e-10
L06 N05 N06 1.06e-11
R06 N05 N06 8.17e+00
C07 N06 N07 2.05e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 7.98e-13
L08 N07 Port2 4.02e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM1882C1H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-10
R03 N02 N03 7.55e-02
C04 N03 N04 3.97e-10
L04 N03 N04 8.90e-12
R04 N03 N04 6.15e+00
C05 N04 N05 1.09e-11
L05 N04 N05 2.79e-11
R05 N04 N05 5.25e+00
C06 N05 Port2 1.49e-12
L06 N05 Port2 1.97e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1882C1H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM1882C1H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-10
R03 N02 N03 7.55e-02
C04 N03 N04 3.97e-10
L04 N03 N04 8.90e-12
R04 N03 N04 6.15e+00
C05 N04 N05 1.09e-11
L05 N04 N05 2.79e-11
R05 N04 N05 5.25e+00
C06 N05 Port2 1.49e-12
L06 N05 Port2 1.97e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1882C1H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM1882C1H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 6.62e-02
L04 N03 N04 7.54e-12
R04 N03 N04 5.90e-03
C05 N04 N05 1.74e-10
L05 N04 N05 2.24e-11
R05 N04 N05 1.62e+01
C06 N05 N06 4.63e-11
L06 N05 N06 1.59e-11
R06 N05 N06 1.58e+01
C07 N06 N07 1.13e-10
L07 N06 N07 5.52e-12
R07 N06 N07 5.76e+00
C08 N07 N08 1.71e-12
L08 N07 N08 1.45e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 4.38e-12
L09 N08 Port2 4.83e-11
R09 N08 Port2 3.17e+01
.ENDS GQM1882C1H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM1882C1H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 6.62e-02
L04 N03 N04 7.54e-12
R04 N03 N04 5.90e-03
C05 N04 N05 1.74e-10
L05 N04 N05 2.24e-11
R05 N04 N05 1.62e+01
C06 N05 N06 4.63e-11
L06 N05 N06 1.59e-11
R06 N05 N06 1.58e+01
C07 N06 N07 1.13e-10
L07 N06 N07 5.52e-12
R07 N06 N07 5.76e+00
C08 N07 N08 1.71e-12
L08 N07 N08 1.45e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 4.38e-12
L09 N08 Port2 4.83e-11
R09 N08 Port2 3.17e+01
.ENDS GQM1882C1H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 6.67e-02
L04 N03 N04 1.24e-12
R04 N03 N04 7.83e-03
C05 N04 N05 2.04e-10
L05 N04 N05 2.13e-11
R05 N04 N05 1.60e+01
C06 N05 N06 5.95e-11
L06 N05 N06 1.38e-11
R06 N05 N06 1.25e+01
C07 N06 N07 1.56e-10
L07 N06 N07 4.44e-12
R07 N06 N07 4.47e+00
C08 N07 N08 4.12e-11
L08 N07 N08 7.90e-12
R08 N07 N08 1.44e+00
C09 N08 Port2 1.51e-12
L09 N08 Port2 1.47e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM1882C1H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 6.67e-02
L04 N03 N04 1.24e-12
R04 N03 N04 7.83e-03
C05 N04 N05 2.04e-10
L05 N04 N05 2.13e-11
R05 N04 N05 1.60e+01
C06 N05 N06 5.95e-11
L06 N05 N06 1.38e-11
R06 N05 N06 1.25e+01
C07 N06 N07 1.56e-10
L07 N06 N07 4.44e-12
R07 N06 N07 4.47e+00
C08 N07 N08 4.12e-11
L08 N07 N08 7.90e-12
R08 N07 N08 1.44e+00
C09 N08 Port2 1.51e-12
L09 N08 Port2 1.47e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.66e-12
R03 N02 N03 4.00e-02
L04 N03 N04 1.96e-11
R04 N03 N04 8.56e-01
C05 N04 N05 2.02e-10
L05 N04 N05 2.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 5.34e-11
L06 N05 N06 1.69e-11
R06 N05 N06 1.59e+01
C07 N06 N07 1.13e-10
L07 N06 N07 6.72e-12
R07 N06 N07 6.21e+00
C08 N07 N08 1.32e-10
L08 N07 N08 2.41e-12
R08 N07 N08 1.41e+00
C09 N08 Port2 7.84e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.66e-12
R03 N02 N03 4.00e-02
L04 N03 N04 1.96e-11
R04 N03 N04 8.56e-01
C05 N04 N05 2.02e-10
L05 N04 N05 2.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 5.34e-11
L06 N05 N06 1.69e-11
R06 N05 N06 1.59e+01
C07 N06 N07 1.13e-10
L07 N06 N07 6.72e-12
R07 N06 N07 6.21e+00
C08 N07 N08 1.32e-10
L08 N07 N08 2.41e-12
R08 N07 N08 1.41e+00
C09 N08 Port2 7.84e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.44e-10
R03 N02 N03 6.26e-02
L04 N03 N04 1.63e-12
R04 N03 N04 9.67e-03
C05 N04 N05 2.46e-10
L05 N04 N05 2.11e-11
R05 N04 N05 1.49e+01
C06 N05 N06 8.27e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.04e+01
C07 N06 N07 2.10e-10
L07 N06 N07 3.89e-12
R07 N06 N07 3.33e+00
C08 N07 N08 4.58e-11
L08 N07 N08 6.65e-12
R08 N07 N08 1.17e+00
C09 N08 Port2 4.55e-12
L09 N08 Port2 3.73e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.44e-10
R03 N02 N03 6.26e-02
L04 N03 N04 1.63e-12
R04 N03 N04 9.67e-03
C05 N04 N05 2.46e-10
L05 N04 N05 2.11e-11
R05 N04 N05 1.49e+01
C06 N05 N06 8.27e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.04e+01
C07 N06 N07 2.10e-10
L07 N06 N07 3.89e-12
R07 N06 N07 3.33e+00
C08 N07 N08 4.58e-11
L08 N07 N08 6.65e-12
R08 N07 N08 1.17e+00
C09 N08 Port2 4.55e-12
L09 N08 Port2 3.73e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1882C1H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM1882C1H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 6.35e-02
L04 N03 N04 1.87e-12
R04 N03 N04 2.01e-02
C05 N04 N05 2.34e-10
L05 N04 N05 2.49e-11
R05 N04 N05 1.34e+01
C06 N05 N06 6.63e-11
L06 N05 N06 1.61e-11
R06 N05 N06 1.33e+01
C07 N06 N07 1.44e-10
L07 N06 N07 6.28e-12
R07 N06 N07 5.53e+00
C08 N07 Port2 1.80e-12
L08 N07 Port2 2.15e-10
R08 N07 Port2 4.50e+02
.ENDS GQM1882C1H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM1882C1H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 6.35e-02
L04 N03 N04 1.87e-12
R04 N03 N04 2.01e-02
C05 N04 N05 2.34e-10
L05 N04 N05 2.49e-11
R05 N04 N05 1.34e+01
C06 N05 N06 6.63e-11
L06 N05 N06 1.61e-11
R06 N05 N06 1.33e+01
C07 N06 N07 1.44e-10
L07 N06 N07 6.28e-12
R07 N06 N07 5.53e+00
C08 N07 Port2 1.80e-12
L08 N07 Port2 2.15e-10
R08 N07 Port2 4.50e+02
.ENDS GQM1882C1H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 5.96e-02
L04 N03 N04 5.28e-12
R04 N03 N04 3.60e-02
C05 N04 N05 6.03e-10
L05 N04 N05 1.02e-11
R05 N04 N05 5.79e+00
C06 N05 N06 4.23e-11
L06 N05 N06 1.19e-11
R06 N05 N06 6.00e+00
C07 N06 N07 8.35e-12
L07 N06 N07 3.11e-11
R07 N06 N07 2.47e+01
C08 N07 Port2 2.27e-12
L08 N07 Port2 1.09e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM1882C1H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 5.96e-02
L04 N03 N04 5.28e-12
R04 N03 N04 3.60e-02
C05 N04 N05 6.03e-10
L05 N04 N05 1.02e-11
R05 N04 N05 5.79e+00
C06 N05 N06 4.23e-11
L06 N05 N06 1.19e-11
R06 N05 N06 6.00e+00
C07 N06 N07 8.35e-12
L07 N06 N07 3.11e-11
R07 N06 N07 2.47e+01
C08 N07 Port2 2.27e-12
L08 N07 Port2 1.09e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM1882C1H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.83e-11
R03 N02 N03 5.03e-02
L04 N03 N04 5.75e-12
R04 N03 N04 4.77e-02
C05 N04 N05 4.30e-10
L05 N04 N05 1.53e-11
R05 N04 N05 5.80e+00
C06 N05 N06 2.51e-11
L06 N05 N06 2.17e-11
R06 N05 N06 1.28e+01
C07 N06 N07 2.07e-11
L07 N06 N07 1.63e-11
R07 N06 N07 9.55e+00
C08 N07 Port2 7.96e-13
L08 N07 Port2 3.80e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM1882C1H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.83e-11
R03 N02 N03 5.03e-02
L04 N03 N04 5.75e-12
R04 N03 N04 4.77e-02
C05 N04 N05 4.30e-10
L05 N04 N05 1.53e-11
R05 N04 N05 5.80e+00
C06 N05 N06 2.51e-11
L06 N05 N06 2.17e-11
R06 N05 N06 1.28e+01
C07 N06 N07 2.07e-11
L07 N06 N07 1.63e-11
R07 N06 N07 9.55e+00
C08 N07 Port2 7.96e-13
L08 N07 Port2 3.80e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H510GB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.01e-10
R03 N02 N03 5.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 1.90e-02
C05 N04 N05 6.79e-10
L05 N04 N05 1.08e-11
R05 N04 N05 4.80e+00
C06 N05 N06 2.97e-11
L06 N05 N06 2.03e-11
R06 N05 N06 9.61e+00
C07 N06 N07 2.76e-12
L07 N06 N07 1.24e-10
R07 N06 N07 1.60e+02
C08 N07 Port2 1.06e-12
L08 N07 Port2 2.38e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H510GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H510JB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H510JB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.01e-10
R03 N02 N03 5.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 1.90e-02
C05 N04 N05 6.79e-10
L05 N04 N05 1.08e-11
R05 N04 N05 4.80e+00
C06 N05 N06 2.97e-11
L06 N05 N06 2.03e-11
R06 N05 N06 9.61e+00
C07 N06 N07 2.76e-12
L07 N06 N07 1.24e-10
R07 N06 N07 1.60e+02
C08 N07 Port2 1.06e-12
L08 N07 Port2 2.38e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H510JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H560GB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H560GB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.47e-10
R03 N02 N03 4.75e-02
L04 N03 N04 6.41e-12
R04 N03 N04 2.67e-02
C05 N04 N05 6.98e-10
L05 N04 N05 1.13e-11
R05 N04 N05 5.29e+00
C06 N05 N06 6.59e-11
L06 N05 N06 1.18e-11
R06 N05 N06 5.46e+00
C07 N06 Port2 1.84e-12
L07 N06 Port2 1.97e-10
R07 N06 Port2 3.24e+02
.ENDS GQM1882C1H560GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM1882C1H560JB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.47e-10
R03 N02 N03 4.75e-02
L04 N03 N04 6.41e-12
R04 N03 N04 2.67e-02
C05 N04 N05 6.98e-10
L05 N04 N05 1.13e-11
R05 N04 N05 5.29e+00
C06 N05 N06 6.59e-11
L06 N05 N06 1.18e-11
R06 N05 N06 5.46e+00
C07 N06 Port2 1.84e-12
L07 N06 Port2 1.97e-10
R07 N06 Port2 3.24e+02
.ENDS GQM1882C1H560JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H620GB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 4.82e-02
L04 N03 N04 7.68e-12
R04 N03 N04 2.70e-02
C05 N04 N05 7.48e-10
L05 N04 N05 1.17e-11
R05 N04 N05 4.60e+00
C06 N05 N06 9.89e-11
L06 N05 N06 8.78e-12
R06 N05 N06 3.75e+00
C07 N06 N07 4.71e-12
L07 N06 N07 7.25e-11
R07 N06 N07 6.50e+01
C08 N07 Port2 2.53e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H620GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H620JB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H620JB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 4.82e-02
L04 N03 N04 7.68e-12
R04 N03 N04 2.70e-02
C05 N04 N05 7.48e-10
L05 N04 N05 1.17e-11
R05 N04 N05 4.60e+00
C06 N05 N06 9.89e-11
L06 N05 N06 8.78e-12
R06 N05 N06 3.75e+00
C07 N06 N07 4.71e-12
L07 N06 N07 7.25e-11
R07 N06 N07 6.50e+01
C08 N07 Port2 2.53e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H620JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM1882C1H680GB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H680GB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 4.80e-02
L04 N03 N04 6.31e-12
R04 N03 N04 5.38e-02
C05 N04 N05 7.54e-10
L05 N04 N05 1.29e-11
R05 N04 N05 4.76e+00
C06 N05 N06 7.71e-11
L06 N05 N06 1.21e-11
R06 N05 N06 5.02e+00
C07 N06 N07 1.53e-11
L07 N06 N07 2.19e-11
R07 N06 N07 1.45e+01
C08 N07 Port2 1.48e-12
L08 N07 Port2 2.17e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H680GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM1882C1H680JB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 4.80e-02
L04 N03 N04 6.31e-12
R04 N03 N04 5.38e-02
C05 N04 N05 7.54e-10
L05 N04 N05 1.29e-11
R05 N04 N05 4.76e+00
C06 N05 N06 7.71e-11
L06 N05 N06 1.21e-11
R06 N05 N06 5.02e+00
C07 N06 N07 1.53e-11
L07 N06 N07 2.19e-11
R07 N06 N07 1.45e+01
C08 N07 Port2 1.48e-12
L08 N07 Port2 2.17e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H680JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM1882C1H750GB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H750GB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 4.82e-02
L04 N03 N04 4.02e-12
R04 N03 N04 2.01e-02
C05 N04 N05 7.64e-10
L05 N04 N05 1.37e-11
R05 N04 N05 4.71e+00
C06 N05 N06 1.42e-10
L06 N05 N06 8.54e-12
R06 N05 N06 3.58e+00
C07 N06 N07 3.04e-12
L07 N06 N07 1.18e-10
R07 N06 N07 1.03e+02
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.23e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H750GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM1882C1H750JB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 4.82e-02
L04 N03 N04 4.02e-12
R04 N03 N04 2.01e-02
C05 N04 N05 7.64e-10
L05 N04 N05 1.37e-11
R05 N04 N05 4.71e+00
C06 N05 N06 1.42e-10
L06 N05 N06 8.54e-12
R06 N05 N06 3.58e+00
C07 N06 N07 3.04e-12
L07 N06 N07 1.18e-10
R07 N06 N07 1.03e+02
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.23e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H750JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.53e-12
R04 N03 N04 3.84e-02
C05 N04 N05 1.15e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.80e-11
L06 N05 N06 1.17e-11
R06 N05 N06 6.97e+00
C07 N06 Port2 7.12e-11
L07 N06 Port2 1.53e-11
R07 N06 Port2 1.86e+01
.ENDS GQM1882C1H7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.53e-12
R04 N03 N04 3.84e-02
C05 N04 N05 1.15e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.80e-11
L06 N05 N06 1.17e-11
R06 N05 N06 6.97e+00
C07 N06 Port2 7.12e-11
L07 N06 Port2 1.53e-11
R07 N06 Port2 1.86e+01
.ENDS GQM1882C1H7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GQM1882C1H7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.11e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.75e+01
C05 N04 N05 1.73e-12
L05 N04 N05 1.54e-10
R05 N04 N05 3.22e+03
C06 N05 Port2 6.77e-12
L06 N05 Port2 2.69e-11
R06 N05 Port2 6.48e+00
.ENDS GQM1882C1H7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GQM1882C1H7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.11e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.75e+01
C05 N04 N05 1.73e-12
L05 N04 N05 1.54e-10
R05 N04 N05 3.22e+03
C06 N05 Port2 6.77e-12
L06 N05 Port2 2.69e-11
R06 N05 Port2 6.48e+00
.ENDS GQM1882C1H7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H820GB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H820GB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 5.27e-02
C04 N03 N04 9.10e-10
L04 N03 N04 1.26e-11
R04 N03 N04 4.66e+00
C05 N04 N05 1.48e-10
L05 N04 N05 8.95e-12
R05 N04 N05 3.49e+00
C06 N05 N06 4.44e-12
L06 N05 N06 8.72e-11
R06 N05 N06 8.31e+01
C07 N06 Port2 1.71e-12
L07 N06 Port2 1.94e-10
R07 N06 Port2 7.76e+02
.ENDS GQM1882C1H820GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM1882C1H820JB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H820JB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 5.27e-02
C04 N03 N04 9.10e-10
L04 N03 N04 1.26e-11
R04 N03 N04 4.66e+00
C05 N04 N05 1.48e-10
L05 N04 N05 8.95e-12
R05 N04 N05 3.49e+00
C06 N05 N06 4.44e-12
L06 N05 N06 8.72e-11
R06 N05 N06 8.31e+01
C07 N06 Port2 1.71e-12
L07 N06 Port2 1.94e-10
R07 N06 Port2 7.76e+02
.ENDS GQM1882C1H820JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.48e-12
R04 N03 N04 3.72e-02
L05 N04 N05 1.49e-11
R05 N04 N05 2.80e+00
C06 N05 N06 1.05e-12
L06 N05 N06 2.80e-10
C07 N06 N07 5.00e-11
L07 N06 N07 7.16e-12
R07 N06 N07 4.26e+00
C08 N07 Port2 9.54e-11
L08 N07 Port2 1.31e-11
R08 N07 Port2 1.52e+01
.ENDS GQM1882C1H8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.48e-12
R04 N03 N04 3.72e-02
L05 N04 N05 1.49e-11
R05 N04 N05 2.80e+00
C06 N05 N06 1.05e-12
L06 N05 N06 2.80e-10
C07 N06 N07 5.00e-11
L07 N06 N07 7.16e-12
R07 N06 N07 4.26e+00
C08 N07 Port2 9.54e-11
L08 N07 Port2 1.31e-11
R08 N07 Port2 1.52e+01
.ENDS GQM1882C1H8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GQM1882C1H8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-11
R03 N02 N03 9.35e-02
L04 N03 N04 2.93e-12
R04 N03 N04 3.28e-02
C05 N04 N05 8.56e-11
L05 N04 N05 1.51e-11
R05 N04 N05 1.92e+01
C06 N05 N06 2.34e-11
L06 N05 N06 1.41e-11
R06 N05 N06 7.02e+00
C07 N06 Port2 5.17e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GQM1882C1H8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-11
R03 N02 N03 9.35e-02
L04 N03 N04 2.93e-12
R04 N03 N04 3.28e-02
C05 N04 N05 8.56e-11
L05 N04 N05 1.51e-11
R05 N04 N05 1.92e+01
C06 N05 N06 2.34e-11
L06 N05 N06 1.41e-11
R06 N05 N06 7.02e+00
C07 N06 Port2 5.17e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H910GB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H910GB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-10
R03 N02 N03 5.22e-02
C04 N03 N04 7.94e-10
L04 N03 N04 1.61e-11
R04 N03 N04 4.51e+00
C05 N04 N05 1.34e-10
L05 N04 N05 1.19e-11
R05 N04 N05 2.98e+00
C06 N05 N06 3.14e-11
L06 N05 N06 1.53e-11
R06 N05 N06 7.78e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 1.83e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H910GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM1882C1H910JB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-10
R03 N02 N03 5.22e-02
C04 N03 N04 7.94e-10
L04 N03 N04 1.61e-11
R04 N03 N04 4.51e+00
C05 N04 N05 1.34e-10
L05 N04 N05 1.19e-11
R05 N04 N05 2.98e+00
C06 N05 N06 3.14e-11
L06 N05 N06 1.53e-11
R06 N05 N06 7.78e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 1.83e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H910JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 4.00e-02
L04 N03 N04 9.75e-12
R04 N03 N04 1.38e-01
C05 N04 N05 1.12e-10
L05 N04 N05 1.24e-11
R05 N04 N05 1.53e+01
C06 N05 N06 5.04e-12
L06 N05 N06 6.70e-11
R06 N05 N06 7.89e+01
C07 N06 N07 1.32e-12
L07 N06 N07 2.37e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-12
L08 N07 Port2 4.27e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GQM1882C1H9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 4.00e-02
L04 N03 N04 9.75e-12
R04 N03 N04 1.38e-01
C05 N04 N05 1.12e-10
L05 N04 N05 1.24e-11
R05 N04 N05 1.53e+01
C06 N05 N06 5.04e-12
L06 N05 N06 6.70e-11
R06 N05 N06 7.89e+01
C07 N06 N07 1.32e-12
L07 N06 N07 2.37e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-12
L08 N07 Port2 4.27e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1882C1H9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GQM1882C1H9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 8.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 4.41e-02
C05 N04 N05 1.02e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 1.03e-11
L06 N05 N06 3.32e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.25e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GQM1882C1H9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C1H9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 8.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 4.41e-02
C05 N04 N05 1.02e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 1.03e-11
L06 N05 N06 3.32e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.25e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C1H9R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.74e-12
R04 N03 N04 6.88e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 4.79e-11
L07 N06 Port2 1.29e-11
R07 N06 Port2 1.95e+01
.ENDS GQM1882C2A4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.74e-12
R04 N03 N04 6.88e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 4.79e-11
L07 N06 Port2 1.29e-11
R07 N06 Port2 1.95e+01
.ENDS GQM1882C2A4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.63e-12
R04 N03 N04 4.81e-02
C05 N04 N05 4.40e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.31e+01
C06 N05 N06 2.43e-11
L06 N05 N06 1.32e-11
R06 N05 N06 8.35e+00
C07 N06 Port2 1.05e-12
L07 N06 Port2 1.89e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.63e-12
R04 N03 N04 4.81e-02
C05 N04 N05 4.40e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.31e+01
C06 N05 N06 2.43e-11
L06 N05 N06 1.32e-11
R06 N05 N06 8.35e+00
C07 N06 Port2 1.05e-12
L07 N06 Port2 1.89e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.30e-01
L04 N03 N04 6.62e-13
R04 N03 N04 3.12e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.40e-10
C06 N05 N06 2.00e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 5.05e-11
L07 N06 Port2 1.44e-11
R07 N06 Port2 2.87e+01
.ENDS GQM1882C2A4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM1882C2A4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.30e-01
L04 N03 N04 6.62e-13
R04 N03 N04 3.12e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.40e-10
C06 N05 N06 2.00e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 5.05e-11
L07 N06 Port2 1.44e-11
R07 N06 Port2 2.87e+01
.ENDS GQM1882C2A4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 1.25e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.15e-12
L05 N04 N05 2.60e-10
C06 N05 N06 1.85e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 4.87e-11
L07 N06 Port2 1.62e-11
R07 N06 Port2 2.33e+01
.ENDS GQM1882C2A5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 1.25e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.15e-12
L05 N04 N05 2.60e-10
C06 N05 N06 1.85e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 4.87e-11
L07 N06 Port2 1.62e-11
R07 N06 Port2 2.33e+01
.ENDS GQM1882C2A5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.96e-12
R04 N03 N04 7.53e-02
C05 N04 N05 5.16e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.27e+01
C06 N05 N06 7.53e-11
L06 N05 N06 4.28e-12
R06 N05 N06 2.16e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.50e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.96e-12
R04 N03 N04 7.53e-02
C05 N04 N05 5.16e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.27e+01
C06 N05 N06 7.53e-11
L06 N05 N06 4.28e-12
R06 N05 N06 2.16e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.50e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.52e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.17e-12
R04 N03 N04 6.85e-02
C05 N04 N05 6.04e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.47e+01
C06 N05 N06 8.77e-11
L06 N05 N06 3.26e-12
R06 N05 N06 1.00e+00
C07 N06 Port2 4.86e-12
L07 N06 Port2 5.69e-11
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM1882C2A5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.52e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.17e-12
R04 N03 N04 6.85e-02
C05 N04 N05 6.04e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.47e+01
C06 N05 N06 8.77e-11
L06 N05 N06 3.26e-12
R06 N05 N06 1.00e+00
C07 N06 Port2 4.86e-12
L07 N06 Port2 5.69e-11
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 1.20e-01
C05 N03 N04 1.13e-12
L05 N03 N04 2.70e-10
C06 N04 N05 8.20e-12
L06 N04 N05 4.10e-11
R06 N04 N05 2.44e+01
C07 N05 Port2 8.15e-11
L07 N05 Port2 1.18e-11
R07 N05 Port2 1.95e+01
.ENDS GQM1882C2A6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 1.20e-01
C05 N03 N04 1.13e-12
L05 N03 N04 2.70e-10
C06 N04 N05 8.20e-12
L06 N04 N05 4.10e-11
R06 N04 N05 2.44e+01
C07 N05 Port2 8.15e-11
L07 N05 Port2 1.18e-11
R07 N05 Port2 1.95e+01
.ENDS GQM1882C2A6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.14e-11
R03 N02 N03 1.19e-01
L04 N03 N04 1.70e-12
R04 N03 N04 6.13e-02
C05 N04 N05 7.79e-11
L05 N04 N05 1.22e-11
R05 N04 N05 2.38e+01
C06 N05 N06 2.66e-11
L06 N05 N06 1.18e-11
R06 N05 N06 3.41e+00
C07 N06 Port2 4.59e-13
L07 N06 Port2 4.13e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.14e-11
R03 N02 N03 1.19e-01
L04 N03 N04 1.70e-12
R04 N03 N04 6.13e-02
C05 N04 N05 7.79e-11
L05 N04 N05 1.22e-11
R05 N04 N05 2.38e+01
C06 N05 N06 2.66e-11
L06 N05 N06 1.18e-11
R06 N05 N06 3.41e+00
C07 N06 Port2 4.59e-13
L07 N06 Port2 4.13e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1882C2A6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 1.15e-01
L04 N03 N04 5.91e-13
R04 N03 N04 5.84e-02
C05 N04 N05 1.05e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.40e-11
L06 N05 N06 1.45e-11
R06 N05 N06 8.64e+00
C07 N06 Port2 8.77e-11
L07 N06 Port2 1.18e-11
R07 N06 Port2 1.82e+01
.ENDS GQM1882C2A6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM1882C2A6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1882C2A6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 1.15e-01
L04 N03 N04 5.91e-13
R04 N03 N04 5.84e-02
C05 N04 N05 1.05e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.40e-11
L06 N05 N06 1.45e-11
R06 N05 N06 8.64e+00
C07 N06 Port2 8.77e-11
L07 N06 Port2 1.18e-11
R07 N06 Port2 1.82e+01
.ENDS GQM1882C2A6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 1.80e-01
L04 N03 N04 4.78e-12
R04 N03 N04 2.80e-01
C05 N04 N05 1.80e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 1.64e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 6.00e+01
.ENDS GQM1883C2A2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 1.80e-01
L04 N03 N04 4.78e-12
R04 N03 N04 2.80e-01
C05 N04 N05 1.80e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 1.64e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 6.00e+01
.ENDS GQM1883C2A2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.12e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.62e-12
R04 N03 N04 7.53e-02
C05 N04 Port2 2.92e-11
L05 N04 Port2 1.31e-11
R05 N04 Port2 3.68e+01
.ENDS GQM1883C2A2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.12e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.62e-12
R04 N03 N04 7.53e-02
C05 N04 Port2 2.92e-11
L05 N04 Port2 1.31e-11
R05 N04 Port2 3.68e+01
.ENDS GQM1883C2A2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.69e-10
R03 N02 N03 1.74e-01
L04 N03 N04 2.00e-12
R04 N03 N04 1.62e-01
C05 N04 N05 2.24e-11
L05 N04 N05 1.88e-11
R05 N04 N05 5.72e+01
C06 N05 Port2 1.84e-11
L06 N05 Port2 1.78e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1883C2A2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM1883C2A2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.69e-10
R03 N02 N03 1.74e-01
L04 N03 N04 2.00e-12
R04 N03 N04 1.62e-01
C05 N04 N05 2.24e-11
L05 N04 N05 1.88e-11
R05 N04 N05 5.72e+01
C06 N05 Port2 1.84e-11
L06 N05 Port2 1.78e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1883C2A2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.70e-01
C05 N03 N04 1.63e-12
L05 N03 N04 1.65e-10
C06 N04 N05 9.90e-11
L06 N04 N05 4.00e-12
R06 N04 N05 8.00e-01
C07 N05 Port2 2.08e-11
L07 N05 Port2 2.24e-11
R07 N05 Port2 6.97e+01
.ENDS GQM1883C2A3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.70e-01
C05 N03 N04 1.63e-12
L05 N03 N04 1.65e-10
C06 N04 N05 9.90e-11
L06 N04 N05 4.00e-12
R06 N04 N05 8.00e-01
C07 N05 Port2 2.08e-11
L07 N05 Port2 2.24e-11
R07 N05 Port2 6.97e+01
.ENDS GQM1883C2A3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.40e-10
R03 N02 N03 1.50e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.35e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 2.17e-11
L07 N06 Port2 2.39e-11
R07 N06 Port2 6.12e+01
.ENDS GQM1883C2A3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.40e-10
R03 N02 N03 1.50e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.35e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 2.17e-11
L07 N06 Port2 2.39e-11
R07 N06 Port2 6.12e+01
.ENDS GQM1883C2A3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.42e-01
L04 N03 N04 8.40e-13
R04 N03 N04 2.84e-02
C05 N04 N05 3.12e-11
L05 N04 N05 1.80e-11
R05 N04 N05 4.45e+01
C06 N05 N06 3.28e-11
L06 N05 N06 9.92e-12
R06 N05 N06 2.55e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 2.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1883C2A3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.42e-01
L04 N03 N04 8.40e-13
R04 N03 N04 2.84e-02
C05 N04 N05 3.12e-11
L05 N04 N05 1.80e-11
R05 N04 N05 4.45e+01
C06 N05 N06 3.28e-11
L06 N05 N06 9.92e-12
R06 N05 N06 2.55e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 2.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1883C2A3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 1.34e-01
L04 N03 N04 1.85e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.86e-11
L05 N04 N05 1.58e-11
R05 N04 N05 4.46e+01
C06 N05 N06 3.83e-11
L06 N05 N06 8.62e-12
R06 N05 N06 6.73e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1883C2A3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CJ(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM1883C2A3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1883C2A3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 1.34e-01
L04 N03 N04 1.85e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.86e-11
L05 N04 N05 1.58e-11
R05 N04 N05 4.46e+01
C06 N05 N06 3.83e-11
L06 N05 N06 8.62e-12
R06 N05 N06 6.73e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1883C2A3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.10e-10
R03 N02 N03 2.50e-01
L04 N03 N04 6.83e-12
R04 N03 N04 6.44e-01
C05 N04 N05 8.68e-12
L05 N04 N05 3.17e-11
C06 N05 Port2 1.08e-10
L06 N05 Port2 2.62e-12
R06 N05 Port2 1.63e+00
.ENDS GQM1884C2A1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.10e-10
R03 N02 N03 2.50e-01
L04 N03 N04 6.83e-12
R04 N03 N04 6.44e-01
C05 N04 N05 8.68e-12
L05 N04 N05 3.17e-11
C06 N05 Port2 1.08e-10
L06 N05 Port2 2.62e-12
R06 N05 Port2 1.63e+00
.ENDS GQM1884C2A1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.92e-10
R03 N02 N03 2.19e-01
L04 N03 Port2 4.81e-12
R04 N03 Port2 5.77e-02
.ENDS GQM1884C2A1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.92e-10
R03 N02 N03 2.19e-01
L04 N03 Port2 4.81e-12
R04 N03 Port2 5.77e-02
.ENDS GQM1884C2A1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.90e-10
R03 N02 N03 2.08e-01
L04 N03 N04 3.26e-12
R04 N03 N04 4.54e-02
C05 N04 Port2 6.46e-11
L05 N04 Port2 4.73e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1884C2A1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.90e-10
R03 N02 N03 2.08e-01
L04 N03 N04 3.26e-12
R04 N03 N04 4.54e-02
C05 N04 Port2 6.46e-11
L05 N04 Port2 4.73e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1884C2A1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 2.05e-01
L04 N03 N04 2.62e-12
R04 N03 N04 3.68e-02
C05 N04 Port2 8.48e-11
L05 N04 Port2 3.88e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1884C2A1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 2.05e-01
L04 N03 N04 2.62e-12
R04 N03 N04 3.68e-02
C05 N04 Port2 8.48e-11
L05 N04 Port2 3.88e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1884C2A1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 1.45e-01
L04 N03 N04 6.33e-12
R04 N03 N04 1.13e+00
C05 N04 N05 1.75e-12
L05 N04 N05 1.40e-10
C06 N05 Port2 8.00e-11
L06 N05 Port2 3.80e-12
R06 N05 Port2 9.48e-01
.ENDS GQM1884C2A1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 1.45e-01
L04 N03 N04 6.33e-12
R04 N03 N04 1.13e+00
C05 N04 N05 1.75e-12
L05 N04 N05 1.40e-10
C06 N05 Port2 8.00e-11
L06 N05 Port2 3.80e-12
R06 N05 Port2 9.48e-01
.ENDS GQM1884C2A1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.17e-12
R04 N03 N04 1.41e-02
C05 N04 Port2 8.81e-12
L05 N04 Port2 2.64e-11
R05 N04 Port2 8.44e+01
.ENDS GQM1884C2A1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.17e-12
R04 N03 N04 1.41e-02
C05 N04 Port2 8.81e-12
L05 N04 Port2 2.64e-11
R05 N04 Port2 8.44e+01
.ENDS GQM1884C2A1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.73e-10
R03 N02 N03 1.95e-01
L04 N03 N04 1.49e-12
R04 N03 N04 8.85e-03
C05 N04 N05 3.65e-11
L05 N04 N05 7.19e-12
R05 N04 N05 3.49e+00
C06 N05 Port2 2.57e-12
L06 N05 Port2 9.33e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1884C2A1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM1884C2A1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.73e-10
R03 N02 N03 1.95e-01
L04 N03 N04 1.49e-12
R04 N03 N04 8.85e-03
C05 N04 N05 3.65e-11
L05 N04 N05 7.19e-12
R05 N04 N05 3.49e+00
C06 N05 Port2 2.57e-12
L06 N05 Port2 9.33e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1884C2A1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM1884C2A2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.90e-01
C05 N03 N04 1.70e-12
L05 N03 N04 1.70e-10
C06 N04 Port2 1.97e-11
L06 N04 Port2 1.72e-11
R06 N04 Port2 1.50e+01
.ENDS GQM1884C2A2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CK(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM1884C2A2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1884C2A2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.90e-01
C05 N03 N04 1.70e-12
L05 N03 N04 1.70e-10
C06 N04 Port2 1.97e-11
L06 N04 Port2 1.72e-11
R06 N04 Port2 1.50e+01
.ENDS GQM1884C2A2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.98e-12
R04 N03 N04 6.02e-02
C05 N04 N05 1.33e-10
L05 N04 N05 1.15e-11
R05 N04 N05 1.41e+01
C06 N05 N06 1.61e-12
L06 N05 N06 2.04e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 1.14e-11
L07 N06 Port2 2.63e-11
R07 N06 Port2 1.50e+01
.ENDS GQM1885C1H100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.98e-12
R04 N03 N04 6.02e-02
C05 N04 N05 1.33e-10
L05 N04 N05 1.15e-11
R05 N04 N05 1.41e+01
C06 N05 N06 1.61e-12
L06 N05 N06 2.04e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 1.14e-11
L07 N06 Port2 2.63e-11
R07 N06 Port2 1.50e+01
.ENDS GQM1885C1H100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM1885C1H101GB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H101GB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 4.50e-02
C04 N03 N04 6.66e-10
L04 N03 N04 2.12e-11
R04 N03 N04 4.30e+00
C05 N04 N05 1.40e-10
L05 N04 N05 1.26e-11
R05 N04 N05 3.45e+00
C06 N05 N06 2.71e-11
L06 N05 N06 1.94e-11
R06 N05 N06 1.08e+01
C07 N06 N07 2.81e-11
L07 N06 N07 1.17e-11
R07 N06 N07 4.03e+00
C08 N07 Port2 9.41e-13
L08 N07 Port2 2.90e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H101GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM1885C1H101JB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 4.50e-02
C04 N03 N04 6.66e-10
L04 N03 N04 2.12e-11
R04 N03 N04 4.30e+00
C05 N04 N05 1.40e-10
L05 N04 N05 1.26e-11
R05 N04 N05 3.45e+00
C06 N05 N06 2.71e-11
L06 N05 N06 1.94e-11
R06 N05 N06 1.08e+01
C07 N06 N07 2.81e-11
L07 N06 N07 1.17e-11
R07 N06 N07 4.03e+00
C08 N07 Port2 9.41e-13
L08 N07 Port2 2.90e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H101JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 9.57e-02
L04 N03 N04 1.47e-11
R04 N03 N04 1.51e-02
C05 N04 N05 1.74e-10
L05 N04 N05 9.73e-12
R05 N04 N05 1.17e+01
C06 N05 N06 4.93e-12
L06 N05 N06 4.41e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 9.78e-13
L07 N06 Port2 2.03e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 9.57e-02
L04 N03 N04 1.47e-11
R04 N03 N04 1.51e-02
C05 N04 N05 1.74e-10
L05 N04 N05 9.73e-12
R05 N04 N05 1.17e+01
C06 N05 N06 4.93e-12
L06 N05 N06 4.41e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 9.78e-13
L07 N06 Port2 2.03e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 7.17e-02
L04 N03 N04 4.49e-12
R04 N03 N04 6.06e-02
C05 N04 N05 2.34e-10
L05 N04 N05 7.95e-12
R05 N04 N05 9.73e+00
C06 N05 N06 1.18e-11
L06 N05 N06 2.14e-11
R06 N05 N06 6.55e+00
C07 N06 Port2 1.54e-12
L07 N06 Port2 1.24e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 7.17e-02
L04 N03 N04 4.49e-12
R04 N03 N04 6.06e-02
C05 N04 N05 2.34e-10
L05 N04 N05 7.95e-12
R05 N04 N05 9.73e+00
C06 N05 N06 1.18e-11
L06 N05 N06 2.14e-11
R06 N05 N06 6.55e+00
C07 N06 Port2 1.54e-12
L07 N06 Port2 1.24e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 7.34e-02
L04 N03 N04 4.70e-12
R04 N03 N04 1.73e-02
C05 N04 N05 2.27e-10
L05 N04 N05 8.82e-12
R05 N04 N05 8.80e+00
C06 N05 N06 1.43e-12
L06 N05 N06 1.92e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 4.59e-12
L07 N06 Port2 3.84e-11
R07 N06 Port2 9.06e+00
.ENDS GQM1885C1H130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.67e-10
R03 N02 N03 7.34e-02
L04 N03 N04 4.70e-12
R04 N03 N04 1.73e-02
C05 N04 N05 2.27e-10
L05 N04 N05 8.82e-12
R05 N04 N05 8.80e+00
C06 N05 N06 1.43e-12
L06 N05 N06 1.92e-10
R06 N05 N06 1.00e+05
C07 N06 Port2 4.59e-12
L07 N06 Port2 3.84e-11
R07 N06 Port2 9.06e+00
.ENDS GQM1885C1H130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GQM1885C1H150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.67e-12
R04 N03 N04 7.68e-02
C05 N04 N05 1.94e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.92e-11
L06 N05 N06 1.68e-11
R06 N05 N06 3.54e+00
C07 N06 Port2 8.75e-13
L07 N06 Port2 3.41e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GQM1885C1H150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.67e-12
R04 N03 N04 7.68e-02
C05 N04 N05 1.94e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.92e-11
L06 N05 N06 1.68e-11
R06 N05 N06 3.54e+00
C07 N06 Port2 8.75e-13
L07 N06 Port2 3.41e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 6.79e-02
L04 N03 N04 2.42e-12
R04 N03 N04 2.13e-02
C05 N04 N05 2.54e-10
L05 N04 N05 9.21e-12
R05 N04 N05 9.68e+00
C06 N05 N06 5.78e-12
L06 N05 N06 5.78e-11
R06 N05 N06 2.17e+01
C07 N06 Port2 9.56e-13
L07 N06 Port2 2.75e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 6.79e-02
L04 N03 N04 2.42e-12
R04 N03 N04 2.13e-02
C05 N04 N05 2.54e-10
L05 N04 N05 9.21e-12
R05 N04 N05 9.68e+00
C06 N05 N06 5.78e-12
L06 N05 N06 5.78e-11
R06 N05 N06 2.17e+01
C07 N06 Port2 9.56e-13
L07 N06 Port2 2.75e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GQM1885C1H180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.00e-10
R03 N02 N03 7.67e-02
C04 N03 N04 2.74e-10
L04 N03 N04 9.50e-12
R04 N03 N04 9.28e+00
C05 N04 Port2 2.00e-12
L05 N04 Port2 1.87e-10
R05 N04 Port2 2.24e+02
.ENDS GQM1885C1H180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GQM1885C1H180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.00e-10
R03 N02 N03 7.67e-02
C04 N03 N04 2.74e-10
L04 N03 N04 9.50e-12
R04 N03 N04 9.28e+00
C05 N04 Port2 2.00e-12
L05 N04 Port2 1.87e-10
R05 N04 Port2 2.24e+02
.ENDS GQM1885C1H180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.14e-02
C04 N03 N04 3.56e-10
L04 N03 N04 8.32e-12
R04 N03 N04 6.73e+00
C05 N04 N05 3.71e-12
L05 N04 N05 9.09e-11
R05 N04 N05 6.24e+01
C06 N05 Port2 1.26e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1885C1H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.14e-02
C04 N03 N04 3.56e-10
L04 N03 N04 8.32e-12
R04 N03 N04 6.73e+00
C05 N04 N05 3.71e-12
L05 N04 N05 9.09e-11
R05 N04 N05 6.24e+01
C06 N05 Port2 1.26e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1885C1H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 6.50e-02
L04 N03 N04 5.72e-12
R04 N03 N04 3.85e-01
L05 N04 N05 6.99e-12
R05 N04 N05 6.47e-02
C06 N05 N06 3.05e-10
L06 N05 N06 1.06e-11
R06 N05 N06 8.17e+00
C07 N06 N07 2.05e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 7.98e-13
L08 N07 Port2 4.02e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 6.50e-02
L04 N03 N04 5.72e-12
R04 N03 N04 3.85e-01
L05 N04 N05 6.99e-12
R05 N04 N05 6.47e-02
C06 N05 N06 3.05e-10
L06 N05 N06 1.06e-11
R06 N05 N06 8.17e+00
C07 N06 N07 2.05e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 7.98e-13
L08 N07 Port2 4.02e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM1885C1H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-10
R03 N02 N03 7.55e-02
C04 N03 N04 3.97e-10
L04 N03 N04 8.90e-12
R04 N03 N04 6.15e+00
C05 N04 N05 1.09e-11
L05 N04 N05 2.79e-11
R05 N04 N05 5.25e+00
C06 N05 Port2 1.49e-12
L06 N05 Port2 1.97e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1885C1H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM1885C1H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-10
R03 N02 N03 7.55e-02
C04 N03 N04 3.97e-10
L04 N03 N04 8.90e-12
R04 N03 N04 6.15e+00
C05 N04 N05 1.09e-11
L05 N04 N05 2.79e-11
R05 N04 N05 5.25e+00
C06 N05 Port2 1.49e-12
L06 N05 Port2 1.97e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1885C1H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM1885C1H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 6.62e-02
L04 N03 N04 7.54e-12
R04 N03 N04 5.90e-03
C05 N04 N05 1.74e-10
L05 N04 N05 2.24e-11
R05 N04 N05 1.62e+01
C06 N05 N06 4.63e-11
L06 N05 N06 1.59e-11
R06 N05 N06 1.58e+01
C07 N06 N07 1.13e-10
L07 N06 N07 5.52e-12
R07 N06 N07 5.76e+00
C08 N07 N08 1.71e-12
L08 N07 N08 1.45e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 4.38e-12
L09 N08 Port2 4.83e-11
R09 N08 Port2 3.17e+01
.ENDS GQM1885C1H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM1885C1H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 6.62e-02
L04 N03 N04 7.54e-12
R04 N03 N04 5.90e-03
C05 N04 N05 1.74e-10
L05 N04 N05 2.24e-11
R05 N04 N05 1.62e+01
C06 N05 N06 4.63e-11
L06 N05 N06 1.59e-11
R06 N05 N06 1.58e+01
C07 N06 N07 1.13e-10
L07 N06 N07 5.52e-12
R07 N06 N07 5.76e+00
C08 N07 N08 1.71e-12
L08 N07 N08 1.45e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 4.38e-12
L09 N08 Port2 4.83e-11
R09 N08 Port2 3.17e+01
.ENDS GQM1885C1H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 6.67e-02
L04 N03 N04 1.24e-12
R04 N03 N04 7.83e-03
C05 N04 N05 2.04e-10
L05 N04 N05 2.13e-11
R05 N04 N05 1.60e+01
C06 N05 N06 5.95e-11
L06 N05 N06 1.38e-11
R06 N05 N06 1.25e+01
C07 N06 N07 1.56e-10
L07 N06 N07 4.44e-12
R07 N06 N07 4.47e+00
C08 N07 N08 4.12e-11
L08 N07 N08 7.90e-12
R08 N07 N08 1.44e+00
C09 N08 Port2 1.51e-12
L09 N08 Port2 1.47e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM1885C1H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 6.67e-02
L04 N03 N04 1.24e-12
R04 N03 N04 7.83e-03
C05 N04 N05 2.04e-10
L05 N04 N05 2.13e-11
R05 N04 N05 1.60e+01
C06 N05 N06 5.95e-11
L06 N05 N06 1.38e-11
R06 N05 N06 1.25e+01
C07 N06 N07 1.56e-10
L07 N06 N07 4.44e-12
R07 N06 N07 4.47e+00
C08 N07 N08 4.12e-11
L08 N07 N08 7.90e-12
R08 N07 N08 1.44e+00
C09 N08 Port2 1.51e-12
L09 N08 Port2 1.47e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.66e-12
R03 N02 N03 4.00e-02
L04 N03 N04 1.96e-11
R04 N03 N04 8.56e-01
C05 N04 N05 2.02e-10
L05 N04 N05 2.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 5.34e-11
L06 N05 N06 1.69e-11
R06 N05 N06 1.59e+01
C07 N06 N07 1.13e-10
L07 N06 N07 6.72e-12
R07 N06 N07 6.21e+00
C08 N07 N08 1.32e-10
L08 N07 N08 2.41e-12
R08 N07 N08 1.41e+00
C09 N08 Port2 7.84e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.66e-12
R03 N02 N03 4.00e-02
L04 N03 N04 1.96e-11
R04 N03 N04 8.56e-01
C05 N04 N05 2.02e-10
L05 N04 N05 2.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 5.34e-11
L06 N05 N06 1.69e-11
R06 N05 N06 1.59e+01
C07 N06 N07 1.13e-10
L07 N06 N07 6.72e-12
R07 N06 N07 6.21e+00
C08 N07 N08 1.32e-10
L08 N07 N08 2.41e-12
R08 N07 N08 1.41e+00
C09 N08 Port2 7.84e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.44e-10
R03 N02 N03 6.26e-02
L04 N03 N04 1.63e-12
R04 N03 N04 9.67e-03
C05 N04 N05 2.46e-10
L05 N04 N05 2.11e-11
R05 N04 N05 1.49e+01
C06 N05 N06 8.27e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.04e+01
C07 N06 N07 2.10e-10
L07 N06 N07 3.89e-12
R07 N06 N07 3.33e+00
C08 N07 N08 4.58e-11
L08 N07 N08 6.65e-12
R08 N07 N08 1.17e+00
C09 N08 Port2 4.55e-12
L09 N08 Port2 3.73e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.44e-10
R03 N02 N03 6.26e-02
L04 N03 N04 1.63e-12
R04 N03 N04 9.67e-03
C05 N04 N05 2.46e-10
L05 N04 N05 2.11e-11
R05 N04 N05 1.49e+01
C06 N05 N06 8.27e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.04e+01
C07 N06 N07 2.10e-10
L07 N06 N07 3.89e-12
R07 N06 N07 3.33e+00
C08 N07 N08 4.58e-11
L08 N07 N08 6.65e-12
R08 N07 N08 1.17e+00
C09 N08 Port2 4.55e-12
L09 N08 Port2 3.73e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1885C1H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM1885C1H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 6.35e-02
L04 N03 N04 1.87e-12
R04 N03 N04 2.01e-02
C05 N04 N05 2.34e-10
L05 N04 N05 2.49e-11
R05 N04 N05 1.34e+01
C06 N05 N06 6.63e-11
L06 N05 N06 1.61e-11
R06 N05 N06 1.33e+01
C07 N06 N07 1.44e-10
L07 N06 N07 6.28e-12
R07 N06 N07 5.53e+00
C08 N07 Port2 1.80e-12
L08 N07 Port2 2.15e-10
R08 N07 Port2 4.50e+02
.ENDS GQM1885C1H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM1885C1H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 6.35e-02
L04 N03 N04 1.87e-12
R04 N03 N04 2.01e-02
C05 N04 N05 2.34e-10
L05 N04 N05 2.49e-11
R05 N04 N05 1.34e+01
C06 N05 N06 6.63e-11
L06 N05 N06 1.61e-11
R06 N05 N06 1.33e+01
C07 N06 N07 1.44e-10
L07 N06 N07 6.28e-12
R07 N06 N07 5.53e+00
C08 N07 Port2 1.80e-12
L08 N07 Port2 2.15e-10
R08 N07 Port2 4.50e+02
.ENDS GQM1885C1H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 5.96e-02
L04 N03 N04 5.28e-12
R04 N03 N04 3.60e-02
C05 N04 N05 6.03e-10
L05 N04 N05 1.02e-11
R05 N04 N05 5.79e+00
C06 N05 N06 4.23e-11
L06 N05 N06 1.19e-11
R06 N05 N06 6.00e+00
C07 N06 N07 8.35e-12
L07 N06 N07 3.11e-11
R07 N06 N07 2.47e+01
C08 N07 Port2 2.27e-12
L08 N07 Port2 1.09e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM1885C1H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 5.96e-02
L04 N03 N04 5.28e-12
R04 N03 N04 3.60e-02
C05 N04 N05 6.03e-10
L05 N04 N05 1.02e-11
R05 N04 N05 5.79e+00
C06 N05 N06 4.23e-11
L06 N05 N06 1.19e-11
R06 N05 N06 6.00e+00
C07 N06 N07 8.35e-12
L07 N06 N07 3.11e-11
R07 N06 N07 2.47e+01
C08 N07 Port2 2.27e-12
L08 N07 Port2 1.09e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM1885C1H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.83e-11
R03 N02 N03 5.03e-02
L04 N03 N04 5.75e-12
R04 N03 N04 4.77e-02
C05 N04 N05 4.30e-10
L05 N04 N05 1.53e-11
R05 N04 N05 5.80e+00
C06 N05 N06 2.51e-11
L06 N05 N06 2.17e-11
R06 N05 N06 1.28e+01
C07 N06 N07 2.07e-11
L07 N06 N07 1.63e-11
R07 N06 N07 9.55e+00
C08 N07 Port2 7.96e-13
L08 N07 Port2 3.80e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM1885C1H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.83e-11
R03 N02 N03 5.03e-02
L04 N03 N04 5.75e-12
R04 N03 N04 4.77e-02
C05 N04 N05 4.30e-10
L05 N04 N05 1.53e-11
R05 N04 N05 5.80e+00
C06 N05 N06 2.51e-11
L06 N05 N06 2.17e-11
R06 N05 N06 1.28e+01
C07 N06 N07 2.07e-11
L07 N06 N07 1.63e-11
R07 N06 N07 9.55e+00
C08 N07 Port2 7.96e-13
L08 N07 Port2 3.80e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H510GB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.01e-10
R03 N02 N03 5.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 1.90e-02
C05 N04 N05 6.79e-10
L05 N04 N05 1.08e-11
R05 N04 N05 4.80e+00
C06 N05 N06 2.97e-11
L06 N05 N06 2.03e-11
R06 N05 N06 9.61e+00
C07 N06 N07 2.76e-12
L07 N06 N07 1.24e-10
R07 N06 N07 1.60e+02
C08 N07 Port2 1.06e-12
L08 N07 Port2 2.38e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H510GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H510JB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H510JB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.01e-10
R03 N02 N03 5.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 1.90e-02
C05 N04 N05 6.79e-10
L05 N04 N05 1.08e-11
R05 N04 N05 4.80e+00
C06 N05 N06 2.97e-11
L06 N05 N06 2.03e-11
R06 N05 N06 9.61e+00
C07 N06 N07 2.76e-12
L07 N06 N07 1.24e-10
R07 N06 N07 1.60e+02
C08 N07 Port2 1.06e-12
L08 N07 Port2 2.38e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H510JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H560GB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H560GB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.47e-10
R03 N02 N03 4.75e-02
L04 N03 N04 6.41e-12
R04 N03 N04 2.67e-02
C05 N04 N05 6.98e-10
L05 N04 N05 1.13e-11
R05 N04 N05 5.29e+00
C06 N05 N06 6.59e-11
L06 N05 N06 1.18e-11
R06 N05 N06 5.46e+00
C07 N06 Port2 1.84e-12
L07 N06 Port2 1.97e-10
R07 N06 Port2 3.24e+02
.ENDS GQM1885C1H560GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM1885C1H560JB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.47e-10
R03 N02 N03 4.75e-02
L04 N03 N04 6.41e-12
R04 N03 N04 2.67e-02
C05 N04 N05 6.98e-10
L05 N04 N05 1.13e-11
R05 N04 N05 5.29e+00
C06 N05 N06 6.59e-11
L06 N05 N06 1.18e-11
R06 N05 N06 5.46e+00
C07 N06 Port2 1.84e-12
L07 N06 Port2 1.97e-10
R07 N06 Port2 3.24e+02
.ENDS GQM1885C1H560JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H620GB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 4.82e-02
L04 N03 N04 7.68e-12
R04 N03 N04 2.70e-02
C05 N04 N05 7.48e-10
L05 N04 N05 1.17e-11
R05 N04 N05 4.60e+00
C06 N05 N06 9.89e-11
L06 N05 N06 8.78e-12
R06 N05 N06 3.75e+00
C07 N06 N07 4.71e-12
L07 N06 N07 7.25e-11
R07 N06 N07 6.50e+01
C08 N07 Port2 2.53e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H620GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H620JB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H620JB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 4.82e-02
L04 N03 N04 7.68e-12
R04 N03 N04 2.70e-02
C05 N04 N05 7.48e-10
L05 N04 N05 1.17e-11
R05 N04 N05 4.60e+00
C06 N05 N06 9.89e-11
L06 N05 N06 8.78e-12
R06 N05 N06 3.75e+00
C07 N06 N07 4.71e-12
L07 N06 N07 7.25e-11
R07 N06 N07 6.50e+01
C08 N07 Port2 2.53e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H620JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM1885C1H680GB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H680GB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 4.80e-02
L04 N03 N04 6.31e-12
R04 N03 N04 5.38e-02
C05 N04 N05 7.54e-10
L05 N04 N05 1.29e-11
R05 N04 N05 4.76e+00
C06 N05 N06 7.71e-11
L06 N05 N06 1.21e-11
R06 N05 N06 5.02e+00
C07 N06 N07 1.53e-11
L07 N06 N07 2.19e-11
R07 N06 N07 1.45e+01
C08 N07 Port2 1.48e-12
L08 N07 Port2 2.17e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H680GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM1885C1H680JB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 4.80e-02
L04 N03 N04 6.31e-12
R04 N03 N04 5.38e-02
C05 N04 N05 7.54e-10
L05 N04 N05 1.29e-11
R05 N04 N05 4.76e+00
C06 N05 N06 7.71e-11
L06 N05 N06 1.21e-11
R06 N05 N06 5.02e+00
C07 N06 N07 1.53e-11
L07 N06 N07 2.19e-11
R07 N06 N07 1.45e+01
C08 N07 Port2 1.48e-12
L08 N07 Port2 2.17e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H680JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM1885C1H750GB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H750GB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 4.82e-02
L04 N03 N04 4.02e-12
R04 N03 N04 2.01e-02
C05 N04 N05 7.64e-10
L05 N04 N05 1.37e-11
R05 N04 N05 4.71e+00
C06 N05 N06 1.42e-10
L06 N05 N06 8.54e-12
R06 N05 N06 3.58e+00
C07 N06 N07 3.04e-12
L07 N06 N07 1.18e-10
R07 N06 N07 1.03e+02
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.23e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H750GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM1885C1H750JB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 4.82e-02
L04 N03 N04 4.02e-12
R04 N03 N04 2.01e-02
C05 N04 N05 7.64e-10
L05 N04 N05 1.37e-11
R05 N04 N05 4.71e+00
C06 N05 N06 1.42e-10
L06 N05 N06 8.54e-12
R06 N05 N06 3.58e+00
C07 N06 N07 3.04e-12
L07 N06 N07 1.18e-10
R07 N06 N07 1.03e+02
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.23e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H750JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.53e-12
R04 N03 N04 3.84e-02
C05 N04 N05 1.15e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.80e-11
L06 N05 N06 1.17e-11
R06 N05 N06 6.97e+00
C07 N06 Port2 7.12e-11
L07 N06 Port2 1.53e-11
R07 N06 Port2 1.86e+01
.ENDS GQM1885C1H7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.53e-12
R04 N03 N04 3.84e-02
C05 N04 N05 1.15e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.80e-11
L06 N05 N06 1.17e-11
R06 N05 N06 6.97e+00
C07 N06 Port2 7.12e-11
L07 N06 Port2 1.53e-11
R07 N06 Port2 1.86e+01
.ENDS GQM1885C1H7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GQM1885C1H7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.11e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.75e+01
C05 N04 N05 1.73e-12
L05 N04 N05 1.54e-10
R05 N04 N05 3.22e+03
C06 N05 Port2 6.77e-12
L06 N05 Port2 2.69e-11
R06 N05 Port2 6.48e+00
.ENDS GQM1885C1H7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GQM1885C1H7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.11e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.75e+01
C05 N04 N05 1.73e-12
L05 N04 N05 1.54e-10
R05 N04 N05 3.22e+03
C06 N05 Port2 6.77e-12
L06 N05 Port2 2.69e-11
R06 N05 Port2 6.48e+00
.ENDS GQM1885C1H7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H820GB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H820GB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 5.27e-02
C04 N03 N04 9.10e-10
L04 N03 N04 1.26e-11
R04 N03 N04 4.66e+00
C05 N04 N05 1.48e-10
L05 N04 N05 8.95e-12
R05 N04 N05 3.49e+00
C06 N05 N06 4.44e-12
L06 N05 N06 8.72e-11
R06 N05 N06 8.31e+01
C07 N06 Port2 1.71e-12
L07 N06 Port2 1.94e-10
R07 N06 Port2 7.76e+02
.ENDS GQM1885C1H820GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM1885C1H820JB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H820JB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 5.27e-02
C04 N03 N04 9.10e-10
L04 N03 N04 1.26e-11
R04 N03 N04 4.66e+00
C05 N04 N05 1.48e-10
L05 N04 N05 8.95e-12
R05 N04 N05 3.49e+00
C06 N05 N06 4.44e-12
L06 N05 N06 8.72e-11
R06 N05 N06 8.31e+01
C07 N06 Port2 1.71e-12
L07 N06 Port2 1.94e-10
R07 N06 Port2 7.76e+02
.ENDS GQM1885C1H820JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.48e-12
R04 N03 N04 3.72e-02
L05 N04 N05 1.49e-11
R05 N04 N05 2.80e+00
C06 N05 N06 1.05e-12
L06 N05 N06 2.80e-10
C07 N06 N07 5.00e-11
L07 N06 N07 7.16e-12
R07 N06 N07 4.26e+00
C08 N07 Port2 9.54e-11
L08 N07 Port2 1.31e-11
R08 N07 Port2 1.52e+01
.ENDS GQM1885C1H8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.48e-12
R04 N03 N04 3.72e-02
L05 N04 N05 1.49e-11
R05 N04 N05 2.80e+00
C06 N05 N06 1.05e-12
L06 N05 N06 2.80e-10
C07 N06 N07 5.00e-11
L07 N06 N07 7.16e-12
R07 N06 N07 4.26e+00
C08 N07 Port2 9.54e-11
L08 N07 Port2 1.31e-11
R08 N07 Port2 1.52e+01
.ENDS GQM1885C1H8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GQM1885C1H8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-11
R03 N02 N03 9.35e-02
L04 N03 N04 2.93e-12
R04 N03 N04 3.28e-02
C05 N04 N05 8.56e-11
L05 N04 N05 1.51e-11
R05 N04 N05 1.92e+01
C06 N05 N06 2.34e-11
L06 N05 N06 1.41e-11
R06 N05 N06 7.02e+00
C07 N06 Port2 5.17e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GQM1885C1H8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-11
R03 N02 N03 9.35e-02
L04 N03 N04 2.93e-12
R04 N03 N04 3.28e-02
C05 N04 N05 8.56e-11
L05 N04 N05 1.51e-11
R05 N04 N05 1.92e+01
C06 N05 N06 2.34e-11
L06 N05 N06 1.41e-11
R06 N05 N06 7.02e+00
C07 N06 Port2 5.17e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H910GB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H910GB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-10
R03 N02 N03 5.22e-02
C04 N03 N04 7.94e-10
L04 N03 N04 1.61e-11
R04 N03 N04 4.51e+00
C05 N04 N05 1.34e-10
L05 N04 N05 1.19e-11
R05 N04 N05 2.98e+00
C06 N05 N06 3.14e-11
L06 N05 N06 1.53e-11
R06 N05 N06 7.78e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 1.83e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H910GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM1885C1H910JB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-10
R03 N02 N03 5.22e-02
C04 N03 N04 7.94e-10
L04 N03 N04 1.61e-11
R04 N03 N04 4.51e+00
C05 N04 N05 1.34e-10
L05 N04 N05 1.19e-11
R05 N04 N05 2.98e+00
C06 N05 N06 3.14e-11
L06 N05 N06 1.53e-11
R06 N05 N06 7.78e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 1.83e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H910JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 4.00e-02
L04 N03 N04 9.75e-12
R04 N03 N04 1.38e-01
C05 N04 N05 1.12e-10
L05 N04 N05 1.24e-11
R05 N04 N05 1.53e+01
C06 N05 N06 5.04e-12
L06 N05 N06 6.70e-11
R06 N05 N06 7.89e+01
C07 N06 N07 1.32e-12
L07 N06 N07 2.37e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-12
L08 N07 Port2 4.27e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GQM1885C1H9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 4.00e-02
L04 N03 N04 9.75e-12
R04 N03 N04 1.38e-01
C05 N04 N05 1.12e-10
L05 N04 N05 1.24e-11
R05 N04 N05 1.53e+01
C06 N05 N06 5.04e-12
L06 N05 N06 6.70e-11
R06 N05 N06 7.89e+01
C07 N06 N07 1.32e-12
L07 N06 N07 2.37e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-12
L08 N07 Port2 4.27e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1885C1H9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GQM1885C1H9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 8.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 4.41e-02
C05 N04 N05 1.02e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 1.03e-11
L06 N05 N06 3.32e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.25e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GQM1885C1H9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C1H9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 8.73e-02
L04 N03 N04 3.64e-12
R04 N03 N04 4.41e-02
C05 N04 N05 1.02e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.47e+01
C06 N05 N06 1.03e-11
L06 N05 N06 3.32e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.25e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C1H9R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.10e-10
R03 N02 N03 2.50e-01
L04 N03 N04 6.83e-12
R04 N03 N04 6.44e-01
C05 N04 N05 8.68e-12
L05 N04 N05 3.17e-11
C06 N05 Port2 1.08e-10
L06 N05 Port2 2.62e-12
R06 N05 Port2 1.63e+00
.ENDS GQM1885C2A1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.10e-10
R03 N02 N03 2.50e-01
L04 N03 N04 6.83e-12
R04 N03 N04 6.44e-01
C05 N04 N05 8.68e-12
L05 N04 N05 3.17e-11
C06 N05 Port2 1.08e-10
L06 N05 Port2 2.62e-12
R06 N05 Port2 1.63e+00
.ENDS GQM1885C2A1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.92e-10
R03 N02 N03 2.19e-01
L04 N03 Port2 4.81e-12
R04 N03 Port2 5.77e-02
.ENDS GQM1885C2A1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.92e-10
R03 N02 N03 2.19e-01
L04 N03 Port2 4.81e-12
R04 N03 Port2 5.77e-02
.ENDS GQM1885C2A1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.90e-10
R03 N02 N03 2.08e-01
L04 N03 N04 3.26e-12
R04 N03 N04 4.54e-02
C05 N04 Port2 6.46e-11
L05 N04 Port2 4.73e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1885C2A1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.90e-10
R03 N02 N03 2.08e-01
L04 N03 N04 3.26e-12
R04 N03 N04 4.54e-02
C05 N04 Port2 6.46e-11
L05 N04 Port2 4.73e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1885C2A1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 2.05e-01
L04 N03 N04 2.62e-12
R04 N03 N04 3.68e-02
C05 N04 Port2 8.48e-11
L05 N04 Port2 3.88e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1885C2A1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 2.05e-01
L04 N03 N04 2.62e-12
R04 N03 N04 3.68e-02
C05 N04 Port2 8.48e-11
L05 N04 Port2 3.88e-12
R05 N04 Port2 1.00e+05
.ENDS GQM1885C2A1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 1.45e-01
L04 N03 N04 6.33e-12
R04 N03 N04 1.13e+00
C05 N04 N05 1.75e-12
L05 N04 N05 1.40e-10
C06 N05 Port2 8.00e-11
L06 N05 Port2 3.80e-12
R06 N05 Port2 9.48e-01
.ENDS GQM1885C2A1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 1.45e-01
L04 N03 N04 6.33e-12
R04 N03 N04 1.13e+00
C05 N04 N05 1.75e-12
L05 N04 N05 1.40e-10
C06 N05 Port2 8.00e-11
L06 N05 Port2 3.80e-12
R06 N05 Port2 9.48e-01
.ENDS GQM1885C2A1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.17e-12
R04 N03 N04 1.41e-02
C05 N04 Port2 8.81e-12
L05 N04 Port2 2.64e-11
R05 N04 Port2 8.44e+01
.ENDS GQM1885C2A1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.17e-12
R04 N03 N04 1.41e-02
C05 N04 Port2 8.81e-12
L05 N04 Port2 2.64e-11
R05 N04 Port2 8.44e+01
.ENDS GQM1885C2A1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.73e-10
R03 N02 N03 1.95e-01
L04 N03 N04 1.49e-12
R04 N03 N04 8.85e-03
C05 N04 N05 3.65e-11
L05 N04 N05 7.19e-12
R05 N04 N05 3.49e+00
C06 N05 Port2 2.57e-12
L06 N05 Port2 9.33e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1885C2A1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM1885C2A1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.73e-10
R03 N02 N03 1.95e-01
L04 N03 N04 1.49e-12
R04 N03 N04 8.85e-03
C05 N04 N05 3.65e-11
L05 N04 N05 7.19e-12
R05 N04 N05 3.49e+00
C06 N05 Port2 2.57e-12
L06 N05 Port2 9.33e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1885C2A1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.90e-01
C05 N03 N04 1.70e-12
L05 N03 N04 1.70e-10
C06 N04 Port2 1.97e-11
L06 N04 Port2 1.72e-11
R06 N04 Port2 1.50e+01
.ENDS GQM1885C2A2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.90e-01
C05 N03 N04 1.70e-12
L05 N03 N04 1.70e-10
C06 N04 Port2 1.97e-11
L06 N04 Port2 1.72e-11
R06 N04 Port2 1.50e+01
.ENDS GQM1885C2A2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 1.80e-01
L04 N03 N04 4.78e-12
R04 N03 N04 2.80e-01
C05 N04 N05 1.80e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 1.64e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 6.00e+01
.ENDS GQM1885C2A2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.58e-10
R03 N02 N03 1.80e-01
L04 N03 N04 4.78e-12
R04 N03 N04 2.80e-01
C05 N04 N05 1.80e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 1.64e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 6.00e+01
.ENDS GQM1885C2A2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.12e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.62e-12
R04 N03 N04 7.53e-02
C05 N04 Port2 2.92e-11
L05 N04 Port2 1.31e-11
R05 N04 Port2 3.68e+01
.ENDS GQM1885C2A2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.12e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.62e-12
R04 N03 N04 7.53e-02
C05 N04 Port2 2.92e-11
L05 N04 Port2 1.31e-11
R05 N04 Port2 3.68e+01
.ENDS GQM1885C2A2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.69e-10
R03 N02 N03 1.74e-01
L04 N03 N04 2.00e-12
R04 N03 N04 1.62e-01
C05 N04 N05 2.24e-11
L05 N04 N05 1.88e-11
R05 N04 N05 5.72e+01
C06 N05 Port2 1.84e-11
L06 N05 Port2 1.78e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1885C2A2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM1885C2A2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.69e-10
R03 N02 N03 1.74e-01
L04 N03 N04 2.00e-12
R04 N03 N04 1.62e-01
C05 N04 N05 2.24e-11
L05 N04 N05 1.88e-11
R05 N04 N05 5.72e+01
C06 N05 Port2 1.84e-11
L06 N05 Port2 1.78e-11
R06 N05 Port2 1.00e+05
.ENDS GQM1885C2A2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.70e-01
C05 N03 N04 1.63e-12
L05 N03 N04 1.65e-10
C06 N04 N05 9.90e-11
L06 N04 N05 4.00e-12
R06 N04 N05 8.00e-01
C07 N05 Port2 2.08e-11
L07 N05 Port2 2.24e-11
R07 N05 Port2 6.97e+01
.ENDS GQM1885C2A3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.70e-01
C05 N03 N04 1.63e-12
L05 N03 N04 1.65e-10
C06 N04 N05 9.90e-11
L06 N04 N05 4.00e-12
R06 N04 N05 8.00e-01
C07 N05 Port2 2.08e-11
L07 N05 Port2 2.24e-11
R07 N05 Port2 6.97e+01
.ENDS GQM1885C2A3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.40e-10
R03 N02 N03 1.50e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.35e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 2.17e-11
L07 N06 Port2 2.39e-11
R07 N06 Port2 6.12e+01
.ENDS GQM1885C2A3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.40e-10
R03 N02 N03 1.50e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.35e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 2.17e-11
L07 N06 Port2 2.39e-11
R07 N06 Port2 6.12e+01
.ENDS GQM1885C2A3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.42e-01
L04 N03 N04 8.40e-13
R04 N03 N04 2.84e-02
C05 N04 N05 3.12e-11
L05 N04 N05 1.80e-11
R05 N04 N05 4.45e+01
C06 N05 N06 3.28e-11
L06 N05 N06 9.92e-12
R06 N05 N06 2.55e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 2.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.42e-01
L04 N03 N04 8.40e-13
R04 N03 N04 2.84e-02
C05 N04 N05 3.12e-11
L05 N04 N05 1.80e-11
R05 N04 N05 4.45e+01
C06 N05 N06 3.28e-11
L06 N05 N06 9.92e-12
R06 N05 N06 2.55e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 2.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 1.34e-01
L04 N03 N04 1.85e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.86e-11
L05 N04 N05 1.58e-11
R05 N04 N05 4.46e+01
C06 N05 N06 3.83e-11
L06 N05 N06 8.62e-12
R06 N05 N06 6.73e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM1885C2A3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 1.34e-01
L04 N03 N04 1.85e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.86e-11
L05 N04 N05 1.58e-11
R05 N04 N05 4.46e+01
C06 N05 N06 3.83e-11
L06 N05 N06 8.62e-12
R06 N05 N06 6.73e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.74e-12
R04 N03 N04 6.88e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 4.79e-11
L07 N06 Port2 1.29e-11
R07 N06 Port2 1.95e+01
.ENDS GQM1885C2A4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.74e-12
R04 N03 N04 6.88e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.10e-10
C06 N05 N06 1.65e-10
L06 N05 N06 2.28e-12
R06 N05 N06 1.36e+00
C07 N06 Port2 4.79e-11
L07 N06 Port2 1.29e-11
R07 N06 Port2 1.95e+01
.ENDS GQM1885C2A4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.63e-12
R04 N03 N04 4.81e-02
C05 N04 N05 4.40e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.31e+01
C06 N05 N06 2.43e-11
L06 N05 N06 1.32e-11
R06 N05 N06 8.35e+00
C07 N06 Port2 1.05e-12
L07 N06 Port2 1.89e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.77e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.63e-12
R04 N03 N04 4.81e-02
C05 N04 N05 4.40e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.31e+01
C06 N05 N06 2.43e-11
L06 N05 N06 1.32e-11
R06 N05 N06 8.35e+00
C07 N06 Port2 1.05e-12
L07 N06 Port2 1.89e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.30e-01
L04 N03 N04 6.62e-13
R04 N03 N04 3.12e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.40e-10
C06 N05 N06 2.00e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 5.05e-11
L07 N06 Port2 1.44e-11
R07 N06 Port2 2.87e+01
.ENDS GQM1885C2A4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM1885C2A4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.30e-01
L04 N03 N04 6.62e-13
R04 N03 N04 3.12e-02
C05 N04 N05 1.28e-12
L05 N04 N05 2.40e-10
C06 N05 N06 2.00e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 5.05e-11
L07 N06 Port2 1.44e-11
R07 N06 Port2 2.87e+01
.ENDS GQM1885C2A4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 1.25e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.15e-12
L05 N04 N05 2.60e-10
C06 N05 N06 1.85e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 4.87e-11
L07 N06 Port2 1.62e-11
R07 N06 Port2 2.33e+01
.ENDS GQM1885C2A5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 1.25e-01
L04 N03 N04 3.93e-12
R04 N03 N04 1.85e-01
C05 N04 N05 1.15e-12
L05 N04 N05 2.60e-10
C06 N05 N06 1.85e-11
L06 N05 N06 1.75e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 4.87e-11
L07 N06 Port2 1.62e-11
R07 N06 Port2 2.33e+01
.ENDS GQM1885C2A5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.96e-12
R04 N03 N04 7.53e-02
C05 N04 N05 5.16e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.27e+01
C06 N05 N06 7.53e-11
L06 N05 N06 4.28e-12
R06 N05 N06 2.16e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.50e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.96e-12
R04 N03 N04 7.53e-02
C05 N04 N05 5.16e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.27e+01
C06 N05 N06 7.53e-11
L06 N05 N06 4.28e-12
R06 N05 N06 2.16e+00
C07 N06 Port2 1.68e-12
L07 N06 Port2 1.50e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.52e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.17e-12
R04 N03 N04 6.85e-02
C05 N04 N05 6.04e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.47e+01
C06 N05 N06 8.77e-11
L06 N05 N06 3.26e-12
R06 N05 N06 1.00e+00
C07 N06 Port2 4.86e-12
L07 N06 Port2 5.69e-11
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM1885C2A5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.52e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.17e-12
R04 N03 N04 6.85e-02
C05 N04 N05 6.04e-11
L05 N04 N05 1.49e-11
R05 N04 N05 2.47e+01
C06 N05 N06 8.77e-11
L06 N05 N06 3.26e-12
R06 N05 N06 1.00e+00
C07 N06 Port2 4.86e-12
L07 N06 Port2 5.69e-11
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 1.20e-01
C05 N03 N04 1.13e-12
L05 N03 N04 2.70e-10
C06 N04 N05 8.20e-12
L06 N04 N05 4.10e-11
R06 N04 N05 2.44e+01
C07 N05 Port2 8.15e-11
L07 N05 Port2 1.18e-11
R07 N05 Port2 1.95e+01
.ENDS GQM1885C2A6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 1.20e-01
C05 N03 N04 1.13e-12
L05 N03 N04 2.70e-10
C06 N04 N05 8.20e-12
L06 N04 N05 4.10e-11
R06 N04 N05 2.44e+01
C07 N05 Port2 8.15e-11
L07 N05 Port2 1.18e-11
R07 N05 Port2 1.95e+01
.ENDS GQM1885C2A6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.14e-11
R03 N02 N03 1.19e-01
L04 N03 N04 1.70e-12
R04 N03 N04 6.13e-02
C05 N04 N05 7.79e-11
L05 N04 N05 1.22e-11
R05 N04 N05 2.38e+01
C06 N05 N06 2.66e-11
L06 N05 N06 1.18e-11
R06 N05 N06 3.41e+00
C07 N06 Port2 4.59e-13
L07 N06 Port2 4.13e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.14e-11
R03 N02 N03 1.19e-01
L04 N03 N04 1.70e-12
R04 N03 N04 6.13e-02
C05 N04 N05 7.79e-11
L05 N04 N05 1.22e-11
R05 N04 N05 2.38e+01
C06 N05 N06 2.66e-11
L06 N05 N06 1.18e-11
R06 N05 N06 3.41e+00
C07 N06 Port2 4.59e-13
L07 N06 Port2 4.13e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1885C2A6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 1.15e-01
L04 N03 N04 5.91e-13
R04 N03 N04 5.84e-02
C05 N04 N05 1.05e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.40e-11
L06 N05 N06 1.45e-11
R06 N05 N06 8.64e+00
C07 N06 Port2 8.77e-11
L07 N06 Port2 1.18e-11
R07 N06 Port2 1.82e+01
.ENDS GQM1885C2A6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM1885C2A6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1885C2A6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 1.15e-01
L04 N03 N04 5.91e-13
R04 N03 N04 5.84e-02
C05 N04 N05 1.05e-12
L05 N04 N05 2.70e-10
C06 N05 N06 2.40e-11
L06 N05 N06 1.45e-11
R06 N05 N06 8.64e+00
C07 N06 Port2 8.77e-11
L07 N06 Port2 1.18e-11
R07 N06 Port2 1.82e+01
.ENDS GQM1885C2A6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM2192C1H101GB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H101GB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.72e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.61e-12
R04 N03 N04 4.40e-02
C05 N04 N05 7.17e-10
L05 N04 N05 1.51e-11
R05 N04 N05 5.06e+00
C06 N05 N06 2.60e-11
L06 N05 N06 2.23e-11
R06 N05 N06 1.26e+01
C07 N06 N07 3.50e-12
L07 N06 N07 9.73e-11
R07 N06 N07 9.99e+01
C08 N07 Port2 1.02e-12
L08 N07 Port2 3.30e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2192C1H101GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM2192C1H101JB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.72e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.61e-12
R04 N03 N04 4.40e-02
C05 N04 N05 7.17e-10
L05 N04 N05 1.51e-11
R05 N04 N05 5.06e+00
C06 N05 N06 2.60e-11
L06 N05 N06 2.23e-11
R06 N05 N06 1.26e+01
C07 N06 N07 3.50e-12
L07 N06 N07 9.73e-11
R07 N06 N07 9.99e+01
C08 N07 Port2 1.02e-12
L08 N07 Port2 3.30e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2192C1H101JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM2192C1H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 4.80e-02
L04 N03 N04 1.51e-12
R04 N03 N04 8.47e-03
C05 N04 N05 1.81e-10
L05 N04 N05 1.28e-11
R05 N04 N05 1.42e+01
C06 N05 Port2 1.39e-12
L06 N05 Port2 3.11e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2192C1H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM2192C1H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 4.80e-02
L04 N03 N04 1.51e-12
R04 N03 N04 8.47e-03
C05 N04 N05 1.81e-10
L05 N04 N05 1.28e-11
R05 N04 N05 1.42e+01
C06 N05 Port2 1.39e-12
L06 N05 Port2 3.11e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2192C1H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.51e-11
R03 N02 N03 4.40e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.68e-02
C05 N04 N05 4.18e-11
L05 N04 N05 4.95e-11
R05 N04 N05 6.20e+01
C06 N05 N06 1.49e-11
L06 N05 N06 5.56e-11
R06 N05 N06 1.13e+02
C07 N06 N07 1.13e-11
L07 N06 N07 3.58e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 1.31e-12
L08 N07 Port2 1.99e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2192C1H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.51e-11
R03 N02 N03 4.40e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.68e-02
C05 N04 N05 4.18e-11
L05 N04 N05 4.95e-11
R05 N04 N05 6.20e+01
C06 N05 N06 1.49e-11
L06 N05 N06 5.56e-11
R06 N05 N06 1.13e+02
C07 N06 N07 1.13e-11
L07 N06 N07 3.58e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 1.31e-12
L08 N07 Port2 1.99e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2192C1H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM2192C1H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 6.11e-02
C04 N03 N04 2.33e-10
L04 N03 N04 1.21e-11
R04 N03 N04 1.24e+01
C05 N04 Port2 1.16e-12
L05 N04 Port2 3.36e-10
R05 N04 Port2 1.46e+03
.ENDS GQM2192C1H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM2192C1H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 6.11e-02
C04 N03 N04 2.33e-10
L04 N03 N04 1.21e-11
R04 N03 N04 1.24e+01
C05 N04 Port2 1.16e-12
L05 N04 Port2 3.36e-10
R05 N04 Port2 1.46e+03
.ENDS GQM2192C1H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM2192C1H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 5.02e-02
L04 N03 N04 1.97e-12
R04 N03 N04 1.87e-02
C05 N04 N05 2.78e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.15e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.38e-10
R06 N05 Port2 7.73e+02
.ENDS GQM2192C1H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM2192C1H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 5.02e-02
L04 N03 N04 1.97e-12
R04 N03 N04 1.87e-02
C05 N04 N05 2.78e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.15e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.38e-10
R06 N05 Port2 7.73e+02
.ENDS GQM2192C1H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM2192C1H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-12
R03 N02 N03 4.66e-02
L04 N03 N04 7.88e-12
R04 N03 N04 2.42e-02
C05 N04 N05 3.21e-10
L05 N04 N05 1.07e-11
R05 N04 N05 1.03e+01
C06 N05 Port2 7.20e-13
L06 N05 Port2 4.84e-10
R06 N05 Port2 2.99e+03
.ENDS GQM2192C1H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM2192C1H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-12
R03 N02 N03 4.66e-02
L04 N03 N04 7.88e-12
R04 N03 N04 2.42e-02
C05 N04 N05 3.21e-10
L05 N04 N05 1.07e-11
R05 N04 N05 1.03e+01
C06 N05 Port2 7.20e-13
L06 N05 Port2 4.84e-10
R06 N05 Port2 2.99e+03
.ENDS GQM2192C1H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM2192C1H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.64e-12
R04 N03 N04 6.61e-02
C05 N04 N05 2.99e-10
L05 N04 N05 1.28e-11
R05 N04 N05 9.00e+00
C06 N05 Port2 7.24e-13
L06 N05 Port2 4.68e-10
R06 N05 Port2 1.35e+04
.ENDS GQM2192C1H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM2192C1H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.64e-12
R04 N03 N04 6.61e-02
C05 N04 N05 2.99e-10
L05 N04 N05 1.28e-11
R05 N04 N05 9.00e+00
C06 N05 Port2 7.24e-13
L06 N05 Port2 4.68e-10
R06 N05 Port2 1.35e+04
.ENDS GQM2192C1H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM2192C1H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 4.61e-02
L04 N03 N04 1.75e-12
R04 N03 N04 1.53e-02
C05 N04 N05 3.47e-10
L05 N04 N05 1.22e-11
R05 N04 N05 9.74e+00
C06 N05 Port2 1.00e-12
L06 N05 Port2 3.47e-10
R06 N05 Port2 1.05e+03
.ENDS GQM2192C1H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM2192C1H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 4.61e-02
L04 N03 N04 1.75e-12
R04 N03 N04 1.53e-02
C05 N04 N05 3.47e-10
L05 N04 N05 1.22e-11
R05 N04 N05 9.74e+00
C06 N05 Port2 1.00e-12
L06 N05 Port2 3.47e-10
R06 N05 Port2 1.05e+03
.ENDS GQM2192C1H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM2192C1H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 4.43e-02
L04 N03 N04 3.04e-12
R04 N03 N04 1.17e-02
C05 N04 N05 3.77e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.01e+01
C06 N05 Port2 9.25e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.32e+03
.ENDS GQM2192C1H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM2192C1H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 4.43e-02
L04 N03 N04 3.04e-12
R04 N03 N04 1.17e-02
C05 N04 N05 3.77e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.01e+01
C06 N05 Port2 9.25e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.32e+03
.ENDS GQM2192C1H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM2192C1H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.82e-11
R03 N02 N03 4.85e-02
L04 N03 N04 1.84e-12
R04 N03 N04 1.04e-02
C05 N04 N05 4.20e-10
L05 N04 N05 1.16e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 1.12e-12
L06 N05 Port2 4.10e-10
R06 N05 Port2 1.65e+03
.ENDS GQM2192C1H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM2192C1H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.82e-11
R03 N02 N03 4.85e-02
L04 N03 N04 1.84e-12
R04 N03 N04 1.04e-02
C05 N04 N05 4.20e-10
L05 N04 N05 1.16e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 1.12e-12
L06 N05 Port2 4.10e-10
R06 N05 Port2 1.65e+03
.ENDS GQM2192C1H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM2192C1H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-12
R03 N02 N03 4.50e-02
L04 N03 N04 7.40e-12
R04 N03 N04 8.46e-02
C05 N04 N05 3.57e-10
L05 N04 N05 1.48e-11
R05 N04 N05 8.97e+00
C06 N05 N06 1.63e-11
L06 N05 N06 2.14e-11
R06 N05 N06 5.13e+01
C07 N06 Port2 7.01e-13
L07 N06 Port2 4.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM2192C1H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-12
R03 N02 N03 4.50e-02
L04 N03 N04 7.40e-12
R04 N03 N04 8.46e-02
C05 N04 N05 3.57e-10
L05 N04 N05 1.48e-11
R05 N04 N05 8.97e+00
C06 N05 N06 1.63e-11
L06 N05 N06 2.14e-11
R06 N05 N06 5.13e+01
C07 N06 Port2 7.01e-13
L07 N06 Port2 4.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM2192C1H510GB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-12
R03 N02 N03 4.33e-02
C04 N03 N04 2.73e-10
L04 N03 N04 2.10e-11
R04 N03 N04 1.47e+01
C05 N04 N05 1.37e-11
L05 N04 N05 4.06e-11
R05 N04 N05 3.76e+01
C06 N05 N06 2.15e-12
L06 N05 N06 1.62e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H510GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM2192C1H510JB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H510JB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-12
R03 N02 N03 4.33e-02
C04 N03 N04 2.73e-10
L04 N03 N04 2.10e-11
R04 N03 N04 1.47e+01
C05 N04 N05 1.37e-11
L05 N04 N05 4.06e-11
R05 N04 N05 3.76e+01
C06 N05 N06 2.15e-12
L06 N05 N06 1.62e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H510JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM2192C1H560GB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H560GB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 5.07e-02
C04 N03 N04 3.71e-10
L04 N03 N04 1.71e-11
R04 N03 N04 1.11e+01
C05 N04 N05 1.25e-11
L05 N04 N05 4.83e-11
R05 N04 N05 4.77e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.34e-10
R06 N05 Port2 2.00e+03
.ENDS GQM2192C1H560GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM2192C1H560JB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 5.07e-02
C04 N03 N04 3.71e-10
L04 N03 N04 1.71e-11
R04 N03 N04 1.11e+01
C05 N04 N05 1.25e-11
L05 N04 N05 4.83e-11
R05 N04 N05 4.77e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.34e-10
R06 N05 Port2 2.00e+03
.ENDS GQM2192C1H560JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H620GB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.53e-02
C04 N03 N04 3.49e-10
L04 N03 N04 2.07e-11
R04 N03 N04 1.19e+01
C05 N04 N05 4.00e-11
L05 N04 N05 2.14e-11
R05 N04 N05 1.89e+01
C06 N05 N06 1.29e-10
L06 N05 N06 5.83e-12
R06 N05 N06 5.25e+00
C07 N06 Port2 1.07e-12
L07 N06 Port2 3.27e-10
R07 N06 Port2 1.01e+03
.ENDS GQM2192C1H620GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H620JB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H620JB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.53e-02
C04 N03 N04 3.49e-10
L04 N03 N04 2.07e-11
R04 N03 N04 1.19e+01
C05 N04 N05 4.00e-11
L05 N04 N05 2.14e-11
R05 N04 N05 1.89e+01
C06 N05 N06 1.29e-10
L06 N05 N06 5.83e-12
R06 N05 N06 5.25e+00
C07 N06 Port2 1.07e-12
L07 N06 Port2 3.27e-10
R07 N06 Port2 1.01e+03
.ENDS GQM2192C1H620JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM2192C1H680GB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H680GB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.40e-11
R03 N02 N03 4.30e-02
C04 N03 N04 3.54e-10
L04 N03 N04 2.25e-11
R04 N03 N04 8.87e+00
C05 N04 N05 4.77e-11
L05 N04 N05 1.99e-11
R05 N04 N05 1.54e+01
C06 N05 N06 7.08e-12
L06 N05 N06 4.82e-11
R06 N05 N06 4.28e+01
C07 N06 Port2 1.06e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H680GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM2192C1H680JB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.40e-11
R03 N02 N03 4.30e-02
C04 N03 N04 3.54e-10
L04 N03 N04 2.25e-11
R04 N03 N04 8.87e+00
C05 N04 N05 4.77e-11
L05 N04 N05 1.99e-11
R05 N04 N05 1.54e+01
C06 N05 N06 7.08e-12
L06 N05 N06 4.82e-11
R06 N05 N06 4.28e+01
C07 N06 Port2 1.06e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C1H680JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM2192C1H750GB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H750GB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.50e-11
R03 N02 N03 4.29e-02
C04 N03 N04 3.97e-10
L04 N03 N04 2.27e-11
R04 N03 N04 1.14e+01
C05 N04 N05 8.51e-11
L05 N04 N05 1.48e-11
R05 N04 N05 1.23e+01
C06 N05 N06 1.70e-10
L06 N05 N06 6.17e-12
R06 N05 N06 4.39e+00
C07 N06 N07 1.54e-12
L07 N06 N07 2.98e-10
R07 N06 N07 1.25e+03
C08 N07 Port2 1.30e-11
L08 N07 Port2 2.72e-11
R08 N07 Port2 4.08e+01
.ENDS GQM2192C1H750GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM2192C1H750JB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.50e-11
R03 N02 N03 4.29e-02
C04 N03 N04 3.97e-10
L04 N03 N04 2.27e-11
R04 N03 N04 1.14e+01
C05 N04 N05 8.51e-11
L05 N04 N05 1.48e-11
R05 N04 N05 1.23e+01
C06 N05 N06 1.70e-10
L06 N05 N06 6.17e-12
R06 N05 N06 4.39e+00
C07 N06 N07 1.54e-12
L07 N06 N07 2.98e-10
R07 N06 N07 1.25e+03
C08 N07 Port2 1.30e-11
L08 N07 Port2 2.72e-11
R08 N07 Port2 4.08e+01
.ENDS GQM2192C1H750JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H820GB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H820GB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 4.46e-02
C04 N03 N04 4.39e-10
L04 N03 N04 2.19e-11
R04 N03 N04 9.59e+00
C05 N04 N05 1.42e-10
L05 N04 N05 9.51e-12
R05 N04 N05 7.28e+00
C06 N05 N06 2.49e-10
L06 N05 N06 4.60e-12
R06 N05 N06 3.20e+00
C07 N06 N07 3.20e-12
L07 N06 N07 1.48e-10
R07 N06 N07 6.04e+02
C08 N07 Port2 8.84e-12
L08 N07 Port2 4.18e-11
R08 N07 Port2 4.29e+01
.ENDS GQM2192C1H820GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM2192C1H820JB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H820JB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 4.46e-02
C04 N03 N04 4.39e-10
L04 N03 N04 2.19e-11
R04 N03 N04 9.59e+00
C05 N04 N05 1.42e-10
L05 N04 N05 9.51e-12
R05 N04 N05 7.28e+00
C06 N05 N06 2.49e-10
L06 N05 N06 4.60e-12
R06 N05 N06 3.20e+00
C07 N06 N07 3.20e-12
L07 N06 N07 1.48e-10
R07 N06 N07 6.04e+02
C08 N07 Port2 8.84e-12
L08 N07 Port2 4.18e-11
R08 N07 Port2 4.29e+01
.ENDS GQM2192C1H820JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM2192C1H910GB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H910GB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 4.44e-02
C04 N03 N04 8.25e-10
L04 N03 N04 1.21e-11
R04 N03 N04 5.90e+00
C05 N04 N05 5.63e-12
L05 N04 N05 1.00e-10
R05 N04 N05 1.93e+02
C06 N05 Port2 2.47e-12
L06 N05 Port2 1.99e-10
R06 N05 Port2 4.85e+02
.ENDS GQM2192C1H910GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM2192C1H910JB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C1H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 4.44e-02
C04 N03 N04 8.25e-10
L04 N03 N04 1.21e-11
R04 N03 N04 5.90e+00
C05 N04 N05 5.63e-12
L05 N04 N05 1.00e-10
R05 N04 N05 1.93e+02
C06 N05 Port2 2.47e-12
L06 N05 Port2 1.99e-10
R06 N05 Port2 4.85e+02
.ENDS GQM2192C1H910JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GQM2192C2A100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.17e-11
R03 N02 N03 4.01e-02
L04 N03 N04 5.60e-12
R04 N03 N04 9.65e-02
C05 N04 N05 5.74e-11
L05 N04 N05 2.06e-11
R05 N04 N05 3.85e+01
C06 N05 N06 1.20e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 Port2 8.86e-13
L07 N06 Port2 3.70e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GQM2192C2A100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.17e-11
R03 N02 N03 4.01e-02
L04 N03 N04 5.60e-12
R04 N03 N04 9.65e-02
C05 N04 N05 5.74e-11
L05 N04 N05 2.06e-11
R05 N04 N05 3.85e+01
C06 N05 N06 1.20e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 Port2 8.86e-13
L07 N06 Port2 3.70e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.10e-05[uF]/100[V]
* Murata P/N :GQM2192C2A110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 7.28e-02
L04 N03 N04 6.56e-12
R04 N03 N04 8.62e-03
C05 N04 N05 8.32e-11
L05 N04 N05 1.56e-11
R05 N04 N05 3.00e+01
C06 N05 Port2 1.49e-12
L06 N05 Port2 2.93e-10
R06 N05 Port2 1.51e+03
.ENDS GQM2192C2A110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.10e-05[uF]/100[V]
* Murata P/N :GQM2192C2A110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 7.28e-02
L04 N03 N04 6.56e-12
R04 N03 N04 8.62e-03
C05 N04 N05 8.32e-11
L05 N04 N05 1.56e-11
R05 N04 N05 3.00e+01
C06 N05 Port2 1.49e-12
L06 N05 Port2 2.93e-10
R06 N05 Port2 1.51e+03
.ENDS GQM2192C2A110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GQM2192C2A120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.49e-11
R03 N02 N03 6.17e-02
L04 N03 N04 2.14e-12
R04 N03 N04 2.31e-02
C05 N04 N05 9.17e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.11e+01
C06 N05 Port2 1.19e-12
L06 N05 Port2 3.72e-10
R06 N05 Port2 9.51e+02
.ENDS GQM2192C2A120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GQM2192C2A120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.49e-11
R03 N02 N03 6.17e-02
L04 N03 N04 2.14e-12
R04 N03 N04 2.31e-02
C05 N04 N05 9.17e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.11e+01
C06 N05 Port2 1.19e-12
L06 N05 Port2 3.72e-10
R06 N05 Port2 9.51e+02
.ENDS GQM2192C2A120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.30e-05[uF]/100[V]
* Murata P/N :GQM2192C2A130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-11
R03 N02 N03 6.19e-02
L04 N03 N04 3.58e-12
R04 N03 N04 7.12e-03
C05 N04 N05 8.55e-11
L05 N04 N05 1.78e-11
R05 N04 N05 2.91e+01
C06 N05 Port2 8.76e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2192C2A130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.30e-05[uF]/100[V]
* Murata P/N :GQM2192C2A130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-11
R03 N02 N03 6.19e-02
L04 N03 N04 3.58e-12
R04 N03 N04 7.12e-03
C05 N04 N05 8.55e-11
L05 N04 N05 1.78e-11
R05 N04 N05 2.91e+01
C06 N05 Port2 8.76e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2192C2A130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GQM2192C2A150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.41e-12
R03 N02 N03 4.50e-02
L04 N03 N04 6.20e-12
R04 N03 N04 6.00e-02
C05 N04 N05 1.10e-10
L05 N04 N05 1.59e-11
R05 N04 N05 1.94e+01
C06 N05 N06 2.20e-11
L06 N05 N06 1.62e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 7.43e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GQM2192C2A150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.41e-12
R03 N02 N03 4.50e-02
L04 N03 N04 6.20e-12
R04 N03 N04 6.00e-02
C05 N04 N05 1.10e-10
L05 N04 N05 1.59e-11
R05 N04 N05 1.94e+01
C06 N05 N06 2.20e-11
L06 N05 N06 1.62e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 7.43e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.60e-05[uF]/100[V]
* Murata P/N :GQM2192C2A160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 5.30e-02
L04 N03 N04 4.12e-12
R04 N03 N04 1.14e-02
C05 N04 N05 1.25e-10
L05 N04 N05 1.50e-11
R05 N04 N05 1.90e+01
C06 N05 Port2 1.37e-12
L06 N05 Port2 3.14e-10
R06 N05 Port2 1.08e+03
.ENDS GQM2192C2A160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.60e-05[uF]/100[V]
* Murata P/N :GQM2192C2A160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 5.30e-02
L04 N03 N04 4.12e-12
R04 N03 N04 1.14e-02
C05 N04 N05 1.25e-10
L05 N04 N05 1.50e-11
R05 N04 N05 1.90e+01
C06 N05 Port2 1.37e-12
L06 N05 Port2 3.14e-10
R06 N05 Port2 1.08e+03
.ENDS GQM2192C2A160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GQM2192C2A180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.37e-11
R03 N02 N03 4.25e-02
L04 N03 N04 5.50e-12
R04 N03 N04 1.95e-02
C05 N04 N05 1.41e-10
L05 N04 N05 1.48e-11
R05 N04 N05 1.91e+01
C06 N05 N06 3.05e-12
L06 N05 N06 1.21e-10
R06 N05 N06 1.55e+02
C07 N06 Port2 9.80e-13
L07 N06 Port2 3.23e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GQM2192C2A180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.37e-11
R03 N02 N03 4.25e-02
L04 N03 N04 5.50e-12
R04 N03 N04 1.95e-02
C05 N04 N05 1.41e-10
L05 N04 N05 1.48e-11
R05 N04 N05 1.91e+01
C06 N05 N06 3.05e-12
L06 N05 N06 1.21e-10
R06 N05 N06 1.55e+02
C07 N06 Port2 9.80e-13
L07 N06 Port2 3.23e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.64e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.10e+03
C05 N04 Port2 9.06e-12
L05 N04 Port2 5.43e-11
R05 N04 Port2 2.51e+02
.ENDS GQM2192C2A4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.64e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.10e+03
C05 N04 Port2 9.06e-12
L05 N04 Port2 5.43e-11
R05 N04 Port2 2.51e+02
.ENDS GQM2192C2A4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 6.77e-02
L04 N03 N04 1.23e-12
R04 N03 N04 7.71e-02
C05 N04 N05 1.00e-11
L05 N04 N05 5.21e-11
R05 N04 N05 1.66e+02
C06 N05 N06 8.83e-12
L06 N05 N06 3.88e-11
R06 N05 N06 2.76e+01
C07 N06 Port2 2.55e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 5.20e+03
.ENDS GQM2192C2A4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 6.77e-02
L04 N03 N04 1.23e-12
R04 N03 N04 7.71e-02
C05 N04 N05 1.00e-11
L05 N04 N05 5.21e-11
R05 N04 N05 1.66e+02
C06 N05 N06 8.83e-12
L06 N05 N06 3.88e-11
R06 N05 N06 2.76e+01
C07 N06 Port2 2.55e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 5.20e+03
.ENDS GQM2192C2A4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 6.00e-02
C04 N03 N04 8.49e-13
L04 N03 N04 3.76e-10
R04 N03 N04 2.00e+03
C05 N04 Port2 1.30e-11
L05 N04 Port2 4.54e-11
R05 N04 Port2 1.53e+02
.ENDS GQM2192C2A4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM2192C2A4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 6.00e-02
C04 N03 N04 8.49e-13
L04 N03 N04 3.76e-10
R04 N03 N04 2.00e+03
C05 N04 Port2 1.30e-11
L05 N04 Port2 4.54e-11
R05 N04 Port2 1.53e+02
.ENDS GQM2192C2A4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.65e-12
R04 N03 N04 1.75e-01
C05 N04 N05 1.01e-12
L05 N04 N05 3.09e-10
R05 N04 N05 3.50e+03
C06 N05 Port2 1.98e-11
L06 N05 Port2 3.17e-11
R06 N05 Port2 1.15e+02
.ENDS GQM2192C2A5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.65e-12
R04 N03 N04 1.75e-01
C05 N04 N05 1.01e-12
L05 N04 N05 3.09e-10
R05 N04 N05 3.50e+03
C06 N05 Port2 1.98e-11
L06 N05 Port2 3.17e-11
R06 N05 Port2 1.15e+02
.ENDS GQM2192C2A5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 5.48e-02
L04 N03 N04 1.91e-11
R04 N03 N04 3.50e-02
C05 N04 N05 2.20e-11
L05 N04 N05 2.86e-11
R05 N04 N05 9.17e+01
C06 N05 N06 3.96e-12
L06 N05 N06 8.38e-11
R06 N05 N06 1.16e+02
C07 N06 Port2 2.74e-12
L07 N06 Port2 1.17e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 5.48e-02
L04 N03 N04 1.91e-11
R04 N03 N04 3.50e-02
C05 N04 N05 2.20e-11
L05 N04 N05 2.86e-11
R05 N04 N05 9.17e+01
C06 N05 N06 3.96e-12
L06 N05 N06 8.38e-11
R06 N05 N06 1.16e+02
C07 N06 Port2 2.74e-12
L07 N06 Port2 1.17e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 5.68e-02
L04 N03 N04 1.07e-11
R04 N03 N04 3.18e-02
C05 N04 N05 2.17e-11
L05 N04 N05 3.17e-11
R05 N04 N05 9.19e+01
C06 N05 N06 3.30e-12
L06 N05 N06 1.06e-10
R06 N05 N06 4.81e+02
C07 N06 Port2 1.79e-12
L07 N06 Port2 1.87e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM2192C2A5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 5.68e-02
L04 N03 N04 1.07e-11
R04 N03 N04 3.18e-02
C05 N04 N05 2.17e-11
L05 N04 N05 3.17e-11
R05 N04 N05 9.19e+01
C06 N05 N06 3.30e-12
L06 N05 N06 1.06e-10
R06 N05 N06 4.81e+02
C07 N06 Port2 1.79e-12
L07 N06 Port2 1.87e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.60e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.47e-12
R04 N03 N04 2.44e-01
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.17e-11
L06 N05 Port2 2.31e-11
R06 N05 Port2 6.70e+01
.ENDS GQM2192C2A6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.60e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.47e-12
R04 N03 N04 2.44e-01
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.17e-11
L06 N05 Port2 2.31e-11
R06 N05 Port2 6.70e+01
.ENDS GQM2192C2A6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.45e-11
R03 N02 N03 5.14e-02
L04 N03 N04 1.54e-11
R04 N03 N04 3.88e-02
C05 N04 N05 2.62e-11
L05 N04 N05 2.87e-11
R05 N04 N05 8.61e+01
C06 N05 N06 3.22e-12
L06 N05 N06 1.02e-10
R06 N05 N06 2.27e+02
C07 N06 Port2 1.15e-12
L07 N06 Port2 2.82e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.45e-11
R03 N02 N03 5.14e-02
L04 N03 N04 1.54e-11
R04 N03 N04 3.88e-02
C05 N04 N05 2.62e-11
L05 N04 N05 2.87e-11
R05 N04 N05 8.61e+01
C06 N05 N06 3.22e-12
L06 N05 N06 1.02e-10
R06 N05 N06 2.27e+02
C07 N06 Port2 1.15e-12
L07 N06 Port2 2.82e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.10e-11
R03 N02 N03 5.00e-02
L04 N03 N04 5.17e-12
R04 N03 N04 9.74e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.89e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 5.12e+01
.ENDS GQM2192C2A6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM2192C2A6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.10e-11
R03 N02 N03 5.00e-02
L04 N03 N04 5.17e-12
R04 N03 N04 9.74e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.89e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 5.12e+01
.ENDS GQM2192C2A6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.70e-11
R03 N02 N03 5.00e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.48e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.62e-11
L06 N05 Port2 2.33e-11
R06 N05 Port2 5.50e+01
.ENDS GQM2192C2A7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.70e-11
R03 N02 N03 5.00e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.48e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.62e-11
L06 N05 Port2 2.33e-11
R06 N05 Port2 5.50e+01
.ENDS GQM2192C2A7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GQM2192C2A7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.56e-02
L04 N03 N04 9.81e-12
R04 N03 N04 2.78e-02
C05 N04 N05 3.53e-11
L05 N04 N05 2.54e-11
R05 N04 N05 5.10e+01
C06 N05 N06 2.56e-12
L06 N05 N06 1.36e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.31e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GQM2192C2A7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.56e-02
L04 N03 N04 9.81e-12
R04 N03 N04 2.78e-02
C05 N04 N05 3.53e-11
L05 N04 N05 2.54e-11
R05 N04 N05 5.10e+01
C06 N05 N06 2.56e-12
L06 N05 N06 1.36e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.31e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.61e-12
R04 N03 N04 1.06e-01
C05 N04 N05 7.50e-13
L05 N04 N05 4.08e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 4.60e-11
L06 N05 Port2 2.07e-11
R06 N05 Port2 4.32e+01
.ENDS GQM2192C2A8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.61e-12
R04 N03 N04 1.06e-01
C05 N04 N05 7.50e-13
L05 N04 N05 4.08e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 4.60e-11
L06 N05 Port2 2.07e-11
R06 N05 Port2 4.32e+01
.ENDS GQM2192C2A8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GQM2192C2A8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.61e-02
L04 N03 N04 2.02e-11
R04 N03 N04 4.15e-02
C05 N04 N05 3.70e-11
L05 N04 N05 2.64e-11
R05 N04 N05 4.69e+01
C06 N05 N06 2.03e-12
L06 N05 N06 1.84e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.90e-12
L07 N06 Port2 1.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GQM2192C2A8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.61e-02
L04 N03 N04 2.02e-11
R04 N03 N04 4.15e-02
C05 N04 N05 3.70e-11
L05 N04 N05 2.64e-11
R05 N04 N05 4.69e+01
C06 N05 N06 2.03e-12
L06 N05 N06 1.84e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.90e-12
L07 N06 Port2 1.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2192C2A8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.05e-12
R04 N03 N04 7.63e-02
C05 N04 N05 8.25e-13
L05 N04 N05 3.79e-10
R05 N04 N05 1.50e+03
C06 N05 Port2 5.65e-11
L06 N05 Port2 1.90e-11
R06 N05 Port2 4.03e+01
.ENDS GQM2192C2A9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GQM2192C2A9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.05e-12
R04 N03 N04 7.63e-02
C05 N04 N05 8.25e-13
L05 N04 N05 3.79e-10
R05 N04 N05 1.50e+03
C06 N05 Port2 5.65e-11
L06 N05 Port2 1.90e-11
R06 N05 Port2 4.03e+01
.ENDS GQM2192C2A9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GQM2192C2A9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 4.56e-02
L04 N03 N04 1.89e-11
R04 N03 N04 3.71e-02
C05 N04 N05 6.14e-11
L05 N04 N05 1.77e-11
R05 N04 N05 3.75e+01
C06 N05 Port2 1.92e-12
L06 N05 Port2 1.92e-10
R06 N05 Port2 4.09e+02
.ENDS GQM2192C2A9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GQM2192C2A9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2192C2A9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 4.56e-02
L04 N03 N04 1.89e-11
R04 N03 N04 3.71e-02
C05 N04 N05 6.14e-11
L05 N04 N05 1.77e-11
R05 N04 N05 3.75e+01
C06 N05 Port2 1.92e-12
L06 N05 Port2 1.92e-10
R06 N05 Port2 4.09e+02
.ENDS GQM2192C2A9R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 1.55e-12
L04 N03 Port2 2.02e-10
R04 N03 Port2 1.60e+03
.ENDS GQM2193C2A2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 1.55e-12
L04 N03 Port2 2.02e-10
R04 N03 Port2 1.60e+03
.ENDS GQM2193C2A2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.69e-10
R03 N02 N03 1.02e-01
L04 N03 N04 2.09e-12
R04 N03 N04 9.71e-03
C05 N04 Port2 3.57e-12
L05 N04 Port2 9.89e-11
R05 N04 Port2 3.05e+02
.ENDS GQM2193C2A2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.69e-10
R03 N02 N03 1.02e-01
L04 N03 N04 2.09e-12
R04 N03 N04 9.71e-03
C05 N04 Port2 3.57e-12
L05 N04 Port2 9.89e-11
R05 N04 Port2 3.05e+02
.ENDS GQM2193C2A2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.70e-10
R03 N02 N03 9.83e-02
L04 N03 N04 1.49e-12
R04 N03 N04 1.84e-02
C05 N04 Port2 3.76e-12
L05 N04 Port2 9.93e-11
R05 N04 Port2 3.47e+02
.ENDS GQM2193C2A2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM2193C2A2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.70e-10
R03 N02 N03 9.83e-02
L04 N03 N04 1.49e-12
R04 N03 N04 1.84e-02
C05 N04 Port2 3.76e-12
L05 N04 Port2 9.93e-11
R05 N04 Port2 3.47e+02
.ENDS GQM2193C2A2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.40e-12
L04 N03 N04 2.01e-10
R04 N03 N04 1.20e+03
C05 N04 Port2 4.47e-12
L05 N04 Port2 8.95e-11
R05 N04 Port2 6.71e+02
.ENDS GQM2193C2A3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.40e-12
L04 N03 N04 2.01e-10
R04 N03 N04 1.20e+03
C05 N04 Port2 4.47e-12
L05 N04 Port2 8.95e-11
R05 N04 Port2 6.71e+02
.ENDS GQM2193C2A3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-11
R03 N02 N03 8.00e-02
C04 N03 N04 8.66e-13
L04 N03 N04 3.05e-10
R04 N03 N04 1.50e+03
C05 N04 Port2 5.08e-12
L05 N04 Port2 8.31e-11
R05 N04 Port2 4.47e+02
.ENDS GQM2193C2A3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-11
R03 N02 N03 8.00e-02
C04 N03 N04 8.66e-13
L04 N03 N04 3.05e-10
R04 N03 N04 1.50e+03
C05 N04 Port2 5.08e-12
L05 N04 Port2 8.31e-11
R05 N04 Port2 4.47e+02
.ENDS GQM2193C2A3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 8.88e-02
L04 N03 N04 5.49e-12
R04 N03 N04 1.85e-02
C05 N04 N05 8.65e-12
L05 N04 N05 5.16e-11
R05 N04 N05 2.12e+02
C06 N05 N06 8.63e-12
L06 N05 N06 3.88e-11
R06 N05 N06 5.35e+01
C07 N06 Port2 3.65e-12
L07 N06 Port2 9.13e-11
R07 N06 Port2 1.64e+03
.ENDS GQM2193C2A3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 8.88e-02
L04 N03 N04 5.49e-12
R04 N03 N04 1.85e-02
C05 N04 N05 8.65e-12
L05 N04 N05 5.16e-11
R05 N04 N05 2.12e+02
C06 N05 N06 8.63e-12
L06 N05 N06 3.88e-11
R06 N05 N06 5.35e+01
C07 N06 Port2 3.65e-12
L07 N06 Port2 9.13e-11
R07 N06 Port2 1.64e+03
.ENDS GQM2193C2A3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 8.16e-02
L04 N03 N04 5.63e-12
R04 N03 N04 1.38e-02
C05 N04 N05 7.48e-12
L05 N04 N05 6.56e-11
R05 N04 N05 2.28e+02
C06 N05 N06 1.66e-11
L06 N05 N06 2.10e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 2.44e-12
L07 N06 Port2 1.36e-10
R07 N06 Port2 1.10e+03
.ENDS GQM2193C2A3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CJ(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM2193C2A3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2193C2A3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 8.16e-02
L04 N03 N04 5.63e-12
R04 N03 N04 1.38e-02
C05 N04 N05 7.48e-12
L05 N04 N05 6.56e-11
R05 N04 N05 2.28e+02
C06 N05 N06 1.66e-11
L06 N05 N06 2.10e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 2.44e-12
L07 N06 Port2 1.36e-10
R07 N06 Port2 1.10e+03
.ENDS GQM2193C2A3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.43e-10
R03 N02 N03 2.00e-01
C04 N03 N04 3.30e-11
L04 N03 N04 1.00e-11
C05 N04 Port2 5.28e-10
L05 N04 Port2 7.11e-13
R05 N04 Port2 2.01e-01
.ENDS GQM2194C2A1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.43e-10
R03 N02 N03 2.00e-01
C04 N03 N04 3.30e-11
L04 N03 N04 1.00e-11
C05 N04 Port2 5.28e-10
L05 N04 Port2 7.11e-13
R05 N04 Port2 2.01e-01
.ENDS GQM2194C2A1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.60e-10
R03 N02 N03 1.94e-01
L04 N03 N04 2.71e-13
R04 N03 N04 4.06e-03
C05 N04 N05 3.00e-10
L05 N04 N05 1.20e-12
R05 N04 N05 5.44e-01
C06 N05 Port2 1.30e-11
L06 N05 Port2 2.41e-11
R06 N05 Port2 1.00e+05
.ENDS GQM2194C2A1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.60e-10
R03 N02 N03 1.94e-01
L04 N03 N04 2.71e-13
R04 N03 N04 4.06e-03
C05 N04 N05 3.00e-10
L05 N04 N05 1.20e-12
R05 N04 N05 5.44e-01
C06 N05 Port2 1.30e-11
L06 N05 Port2 2.41e-11
R06 N05 Port2 1.00e+05
.ENDS GQM2194C2A1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.90e-01
C04 N03 N04 7.17e-11
L04 N03 N04 4.76e-12
R04 N03 N04 4.37e+00
C05 N04 Port2 3.68e-12
L05 N04 Port2 8.21e-11
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.90e-01
C04 N03 N04 7.17e-11
L04 N03 N04 4.76e-12
R04 N03 N04 4.37e+00
C05 N04 Port2 3.68e-12
L05 N04 Port2 8.21e-11
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.86e-01
C04 N03 N04 6.17e-11
L04 N03 N04 5.59e-12
R04 N03 N04 4.34e+00
C05 N04 Port2 1.79e-12
L05 N04 Port2 1.55e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.86e-01
C04 N03 N04 6.17e-11
L04 N03 N04 5.59e-12
R04 N03 N04 4.34e+00
C05 N04 Port2 1.79e-12
L05 N04 Port2 1.55e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.23e-12
L04 N03 N04 2.09e-10
C05 N04 Port2 7.93e-11
L05 N04 Port2 4.44e-12
R05 N04 Port2 2.01e+00
.ENDS GQM2194C2A1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.23e-12
L04 N03 N04 2.09e-10
C05 N04 Port2 7.93e-11
L05 N04 Port2 4.44e-12
R05 N04 Port2 2.01e+00
.ENDS GQM2194C2A1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.63e-01
C04 N03 N04 2.77e-11
L04 N03 N04 1.21e-11
R04 N03 N04 1.56e+01
C05 N04 Port2 2.38e-12
L05 N04 Port2 1.30e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.63e-01
C04 N03 N04 2.77e-11
L04 N03 N04 1.21e-11
R04 N03 N04 1.56e+01
C05 N04 Port2 2.38e-12
L05 N04 Port2 1.30e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2194C2A1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 1.66e-01
C04 N03 N04 5.48e-11
L04 N03 N04 6.28e-12
R04 N03 N04 4.67e+00
C05 N04 Port2 2.37e-12
L05 N04 Port2 1.34e-10
R05 N04 Port2 1.77e+03
.ENDS GQM2194C2A1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM2194C2A1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 1.66e-01
C04 N03 N04 5.48e-11
L04 N03 N04 6.28e-12
R04 N03 N04 4.67e+00
C05 N04 Port2 2.37e-12
L05 N04 Port2 1.34e-10
R05 N04 Port2 1.77e+03
.ENDS GQM2194C2A1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM2194C2A2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 1.52e-12
L04 N03 Port2 2.06e-10
R04 N03 Port2 1.40e+03
.ENDS GQM2194C2A2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CK(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM2194C2A2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2194C2A2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 1.52e-12
L04 N03 Port2 2.06e-10
R04 N03 Port2 1.40e+03
.ENDS GQM2194C2A2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM2195C1H101GB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H101GB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.72e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.61e-12
R04 N03 N04 4.40e-02
C05 N04 N05 7.17e-10
L05 N04 N05 1.51e-11
R05 N04 N05 5.06e+00
C06 N05 N06 2.60e-11
L06 N05 N06 2.23e-11
R06 N05 N06 1.26e+01
C07 N06 N07 3.50e-12
L07 N06 N07 9.73e-11
R07 N06 N07 9.99e+01
C08 N07 Port2 1.02e-12
L08 N07 Port2 3.30e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C1H101GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GQM2195C1H101JB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.72e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.61e-12
R04 N03 N04 4.40e-02
C05 N04 N05 7.17e-10
L05 N04 N05 1.51e-11
R05 N04 N05 5.06e+00
C06 N05 N06 2.60e-11
L06 N05 N06 2.23e-11
R06 N05 N06 1.26e+01
C07 N06 N07 3.50e-12
L07 N06 N07 9.73e-11
R07 N06 N07 9.99e+01
C08 N07 Port2 1.02e-12
L08 N07 Port2 3.30e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C1H101JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM2195C1H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 4.80e-02
L04 N03 N04 1.51e-12
R04 N03 N04 8.47e-03
C05 N04 N05 1.81e-10
L05 N04 N05 1.28e-11
R05 N04 N05 1.42e+01
C06 N05 Port2 1.39e-12
L06 N05 Port2 3.11e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2195C1H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GQM2195C1H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 4.80e-02
L04 N03 N04 1.51e-12
R04 N03 N04 8.47e-03
C05 N04 N05 1.81e-10
L05 N04 N05 1.28e-11
R05 N04 N05 1.42e+01
C06 N05 Port2 1.39e-12
L06 N05 Port2 3.11e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2195C1H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.51e-11
R03 N02 N03 4.40e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.68e-02
C05 N04 N05 4.18e-11
L05 N04 N05 4.95e-11
R05 N04 N05 6.20e+01
C06 N05 N06 1.49e-11
L06 N05 N06 5.56e-11
R06 N05 N06 1.13e+02
C07 N06 N07 1.13e-11
L07 N06 N07 3.58e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 1.31e-12
L08 N07 Port2 1.99e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C1H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.51e-11
R03 N02 N03 4.40e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.68e-02
C05 N04 N05 4.18e-11
L05 N04 N05 4.95e-11
R05 N04 N05 6.20e+01
C06 N05 N06 1.49e-11
L06 N05 N06 5.56e-11
R06 N05 N06 1.13e+02
C07 N06 N07 1.13e-11
L07 N06 N07 3.58e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 1.31e-12
L08 N07 Port2 1.99e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C1H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM2195C1H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 6.11e-02
C04 N03 N04 2.33e-10
L04 N03 N04 1.21e-11
R04 N03 N04 1.24e+01
C05 N04 Port2 1.16e-12
L05 N04 Port2 3.36e-10
R05 N04 Port2 1.46e+03
.ENDS GQM2195C1H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GQM2195C1H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 6.11e-02
C04 N03 N04 2.33e-10
L04 N03 N04 1.21e-11
R04 N03 N04 1.24e+01
C05 N04 Port2 1.16e-12
L05 N04 Port2 3.36e-10
R05 N04 Port2 1.46e+03
.ENDS GQM2195C1H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM2195C1H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 5.02e-02
L04 N03 N04 1.97e-12
R04 N03 N04 1.87e-02
C05 N04 N05 2.78e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.15e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.38e-10
R06 N05 Port2 7.73e+02
.ENDS GQM2195C1H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GQM2195C1H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 5.02e-02
L04 N03 N04 1.97e-12
R04 N03 N04 1.87e-02
C05 N04 N05 2.78e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.15e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.38e-10
R06 N05 Port2 7.73e+02
.ENDS GQM2195C1H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM2195C1H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-12
R03 N02 N03 4.66e-02
L04 N03 N04 7.88e-12
R04 N03 N04 2.42e-02
C05 N04 N05 3.21e-10
L05 N04 N05 1.07e-11
R05 N04 N05 1.03e+01
C06 N05 Port2 7.20e-13
L06 N05 Port2 4.84e-10
R06 N05 Port2 2.99e+03
.ENDS GQM2195C1H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GQM2195C1H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-12
R03 N02 N03 4.66e-02
L04 N03 N04 7.88e-12
R04 N03 N04 2.42e-02
C05 N04 N05 3.21e-10
L05 N04 N05 1.07e-11
R05 N04 N05 1.03e+01
C06 N05 Port2 7.20e-13
L06 N05 Port2 4.84e-10
R06 N05 Port2 2.99e+03
.ENDS GQM2195C1H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM2195C1H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.64e-12
R04 N03 N04 6.61e-02
C05 N04 N05 2.99e-10
L05 N04 N05 1.28e-11
R05 N04 N05 9.00e+00
C06 N05 Port2 7.24e-13
L06 N05 Port2 4.68e-10
R06 N05 Port2 1.35e+04
.ENDS GQM2195C1H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GQM2195C1H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.64e-12
R04 N03 N04 6.61e-02
C05 N04 N05 2.99e-10
L05 N04 N05 1.28e-11
R05 N04 N05 9.00e+00
C06 N05 Port2 7.24e-13
L06 N05 Port2 4.68e-10
R06 N05 Port2 1.35e+04
.ENDS GQM2195C1H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM2195C1H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 4.61e-02
L04 N03 N04 1.75e-12
R04 N03 N04 1.53e-02
C05 N04 N05 3.47e-10
L05 N04 N05 1.22e-11
R05 N04 N05 9.74e+00
C06 N05 Port2 1.00e-12
L06 N05 Port2 3.47e-10
R06 N05 Port2 1.05e+03
.ENDS GQM2195C1H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GQM2195C1H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 4.61e-02
L04 N03 N04 1.75e-12
R04 N03 N04 1.53e-02
C05 N04 N05 3.47e-10
L05 N04 N05 1.22e-11
R05 N04 N05 9.74e+00
C06 N05 Port2 1.00e-12
L06 N05 Port2 3.47e-10
R06 N05 Port2 1.05e+03
.ENDS GQM2195C1H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM2195C1H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 4.43e-02
L04 N03 N04 3.04e-12
R04 N03 N04 1.17e-02
C05 N04 N05 3.77e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.01e+01
C06 N05 Port2 9.25e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.32e+03
.ENDS GQM2195C1H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GQM2195C1H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 4.43e-02
L04 N03 N04 3.04e-12
R04 N03 N04 1.17e-02
C05 N04 N05 3.77e-10
L05 N04 N05 1.14e-11
R05 N04 N05 1.01e+01
C06 N05 Port2 9.25e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.32e+03
.ENDS GQM2195C1H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM2195C1H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.82e-11
R03 N02 N03 4.85e-02
L04 N03 N04 1.84e-12
R04 N03 N04 1.04e-02
C05 N04 N05 4.20e-10
L05 N04 N05 1.16e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 1.12e-12
L06 N05 Port2 4.10e-10
R06 N05 Port2 1.65e+03
.ENDS GQM2195C1H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GQM2195C1H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.82e-11
R03 N02 N03 4.85e-02
L04 N03 N04 1.84e-12
R04 N03 N04 1.04e-02
C05 N04 N05 4.20e-10
L05 N04 N05 1.16e-11
R05 N04 N05 1.16e+01
C06 N05 Port2 1.12e-12
L06 N05 Port2 4.10e-10
R06 N05 Port2 1.65e+03
.ENDS GQM2195C1H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM2195C1H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-12
R03 N02 N03 4.50e-02
L04 N03 N04 7.40e-12
R04 N03 N04 8.46e-02
C05 N04 N05 3.57e-10
L05 N04 N05 1.48e-11
R05 N04 N05 8.97e+00
C06 N05 N06 1.63e-11
L06 N05 N06 2.14e-11
R06 N05 N06 5.13e+01
C07 N06 Port2 7.01e-13
L07 N06 Port2 4.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GQM2195C1H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.82e-12
R03 N02 N03 4.50e-02
L04 N03 N04 7.40e-12
R04 N03 N04 8.46e-02
C05 N04 N05 3.57e-10
L05 N04 N05 1.48e-11
R05 N04 N05 8.97e+00
C06 N05 N06 1.63e-11
L06 N05 N06 2.14e-11
R06 N05 N06 5.13e+01
C07 N06 Port2 7.01e-13
L07 N06 Port2 4.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM2195C1H510GB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-12
R03 N02 N03 4.33e-02
C04 N03 N04 2.73e-10
L04 N03 N04 2.10e-11
R04 N03 N04 1.47e+01
C05 N04 N05 1.37e-11
L05 N04 N05 4.06e-11
R05 N04 N05 3.76e+01
C06 N05 N06 2.15e-12
L06 N05 N06 1.62e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H510GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-05[uF]/50[V]
* Murata P/N :GQM2195C1H510JB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H510JB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-12
R03 N02 N03 4.33e-02
C04 N03 N04 2.73e-10
L04 N03 N04 2.10e-11
R04 N03 N04 1.47e+01
C05 N04 N05 1.37e-11
L05 N04 N05 4.06e-11
R05 N04 N05 3.76e+01
C06 N05 N06 2.15e-12
L06 N05 N06 1.62e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H510JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM2195C1H560GB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H560GB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 5.07e-02
C04 N03 N04 3.71e-10
L04 N03 N04 1.71e-11
R04 N03 N04 1.11e+01
C05 N04 N05 1.25e-11
L05 N04 N05 4.83e-11
R05 N04 N05 4.77e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.34e-10
R06 N05 Port2 2.00e+03
.ENDS GQM2195C1H560GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GQM2195C1H560JB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 5.07e-02
C04 N03 N04 3.71e-10
L04 N03 N04 1.71e-11
R04 N03 N04 1.11e+01
C05 N04 N05 1.25e-11
L05 N04 N05 4.83e-11
R05 N04 N05 4.77e+01
C06 N05 Port2 1.20e-12
L06 N05 Port2 3.34e-10
R06 N05 Port2 2.00e+03
.ENDS GQM2195C1H560JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H620GB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.53e-02
C04 N03 N04 3.49e-10
L04 N03 N04 2.07e-11
R04 N03 N04 1.19e+01
C05 N04 N05 4.00e-11
L05 N04 N05 2.14e-11
R05 N04 N05 1.89e+01
C06 N05 N06 1.29e-10
L06 N05 N06 5.83e-12
R06 N05 N06 5.25e+00
C07 N06 Port2 1.07e-12
L07 N06 Port2 3.27e-10
R07 N06 Port2 1.01e+03
.ENDS GQM2195C1H620GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H620JB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H620JB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.53e-02
C04 N03 N04 3.49e-10
L04 N03 N04 2.07e-11
R04 N03 N04 1.19e+01
C05 N04 N05 4.00e-11
L05 N04 N05 2.14e-11
R05 N04 N05 1.89e+01
C06 N05 N06 1.29e-10
L06 N05 N06 5.83e-12
R06 N05 N06 5.25e+00
C07 N06 Port2 1.07e-12
L07 N06 Port2 3.27e-10
R07 N06 Port2 1.01e+03
.ENDS GQM2195C1H620JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM2195C1H680GB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H680GB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.40e-11
R03 N02 N03 4.30e-02
C04 N03 N04 3.54e-10
L04 N03 N04 2.25e-11
R04 N03 N04 8.87e+00
C05 N04 N05 4.77e-11
L05 N04 N05 1.99e-11
R05 N04 N05 1.54e+01
C06 N05 N06 7.08e-12
L06 N05 N06 4.82e-11
R06 N05 N06 4.28e+01
C07 N06 Port2 1.06e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H680GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GQM2195C1H680JB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.40e-11
R03 N02 N03 4.30e-02
C04 N03 N04 3.54e-10
L04 N03 N04 2.25e-11
R04 N03 N04 8.87e+00
C05 N04 N05 4.77e-11
L05 N04 N05 1.99e-11
R05 N04 N05 1.54e+01
C06 N05 N06 7.08e-12
L06 N05 N06 4.82e-11
R06 N05 N06 4.28e+01
C07 N06 Port2 1.06e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C1H680JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM2195C1H750GB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H750GB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.50e-11
R03 N02 N03 4.29e-02
C04 N03 N04 3.97e-10
L04 N03 N04 2.27e-11
R04 N03 N04 1.14e+01
C05 N04 N05 8.51e-11
L05 N04 N05 1.48e-11
R05 N04 N05 1.23e+01
C06 N05 N06 1.70e-10
L06 N05 N06 6.17e-12
R06 N05 N06 4.39e+00
C07 N06 N07 1.54e-12
L07 N06 N07 2.98e-10
R07 N06 N07 1.25e+03
C08 N07 Port2 1.30e-11
L08 N07 Port2 2.72e-11
R08 N07 Port2 4.08e+01
.ENDS GQM2195C1H750GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-05[uF]/50[V]
* Murata P/N :GQM2195C1H750JB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.50e-11
R03 N02 N03 4.29e-02
C04 N03 N04 3.97e-10
L04 N03 N04 2.27e-11
R04 N03 N04 1.14e+01
C05 N04 N05 8.51e-11
L05 N04 N05 1.48e-11
R05 N04 N05 1.23e+01
C06 N05 N06 1.70e-10
L06 N05 N06 6.17e-12
R06 N05 N06 4.39e+00
C07 N06 N07 1.54e-12
L07 N06 N07 2.98e-10
R07 N06 N07 1.25e+03
C08 N07 Port2 1.30e-11
L08 N07 Port2 2.72e-11
R08 N07 Port2 4.08e+01
.ENDS GQM2195C1H750JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H820GB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H820GB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 4.46e-02
C04 N03 N04 4.39e-10
L04 N03 N04 2.19e-11
R04 N03 N04 9.59e+00
C05 N04 N05 1.42e-10
L05 N04 N05 9.51e-12
R05 N04 N05 7.28e+00
C06 N05 N06 2.49e-10
L06 N05 N06 4.60e-12
R06 N05 N06 3.20e+00
C07 N06 N07 3.20e-12
L07 N06 N07 1.48e-10
R07 N06 N07 6.04e+02
C08 N07 Port2 8.84e-12
L08 N07 Port2 4.18e-11
R08 N07 Port2 4.29e+01
.ENDS GQM2195C1H820GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GQM2195C1H820JB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H820JB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 4.46e-02
C04 N03 N04 4.39e-10
L04 N03 N04 2.19e-11
R04 N03 N04 9.59e+00
C05 N04 N05 1.42e-10
L05 N04 N05 9.51e-12
R05 N04 N05 7.28e+00
C06 N05 N06 2.49e-10
L06 N05 N06 4.60e-12
R06 N05 N06 3.20e+00
C07 N06 N07 3.20e-12
L07 N06 N07 1.48e-10
R07 N06 N07 6.04e+02
C08 N07 Port2 8.84e-12
L08 N07 Port2 4.18e-11
R08 N07 Port2 4.29e+01
.ENDS GQM2195C1H820JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM2195C1H910GB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H910GB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 4.44e-02
C04 N03 N04 8.25e-10
L04 N03 N04 1.21e-11
R04 N03 N04 5.90e+00
C05 N04 N05 5.63e-12
L05 N04 N05 1.00e-10
R05 N04 N05 1.93e+02
C06 N05 Port2 2.47e-12
L06 N05 Port2 1.99e-10
R06 N05 Port2 4.85e+02
.ENDS GQM2195C1H910GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-05[uF]/50[V]
* Murata P/N :GQM2195C1H910JB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C1H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 4.44e-02
C04 N03 N04 8.25e-10
L04 N03 N04 1.21e-11
R04 N03 N04 5.90e+00
C05 N04 N05 5.63e-12
L05 N04 N05 1.00e-10
R05 N04 N05 1.93e+02
C06 N05 Port2 2.47e-12
L06 N05 Port2 1.99e-10
R06 N05 Port2 4.85e+02
.ENDS GQM2195C1H910JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GQM2195C2A100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.17e-11
R03 N02 N03 4.01e-02
L04 N03 N04 5.60e-12
R04 N03 N04 9.65e-02
C05 N04 N05 5.74e-11
L05 N04 N05 2.06e-11
R05 N04 N05 3.85e+01
C06 N05 N06 1.20e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 Port2 8.86e-13
L07 N06 Port2 3.70e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GQM2195C2A100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.17e-11
R03 N02 N03 4.01e-02
L04 N03 N04 5.60e-12
R04 N03 N04 9.65e-02
C05 N04 N05 5.74e-11
L05 N04 N05 2.06e-11
R05 N04 N05 3.85e+01
C06 N05 N06 1.20e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 Port2 8.86e-13
L07 N06 Port2 3.70e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-05[uF]/100[V]
* Murata P/N :GQM2195C2A110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 7.28e-02
L04 N03 N04 6.56e-12
R04 N03 N04 8.62e-03
C05 N04 N05 8.32e-11
L05 N04 N05 1.56e-11
R05 N04 N05 3.00e+01
C06 N05 Port2 1.49e-12
L06 N05 Port2 2.93e-10
R06 N05 Port2 1.51e+03
.ENDS GQM2195C2A110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-05[uF]/100[V]
* Murata P/N :GQM2195C2A110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 7.28e-02
L04 N03 N04 6.56e-12
R04 N03 N04 8.62e-03
C05 N04 N05 8.32e-11
L05 N04 N05 1.56e-11
R05 N04 N05 3.00e+01
C06 N05 Port2 1.49e-12
L06 N05 Port2 2.93e-10
R06 N05 Port2 1.51e+03
.ENDS GQM2195C2A110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GQM2195C2A120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.49e-11
R03 N02 N03 6.17e-02
L04 N03 N04 2.14e-12
R04 N03 N04 2.31e-02
C05 N04 N05 9.17e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.11e+01
C06 N05 Port2 1.19e-12
L06 N05 Port2 3.72e-10
R06 N05 Port2 9.51e+02
.ENDS GQM2195C2A120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GQM2195C2A120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.49e-11
R03 N02 N03 6.17e-02
L04 N03 N04 2.14e-12
R04 N03 N04 2.31e-02
C05 N04 N05 9.17e-11
L05 N04 N05 1.54e-11
R05 N04 N05 3.11e+01
C06 N05 Port2 1.19e-12
L06 N05 Port2 3.72e-10
R06 N05 Port2 9.51e+02
.ENDS GQM2195C2A120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-05[uF]/100[V]
* Murata P/N :GQM2195C2A130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-11
R03 N02 N03 6.19e-02
L04 N03 N04 3.58e-12
R04 N03 N04 7.12e-03
C05 N04 N05 8.55e-11
L05 N04 N05 1.78e-11
R05 N04 N05 2.91e+01
C06 N05 Port2 8.76e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2195C2A130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-05[uF]/100[V]
* Murata P/N :GQM2195C2A130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-11
R03 N02 N03 6.19e-02
L04 N03 N04 3.58e-12
R04 N03 N04 7.12e-03
C05 N04 N05 8.55e-11
L05 N04 N05 1.78e-11
R05 N04 N05 2.91e+01
C06 N05 Port2 8.76e-13
L06 N05 Port2 4.30e-10
R06 N05 Port2 1.59e+03
.ENDS GQM2195C2A130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GQM2195C2A150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.41e-12
R03 N02 N03 4.50e-02
L04 N03 N04 6.20e-12
R04 N03 N04 6.00e-02
C05 N04 N05 1.10e-10
L05 N04 N05 1.59e-11
R05 N04 N05 1.94e+01
C06 N05 N06 2.20e-11
L06 N05 N06 1.62e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 7.43e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GQM2195C2A150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.41e-12
R03 N02 N03 4.50e-02
L04 N03 N04 6.20e-12
R04 N03 N04 6.00e-02
C05 N04 N05 1.10e-10
L05 N04 N05 1.59e-11
R05 N04 N05 1.94e+01
C06 N05 N06 2.20e-11
L06 N05 N06 1.62e-11
R06 N05 N06 1.04e+01
C07 N06 Port2 7.43e-13
L07 N06 Port2 4.52e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-05[uF]/100[V]
* Murata P/N :GQM2195C2A160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 5.30e-02
L04 N03 N04 4.12e-12
R04 N03 N04 1.14e-02
C05 N04 N05 1.25e-10
L05 N04 N05 1.50e-11
R05 N04 N05 1.90e+01
C06 N05 Port2 1.37e-12
L06 N05 Port2 3.14e-10
R06 N05 Port2 1.08e+03
.ENDS GQM2195C2A160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-05[uF]/100[V]
* Murata P/N :GQM2195C2A160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 5.30e-02
L04 N03 N04 4.12e-12
R04 N03 N04 1.14e-02
C05 N04 N05 1.25e-10
L05 N04 N05 1.50e-11
R05 N04 N05 1.90e+01
C06 N05 Port2 1.37e-12
L06 N05 Port2 3.14e-10
R06 N05 Port2 1.08e+03
.ENDS GQM2195C2A160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GQM2195C2A180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.37e-11
R03 N02 N03 4.25e-02
L04 N03 N04 5.50e-12
R04 N03 N04 1.95e-02
C05 N04 N05 1.41e-10
L05 N04 N05 1.48e-11
R05 N04 N05 1.91e+01
C06 N05 N06 3.05e-12
L06 N05 N06 1.21e-10
R06 N05 N06 1.55e+02
C07 N06 Port2 9.80e-13
L07 N06 Port2 3.23e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GQM2195C2A180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.37e-11
R03 N02 N03 4.25e-02
L04 N03 N04 5.50e-12
R04 N03 N04 1.95e-02
C05 N04 N05 1.41e-10
L05 N04 N05 1.48e-11
R05 N04 N05 1.91e+01
C06 N05 N06 3.05e-12
L06 N05 N06 1.21e-10
R06 N05 N06 1.55e+02
C07 N06 Port2 9.80e-13
L07 N06 Port2 3.23e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.43e-10
R03 N02 N03 2.00e-01
C04 N03 N04 3.30e-11
L04 N03 N04 1.00e-11
C05 N04 Port2 5.28e-10
L05 N04 Port2 7.11e-13
R05 N04 Port2 2.01e-01
.ENDS GQM2195C2A1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.43e-10
R03 N02 N03 2.00e-01
C04 N03 N04 3.30e-11
L04 N03 N04 1.00e-11
C05 N04 Port2 5.28e-10
L05 N04 Port2 7.11e-13
R05 N04 Port2 2.01e-01
.ENDS GQM2195C2A1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.60e-10
R03 N02 N03 1.94e-01
L04 N03 N04 2.71e-13
R04 N03 N04 4.06e-03
C05 N04 N05 3.00e-10
L05 N04 N05 1.20e-12
R05 N04 N05 5.44e-01
C06 N05 Port2 1.30e-11
L06 N05 Port2 2.41e-11
R06 N05 Port2 1.00e+05
.ENDS GQM2195C2A1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.60e-10
R03 N02 N03 1.94e-01
L04 N03 N04 2.71e-13
R04 N03 N04 4.06e-03
C05 N04 N05 3.00e-10
L05 N04 N05 1.20e-12
R05 N04 N05 5.44e-01
C06 N05 Port2 1.30e-11
L06 N05 Port2 2.41e-11
R06 N05 Port2 1.00e+05
.ENDS GQM2195C2A1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.90e-01
C04 N03 N04 7.17e-11
L04 N03 N04 4.76e-12
R04 N03 N04 4.37e+00
C05 N04 Port2 3.68e-12
L05 N04 Port2 8.21e-11
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.90e-01
C04 N03 N04 7.17e-11
L04 N03 N04 4.76e-12
R04 N03 N04 4.37e+00
C05 N04 Port2 3.68e-12
L05 N04 Port2 8.21e-11
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.86e-01
C04 N03 N04 6.17e-11
L04 N03 N04 5.59e-12
R04 N03 N04 4.34e+00
C05 N04 Port2 1.79e-12
L05 N04 Port2 1.55e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.86e-01
C04 N03 N04 6.17e-11
L04 N03 N04 5.59e-12
R04 N03 N04 4.34e+00
C05 N04 Port2 1.79e-12
L05 N04 Port2 1.55e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.23e-12
L04 N03 N04 2.09e-10
C05 N04 Port2 7.93e-11
L05 N04 Port2 4.44e-12
R05 N04 Port2 2.01e+00
.ENDS GQM2195C2A1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.23e-12
L04 N03 N04 2.09e-10
C05 N04 Port2 7.93e-11
L05 N04 Port2 4.44e-12
R05 N04 Port2 2.01e+00
.ENDS GQM2195C2A1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.63e-01
C04 N03 N04 2.77e-11
L04 N03 N04 1.21e-11
R04 N03 N04 1.56e+01
C05 N04 Port2 2.38e-12
L05 N04 Port2 1.30e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 1.63e-01
C04 N03 N04 2.77e-11
L04 N03 N04 1.21e-11
R04 N03 N04 1.56e+01
C05 N04 Port2 2.38e-12
L05 N04 Port2 1.30e-10
R05 N04 Port2 1.00e+05
.ENDS GQM2195C2A1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 1.66e-01
C04 N03 N04 5.48e-11
L04 N03 N04 6.28e-12
R04 N03 N04 4.67e+00
C05 N04 Port2 2.37e-12
L05 N04 Port2 1.34e-10
R05 N04 Port2 1.77e+03
.ENDS GQM2195C2A1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GQM2195C2A1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 1.66e-01
C04 N03 N04 5.48e-11
L04 N03 N04 6.28e-12
R04 N03 N04 4.67e+00
C05 N04 Port2 2.37e-12
L05 N04 Port2 1.34e-10
R05 N04 Port2 1.77e+03
.ENDS GQM2195C2A1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 1.52e-12
L04 N03 Port2 2.06e-10
R04 N03 Port2 1.40e+03
.ENDS GQM2195C2A2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 1.52e-12
L04 N03 Port2 2.06e-10
R04 N03 Port2 1.40e+03
.ENDS GQM2195C2A2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 1.55e-12
L04 N03 Port2 2.02e-10
R04 N03 Port2 1.60e+03
.ENDS GQM2195C2A2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 1.55e-12
L04 N03 Port2 2.02e-10
R04 N03 Port2 1.60e+03
.ENDS GQM2195C2A2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.69e-10
R03 N02 N03 1.02e-01
L04 N03 N04 2.09e-12
R04 N03 N04 9.71e-03
C05 N04 Port2 3.57e-12
L05 N04 Port2 9.89e-11
R05 N04 Port2 3.05e+02
.ENDS GQM2195C2A2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.69e-10
R03 N02 N03 1.02e-01
L04 N03 N04 2.09e-12
R04 N03 N04 9.71e-03
C05 N04 Port2 3.57e-12
L05 N04 Port2 9.89e-11
R05 N04 Port2 3.05e+02
.ENDS GQM2195C2A2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.70e-10
R03 N02 N03 9.83e-02
L04 N03 N04 1.49e-12
R04 N03 N04 1.84e-02
C05 N04 Port2 3.76e-12
L05 N04 Port2 9.93e-11
R05 N04 Port2 3.47e+02
.ENDS GQM2195C2A2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GQM2195C2A2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.70e-10
R03 N02 N03 9.83e-02
L04 N03 N04 1.49e-12
R04 N03 N04 1.84e-02
C05 N04 Port2 3.76e-12
L05 N04 Port2 9.93e-11
R05 N04 Port2 3.47e+02
.ENDS GQM2195C2A2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.40e-12
L04 N03 N04 2.01e-10
R04 N03 N04 1.20e+03
C05 N04 Port2 4.47e-12
L05 N04 Port2 8.95e-11
R05 N04 Port2 6.71e+02
.ENDS GQM2195C2A3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.40e-12
L04 N03 N04 2.01e-10
R04 N03 N04 1.20e+03
C05 N04 Port2 4.47e-12
L05 N04 Port2 8.95e-11
R05 N04 Port2 6.71e+02
.ENDS GQM2195C2A3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-11
R03 N02 N03 8.00e-02
C04 N03 N04 8.66e-13
L04 N03 N04 3.05e-10
R04 N03 N04 1.50e+03
C05 N04 Port2 5.08e-12
L05 N04 Port2 8.31e-11
R05 N04 Port2 4.47e+02
.ENDS GQM2195C2A3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-11
R03 N02 N03 8.00e-02
C04 N03 N04 8.66e-13
L04 N03 N04 3.05e-10
R04 N03 N04 1.50e+03
C05 N04 Port2 5.08e-12
L05 N04 Port2 8.31e-11
R05 N04 Port2 4.47e+02
.ENDS GQM2195C2A3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 8.88e-02
L04 N03 N04 5.49e-12
R04 N03 N04 1.85e-02
C05 N04 N05 8.65e-12
L05 N04 N05 5.16e-11
R05 N04 N05 2.12e+02
C06 N05 N06 8.63e-12
L06 N05 N06 3.88e-11
R06 N05 N06 5.35e+01
C07 N06 Port2 3.65e-12
L07 N06 Port2 9.13e-11
R07 N06 Port2 1.64e+03
.ENDS GQM2195C2A3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 8.88e-02
L04 N03 N04 5.49e-12
R04 N03 N04 1.85e-02
C05 N04 N05 8.65e-12
L05 N04 N05 5.16e-11
R05 N04 N05 2.12e+02
C06 N05 N06 8.63e-12
L06 N05 N06 3.88e-11
R06 N05 N06 5.35e+01
C07 N06 Port2 3.65e-12
L07 N06 Port2 9.13e-11
R07 N06 Port2 1.64e+03
.ENDS GQM2195C2A3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 8.16e-02
L04 N03 N04 5.63e-12
R04 N03 N04 1.38e-02
C05 N04 N05 7.48e-12
L05 N04 N05 6.56e-11
R05 N04 N05 2.28e+02
C06 N05 N06 1.66e-11
L06 N05 N06 2.10e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 2.44e-12
L07 N06 Port2 1.36e-10
R07 N06 Port2 1.10e+03
.ENDS GQM2195C2A3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GQM2195C2A3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 8.16e-02
L04 N03 N04 5.63e-12
R04 N03 N04 1.38e-02
C05 N04 N05 7.48e-12
L05 N04 N05 6.56e-11
R05 N04 N05 2.28e+02
C06 N05 N06 1.66e-11
L06 N05 N06 2.10e-11
R06 N05 N06 1.40e+01
C07 N06 Port2 2.44e-12
L07 N06 Port2 1.36e-10
R07 N06 Port2 1.10e+03
.ENDS GQM2195C2A3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.64e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.10e+03
C05 N04 Port2 9.06e-12
L05 N04 Port2 5.43e-11
R05 N04 Port2 2.51e+02
.ENDS GQM2195C2A4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.64e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.10e+03
C05 N04 Port2 9.06e-12
L05 N04 Port2 5.43e-11
R05 N04 Port2 2.51e+02
.ENDS GQM2195C2A4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 6.77e-02
L04 N03 N04 1.23e-12
R04 N03 N04 7.71e-02
C05 N04 N05 1.00e-11
L05 N04 N05 5.21e-11
R05 N04 N05 1.66e+02
C06 N05 N06 8.83e-12
L06 N05 N06 3.88e-11
R06 N05 N06 2.76e+01
C07 N06 Port2 2.55e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 5.20e+03
.ENDS GQM2195C2A4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 6.77e-02
L04 N03 N04 1.23e-12
R04 N03 N04 7.71e-02
C05 N04 N05 1.00e-11
L05 N04 N05 5.21e-11
R05 N04 N05 1.66e+02
C06 N05 N06 8.83e-12
L06 N05 N06 3.88e-11
R06 N05 N06 2.76e+01
C07 N06 Port2 2.55e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 5.20e+03
.ENDS GQM2195C2A4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 6.00e-02
C04 N03 N04 8.49e-13
L04 N03 N04 3.76e-10
R04 N03 N04 2.00e+03
C05 N04 Port2 1.30e-11
L05 N04 Port2 4.54e-11
R05 N04 Port2 1.53e+02
.ENDS GQM2195C2A4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GQM2195C2A4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 6.00e-02
C04 N03 N04 8.49e-13
L04 N03 N04 3.76e-10
R04 N03 N04 2.00e+03
C05 N04 Port2 1.30e-11
L05 N04 Port2 4.54e-11
R05 N04 Port2 1.53e+02
.ENDS GQM2195C2A4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.65e-12
R04 N03 N04 1.75e-01
C05 N04 N05 1.01e-12
L05 N04 N05 3.09e-10
R05 N04 N05 3.50e+03
C06 N05 Port2 1.98e-11
L06 N05 Port2 3.17e-11
R06 N05 Port2 1.15e+02
.ENDS GQM2195C2A5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.65e-12
R04 N03 N04 1.75e-01
C05 N04 N05 1.01e-12
L05 N04 N05 3.09e-10
R05 N04 N05 3.50e+03
C06 N05 Port2 1.98e-11
L06 N05 Port2 3.17e-11
R06 N05 Port2 1.15e+02
.ENDS GQM2195C2A5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 5.48e-02
L04 N03 N04 1.91e-11
R04 N03 N04 3.50e-02
C05 N04 N05 2.20e-11
L05 N04 N05 2.86e-11
R05 N04 N05 9.17e+01
C06 N05 N06 3.96e-12
L06 N05 N06 8.38e-11
R06 N05 N06 1.16e+02
C07 N06 Port2 2.74e-12
L07 N06 Port2 1.17e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 5.48e-02
L04 N03 N04 1.91e-11
R04 N03 N04 3.50e-02
C05 N04 N05 2.20e-11
L05 N04 N05 2.86e-11
R05 N04 N05 9.17e+01
C06 N05 N06 3.96e-12
L06 N05 N06 8.38e-11
R06 N05 N06 1.16e+02
C07 N06 Port2 2.74e-12
L07 N06 Port2 1.17e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 5.68e-02
L04 N03 N04 1.07e-11
R04 N03 N04 3.18e-02
C05 N04 N05 2.17e-11
L05 N04 N05 3.17e-11
R05 N04 N05 9.19e+01
C06 N05 N06 3.30e-12
L06 N05 N06 1.06e-10
R06 N05 N06 4.81e+02
C07 N06 Port2 1.79e-12
L07 N06 Port2 1.87e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GQM2195C2A5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 5.68e-02
L04 N03 N04 1.07e-11
R04 N03 N04 3.18e-02
C05 N04 N05 2.17e-11
L05 N04 N05 3.17e-11
R05 N04 N05 9.19e+01
C06 N05 N06 3.30e-12
L06 N05 N06 1.06e-10
R06 N05 N06 4.81e+02
C07 N06 Port2 1.79e-12
L07 N06 Port2 1.87e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.60e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.47e-12
R04 N03 N04 2.44e-01
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.17e-11
L06 N05 Port2 2.31e-11
R06 N05 Port2 6.70e+01
.ENDS GQM2195C2A6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.60e-11
R03 N02 N03 4.00e-02
L04 N03 N04 6.47e-12
R04 N03 N04 2.44e-01
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.17e-11
L06 N05 Port2 2.31e-11
R06 N05 Port2 6.70e+01
.ENDS GQM2195C2A6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.45e-11
R03 N02 N03 5.14e-02
L04 N03 N04 1.54e-11
R04 N03 N04 3.88e-02
C05 N04 N05 2.62e-11
L05 N04 N05 2.87e-11
R05 N04 N05 8.61e+01
C06 N05 N06 3.22e-12
L06 N05 N06 1.02e-10
R06 N05 N06 2.27e+02
C07 N06 Port2 1.15e-12
L07 N06 Port2 2.82e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.45e-11
R03 N02 N03 5.14e-02
L04 N03 N04 1.54e-11
R04 N03 N04 3.88e-02
C05 N04 N05 2.62e-11
L05 N04 N05 2.87e-11
R05 N04 N05 8.61e+01
C06 N05 N06 3.22e-12
L06 N05 N06 1.02e-10
R06 N05 N06 2.27e+02
C07 N06 Port2 1.15e-12
L07 N06 Port2 2.82e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.10e-11
R03 N02 N03 5.00e-02
L04 N03 N04 5.17e-12
R04 N03 N04 9.74e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.89e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 5.12e+01
.ENDS GQM2195C2A6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GQM2195C2A6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.10e-11
R03 N02 N03 5.00e-02
L04 N03 N04 5.17e-12
R04 N03 N04 9.74e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.89e-11
L06 N05 Port2 2.11e-11
R06 N05 Port2 5.12e+01
.ENDS GQM2195C2A6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.70e-11
R03 N02 N03 5.00e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.48e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.62e-11
L06 N05 Port2 2.33e-11
R06 N05 Port2 5.50e+01
.ENDS GQM2195C2A7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.70e-11
R03 N02 N03 5.00e-02
L04 N03 N04 3.97e-12
R04 N03 N04 7.48e-02
C05 N04 N05 8.33e-13
L05 N04 N05 3.67e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 3.62e-11
L06 N05 Port2 2.33e-11
R06 N05 Port2 5.50e+01
.ENDS GQM2195C2A7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GQM2195C2A7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.56e-02
L04 N03 N04 9.81e-12
R04 N03 N04 2.78e-02
C05 N04 N05 3.53e-11
L05 N04 N05 2.54e-11
R05 N04 N05 5.10e+01
C06 N05 N06 2.56e-12
L06 N05 N06 1.36e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.31e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GQM2195C2A7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.56e-02
L04 N03 N04 9.81e-12
R04 N03 N04 2.78e-02
C05 N04 N05 3.53e-11
L05 N04 N05 2.54e-11
R05 N04 N05 5.10e+01
C06 N05 N06 2.56e-12
L06 N05 N06 1.36e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 1.39e-12
L07 N06 Port2 2.31e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.61e-12
R04 N03 N04 1.06e-01
C05 N04 N05 7.50e-13
L05 N04 N05 4.08e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 4.60e-11
L06 N05 Port2 2.07e-11
R06 N05 Port2 4.32e+01
.ENDS GQM2195C2A8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.61e-12
R04 N03 N04 1.06e-01
C05 N04 N05 7.50e-13
L05 N04 N05 4.08e-10
R05 N04 N05 4.20e+03
C06 N05 Port2 4.60e-11
L06 N05 Port2 2.07e-11
R06 N05 Port2 4.32e+01
.ENDS GQM2195C2A8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.61e-02
L04 N03 N04 2.02e-11
R04 N03 N04 4.15e-02
C05 N04 N05 3.70e-11
L05 N04 N05 2.64e-11
R05 N04 N05 4.69e+01
C06 N05 N06 2.03e-12
L06 N05 N06 1.84e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.90e-12
L07 N06 Port2 1.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GQM2195C2A8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.61e-02
L04 N03 N04 2.02e-11
R04 N03 N04 4.15e-02
C05 N04 N05 3.70e-11
L05 N04 N05 2.64e-11
R05 N04 N05 4.69e+01
C06 N05 N06 2.03e-12
L06 N05 N06 1.84e-10
R06 N05 N06 6.17e+02
C07 N06 Port2 1.90e-12
L07 N06 Port2 1.38e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2A8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.05e-12
R04 N03 N04 7.63e-02
C05 N04 N05 8.25e-13
L05 N04 N05 3.79e-10
R05 N04 N05 1.50e+03
C06 N05 Port2 5.65e-11
L06 N05 Port2 1.90e-11
R06 N05 Port2 4.03e+01
.ENDS GQM2195C2A9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GQM2195C2A9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.17e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.05e-12
R04 N03 N04 7.63e-02
C05 N04 N05 8.25e-13
L05 N04 N05 3.79e-10
R05 N04 N05 1.50e+03
C06 N05 Port2 5.65e-11
L06 N05 Port2 1.90e-11
R06 N05 Port2 4.03e+01
.ENDS GQM2195C2A9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 4.56e-02
L04 N03 N04 1.89e-11
R04 N03 N04 3.71e-02
C05 N04 N05 6.14e-11
L05 N04 N05 1.77e-11
R05 N04 N05 3.75e+01
C06 N05 Port2 1.92e-12
L06 N05 Port2 1.92e-10
R06 N05 Port2 4.09e+02
.ENDS GQM2195C2A9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GQM2195C2A9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2A9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 4.56e-02
L04 N03 N04 1.89e-11
R04 N03 N04 3.71e-02
C05 N04 N05 6.14e-11
L05 N04 N05 1.77e-11
R05 N04 N05 3.75e+01
C06 N05 Port2 1.92e-12
L06 N05 Port2 1.92e-10
R06 N05 Port2 4.09e+02
.ENDS GQM2195C2A9R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E100GB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2E100GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E100JB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195C2E100JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM2195C2E101GB12
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E101GB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-11
R03 N02 N03 3.00e-02
L04 N03 N04 1.99e-11
R04 N03 N04 1.21e+00
C05 N04 N05 2.11e-10
L05 N04 N05 4.18e-11
R05 N04 N05 1.74e+01
C06 N05 N06 9.71e-11
L06 N05 N06 3.47e-11
R06 N05 N06 1.99e+01
C07 N06 N07 1.74e-10
L07 N06 N07 9.35e-12
R07 N06 N07 7.40e+00
C08 N07 N08 7.35e-11
L08 N07 N08 1.36e-11
R08 N07 N08 1.38e+01
C09 N08 N09 1.17e-10
L09 N08 N09 5.62e-12
R09 N08 N09 6.83e+00
C10 N09 N10 4.40e-11
L10 N09 N10 1.09e-11
R10 N09 N10 1.51e+01
C11 N10 N11 4.60e-11
L11 N10 N11 7.84e-12
R11 N10 N11 9.33e+00
C12 N11 Port2 1.02e-12
L12 N11 Port2 2.29e-10
R12 N11 Port2 1.00e+05
.ENDS GQM2195C2E101GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM2195C2E101JB12
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E101JB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-11
R03 N02 N03 3.00e-02
L04 N03 N04 1.99e-11
R04 N03 N04 1.21e+00
C05 N04 N05 2.11e-10
L05 N04 N05 4.18e-11
R05 N04 N05 1.74e+01
C06 N05 N06 9.71e-11
L06 N05 N06 3.47e-11
R06 N05 N06 1.99e+01
C07 N06 N07 1.74e-10
L07 N06 N07 9.35e-12
R07 N06 N07 7.40e+00
C08 N07 N08 7.35e-11
L08 N07 N08 1.36e-11
R08 N07 N08 1.38e+01
C09 N08 N09 1.17e-10
L09 N08 N09 5.62e-12
R09 N08 N09 6.83e+00
C10 N09 N10 4.40e-11
L10 N09 N10 1.09e-11
R10 N09 N10 1.51e+01
C11 N10 N11 4.60e-11
L11 N10 N11 7.84e-12
R11 N10 N11 9.33e+00
C12 N11 Port2 1.02e-12
L12 N11 Port2 2.29e-10
R12 N11 Port2 1.00e+05
.ENDS GQM2195C2E101JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E110GB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195C2E110GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E110JB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195C2E110JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E120GB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E120GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E120JB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E120JB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E120JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E130GB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E130GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E130JB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E130JB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E130JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM2195C2E150GB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E150GB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E150GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM2195C2E150JB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E150JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E160GB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E160GB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E160GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E160JB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E160JB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E160JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM2195C2E180GB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E180GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM2195C2E180JB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E180JB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E180JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R0BB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R0BB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195C2E1R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R0CB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195C2E1R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R1BB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R1BB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195C2E1R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R1CB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R1CB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195C2E1R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R2BB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R2BB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195C2E1R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R2CB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195C2E1R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R3BB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R3BB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195C2E1R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R3CB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R3CB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195C2E1R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R5BB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R5BB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195C2E1R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R5CB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R5CB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195C2E1R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R6BB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195C2E1R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R6CB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R6CB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195C2E1R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R8BB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195C2E1R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R8CB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R8CB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195C2E1R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E200GB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195C2E200GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E200JB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E200JB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195C2E200JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E220GB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E220GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E220JB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E220JB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195C2E220JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195C2E240GB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E240GB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E240GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195C2E240JB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E240JB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E240JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195C2E270GB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E270GB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195C2E270GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195C2E270JB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E270JB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195C2E270JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R0BB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R0BB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195C2E2R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R0CB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195C2E2R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R2BB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R2BB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195C2E2R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R2CB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195C2E2R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R4BB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195C2E2R4BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R4CB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R4CB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195C2E2R4CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R7BB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R7BB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195C2E2R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R7CB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195C2E2R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E300GB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E300GB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195C2E300GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195C2E300JB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E300JB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195C2E300JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E330GB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E330GB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.21e-11
R03 N02 N03 3.58e-02
L04 N03 N04 3.08e-12
R04 N03 N04 2.05e-02
C05 N04 N05 6.32e-11
L05 N04 N05 4.72e-11
R05 N04 N05 4.29e+01
C06 N05 N06 2.85e-11
L06 N05 N06 4.02e-11
R06 N05 N06 4.84e+01
C07 N06 N07 2.27e-11
L07 N06 N07 2.45e-11
R07 N06 N07 2.79e+01
C08 N07 N08 9.08e-12
L08 N07 N08 3.74e-11
R08 N07 N08 7.04e+01
C09 N08 Port2 1.24e-12
L09 N08 Port2 2.01e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E330GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E330JB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E330JB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.21e-11
R03 N02 N03 3.58e-02
L04 N03 N04 3.08e-12
R04 N03 N04 2.05e-02
C05 N04 N05 6.32e-11
L05 N04 N05 4.72e-11
R05 N04 N05 4.29e+01
C06 N05 N06 2.85e-11
L06 N05 N06 4.02e-11
R06 N05 N06 4.84e+01
C07 N06 N07 2.27e-11
L07 N06 N07 2.45e-11
R07 N06 N07 2.79e+01
C08 N07 N08 9.08e-12
L08 N07 N08 3.74e-11
R08 N07 N08 7.04e+01
C09 N08 Port2 1.24e-12
L09 N08 Port2 2.01e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E330JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E360GB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E360GB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E360GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E360JB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E360JB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E360JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195C2E390GB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E390GB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E390GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195C2E390JB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E390JB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E390JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R0BB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R0BB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195C2E3R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R0CB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195C2E3R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R3BB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R3BB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195C2E3R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R3CB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R3CB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195C2E3R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R6BB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R6BB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195C2E3R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R6CB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R6CB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195C2E3R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R9BB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R9BB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195C2E3R9BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195C2E3R9CB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E3R9CB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195C2E3R9CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E430GB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E430GB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195C2E430GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195C2E430JB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E430JB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195C2E430JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195C2E470GB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E470GB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E470GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195C2E470JB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E470JB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E470JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R0BB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195C2E4R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R0CB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R0CB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195C2E4R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R3BB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R3BB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195C2E4R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R3CB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195C2E4R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R7BB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R7BB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195C2E4R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R7CB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195C2E4R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E510GB12
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E510GB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E510GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E510JB12
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E510JB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E510JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E560GB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E560GB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E560GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E560JB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E560JB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E560JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R0BB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195C2E5R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R0CB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195C2E5R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R1CB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195C2E5R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R1DB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R1DB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195C2E5R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R6CB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R6CB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195C2E5R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R6DB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R6DB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195C2E5R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E620GB12
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E620GB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E620GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E620JB12
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E620JB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E620JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195C2E680GB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E680GB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195C2E680GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195C2E680JB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E680JB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195C2E680JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R0CB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195C2E6R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R0DB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R0DB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195C2E6R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R2CB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R2CB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195C2E6R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R2DB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R2DB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195C2E6R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R8CB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R8CB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195C2E6R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R8DB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195C2E6R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195C2E750GB12
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E750GB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195C2E750GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195C2E750JB12
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E750JB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195C2E750JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E7R0CB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195C2E7R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E7R0DB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195C2E7R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM2195C2E7R5CB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E7R5CB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195C2E7R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM2195C2E7R5DB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195C2E7R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E820GB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E820GB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E820GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E820JB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E820JB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E820JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E8R0CB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E8R0CB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195C2E8R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E8R0DB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195C2E8R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E8R2CB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E8R2CB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195C2E8R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E8R2DB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E8R2DB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195C2E8R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E910GB12
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E910GB12 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.24e-10
R03 N02 N03 3.00e-02
L04 N03 N04 3.65e-12
R04 N03 N04 1.41e-02
C05 N04 N05 1.87e-10
L05 N04 N05 4.38e-11
R05 N04 N05 1.87e+01
C06 N05 N06 9.45e-11
L06 N05 N06 3.29e-11
R06 N05 N06 2.05e+01
C07 N06 N07 1.54e-10
L07 N06 N07 9.75e-12
R07 N06 N07 8.41e+00
C08 N07 N08 6.13e-11
L08 N07 N08 1.51e-11
R08 N07 N08 1.61e+01
C09 N08 N09 7.88e-11
L09 N08 N09 7.74e-12
R09 N08 N09 1.17e+01
C10 N09 N10 1.52e-11
L10 N09 N10 2.96e-11
R10 N09 N10 5.27e+01
C11 N10 Port2 2.81e-12
L11 N10 Port2 1.27e-10
R11 N10 Port2 3.10e+02
.ENDS GQM2195C2E910GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E910JB12
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E910JB12 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.24e-10
R03 N02 N03 3.00e-02
L04 N03 N04 3.65e-12
R04 N03 N04 1.41e-02
C05 N04 N05 1.87e-10
L05 N04 N05 4.38e-11
R05 N04 N05 1.87e+01
C06 N05 N06 9.45e-11
L06 N05 N06 3.29e-11
R06 N05 N06 2.05e+01
C07 N06 N07 1.54e-10
L07 N06 N07 9.75e-12
R07 N06 N07 8.41e+00
C08 N07 N08 6.13e-11
L08 N07 N08 1.51e-11
R08 N07 N08 1.61e+01
C09 N08 N09 7.88e-11
L09 N08 N09 7.74e-12
R09 N08 N09 1.17e+01
C10 N09 N10 1.52e-11
L10 N09 N10 2.96e-11
R10 N09 N10 5.27e+01
C11 N10 Port2 2.81e-12
L11 N10 Port2 1.27e-10
R11 N10 Port2 3.10e+02
.ENDS GQM2195C2E910JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E9R0CB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E9R0CB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195C2E9R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E9R0DB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195C2E9R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E9R1CB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E9R1CB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195C2E9R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E9R1DB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195C2E9R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E100FB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E100FB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2E100FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E100GB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2E100GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E100JB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2E100JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E100RB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E100RB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2E100RB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E110FB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E110FB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2E110FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E110GB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2E110GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E110JB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2E110JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E120FB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E120FB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E120FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E120GB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E120GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E120JB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E120JB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E120JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E130FB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E130FB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E130FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E130GB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E130GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E130JB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E130JB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E130JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E150FB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E150FB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E150FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E150GB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E150GB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E150GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E150JB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E150JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E160FB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E160FB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E160FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E160GB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E160GB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E160GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E160JB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E160JB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E160JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E180FB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E180FB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E180FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E180GB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E180GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E180JB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E180JB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E180JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R0BB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R0BB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2E1R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R0CB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2E1R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R0DB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R0DB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2E1R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R0WB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R0WB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2E1R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R1BB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R1BB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2E1R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R1CB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R1CB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2E1R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R1DB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R1DB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2E1R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R1WB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R1WB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2E1R1WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R2BB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R2BB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2E1R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R2CB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2E1R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R2DB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R2DB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2E1R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R2WB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R2WB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2E1R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R3BB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R3BB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2E1R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R3CB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R3CB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2E1R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R3DB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R3DB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2E1R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R3WB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R3WB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2E1R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R5BB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R5BB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2E1R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R5CB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R5CB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2E1R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R5DB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R5DB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2E1R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R5WB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R5WB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2E1R5WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R6BB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2E1R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R6CB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R6CB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2E1R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R6DB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R6DB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2E1R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R6WB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R6WB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2E1R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R8BB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2E1R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R8CB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R8CB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2E1R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R8DB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R8DB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2E1R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R8WB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R8WB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2E1R8WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E200FB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E200FB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2E200FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E200GB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2E200GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E200JB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E200JB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2E200JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E220FB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E220FB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E220FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E220GB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E220GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E220JB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E220JB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E220JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195G2E240FB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E240FB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E240FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195G2E240GB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E240GB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E240GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195G2E240JB12
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E240JB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E240JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E270FB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E270FB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195G2E270FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E270GB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E270GB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195G2E270GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E270JB12
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E270JB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195G2E270JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R0BB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R0BB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2E2R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R0CB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2E2R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R0DB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R0DB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2E2R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R0WB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R0WB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2E2R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R2BB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R2BB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2E2R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R2CB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2E2R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R2DB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R2DB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2E2R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R2WB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R2WB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2E2R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R4BB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2E2R4BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R4CB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R4CB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2E2R4CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R4DB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R4DB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2E2R4DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R4WB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R4WB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2E2R4WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R7BB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R7BB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2E2R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R7CB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2E2R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R7DB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R7DB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2E2R7DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E2R7WB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E2R7WB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2E2R7WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E300FB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E300FB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195G2E300FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E300GB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E300GB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195G2E300GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E300JB12
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E300JB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195G2E300JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E330FB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E330FB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.21e-11
R03 N02 N03 3.58e-02
L04 N03 N04 3.08e-12
R04 N03 N04 2.05e-02
C05 N04 N05 6.32e-11
L05 N04 N05 4.72e-11
R05 N04 N05 4.29e+01
C06 N05 N06 2.85e-11
L06 N05 N06 4.02e-11
R06 N05 N06 4.84e+01
C07 N06 N07 2.27e-11
L07 N06 N07 2.45e-11
R07 N06 N07 2.79e+01
C08 N07 N08 9.08e-12
L08 N07 N08 3.74e-11
R08 N07 N08 7.04e+01
C09 N08 Port2 1.24e-12
L09 N08 Port2 2.01e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E330FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E330GB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E330GB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.21e-11
R03 N02 N03 3.58e-02
L04 N03 N04 3.08e-12
R04 N03 N04 2.05e-02
C05 N04 N05 6.32e-11
L05 N04 N05 4.72e-11
R05 N04 N05 4.29e+01
C06 N05 N06 2.85e-11
L06 N05 N06 4.02e-11
R06 N05 N06 4.84e+01
C07 N06 N07 2.27e-11
L07 N06 N07 2.45e-11
R07 N06 N07 2.79e+01
C08 N07 N08 9.08e-12
L08 N07 N08 3.74e-11
R08 N07 N08 7.04e+01
C09 N08 Port2 1.24e-12
L09 N08 Port2 2.01e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E330GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E330JB12
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E330JB12 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.21e-11
R03 N02 N03 3.58e-02
L04 N03 N04 3.08e-12
R04 N03 N04 2.05e-02
C05 N04 N05 6.32e-11
L05 N04 N05 4.72e-11
R05 N04 N05 4.29e+01
C06 N05 N06 2.85e-11
L06 N05 N06 4.02e-11
R06 N05 N06 4.84e+01
C07 N06 N07 2.27e-11
L07 N06 N07 2.45e-11
R07 N06 N07 2.79e+01
C08 N07 N08 9.08e-12
L08 N07 N08 3.74e-11
R08 N07 N08 7.04e+01
C09 N08 Port2 1.24e-12
L09 N08 Port2 2.01e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E330JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E360FB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E360FB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E360FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E360GB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E360GB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E360GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E360JB12
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E360JB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E360JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195G2E390FB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E390FB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E390FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195G2E390GB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E390GB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E390GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195G2E390JB12
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E390JB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E390JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R0BB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R0BB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2E3R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R0CB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2E3R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R0DB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R0DB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2E3R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R0WB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R0WB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2E3R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R3BB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R3BB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2E3R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R3CB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R3CB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2E3R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R3DB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R3DB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2E3R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R3WB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R3WB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2E3R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R6BB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R6BB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2E3R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R6CB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R6CB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2E3R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R6DB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R6DB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2E3R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R6WB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R6WB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2E3R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R9BB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R9BB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2E3R9BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R9CB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R9CB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2E3R9CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R9DB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R9DB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2E3R9DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R9WB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R9WB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2E3R9WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E430FB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E430FB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195G2E430FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E430GB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E430GB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195G2E430GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E430JB12
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E430JB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195G2E430JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E470FB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E470FB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E470FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E470GB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E470GB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E470GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E470JB12
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E470JB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E470JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R0BB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2E4R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R0CB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R0CB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2E4R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R0DB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R0DB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2E4R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R0WB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R0WB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2E4R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R3BB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R3BB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2E4R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R3CB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2E4R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R3DB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R3DB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2E4R3DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R3WB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R3WB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2E4R3WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R7BB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R7BB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2E4R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R7CB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2E4R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R7DB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R7DB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2E4R7DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195G2E4R7WB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E4R7WB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2E4R7WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E510FB12
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E510FB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E510FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E510GB12
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E510GB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E510GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E510JB12
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E510JB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E510JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E560FB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E560FB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E560FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E560GB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E560GB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E560GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E560JB12
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E560JB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E560JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R0BB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2E5R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R0CB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2E5R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R0DB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R0DB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2E5R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R0WB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R0WB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2E5R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R1BB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R1BB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2E5R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R1CB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2E5R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R1DB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R1DB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2E5R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R1WB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R1WB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2E5R1WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R6BB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R6BB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2E5R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R6CB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R6CB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2E5R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R6DB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R6DB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2E5R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R6WB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R6WB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2E5R6WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E620FB12
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E620FB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E620FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E620GB12
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E620GB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E620GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E620JB12
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E620JB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E620JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E680FB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E680FB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195G2E680FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E680GB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E680GB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195G2E680GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E680JB12
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E680JB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195G2E680JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R0BB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R0BB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2E6R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R0CB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2E6R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R0DB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R0DB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2E6R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R0WB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R0WB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2E6R0WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R2BB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R2BB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2E6R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R2CB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R2CB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2E6R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R2DB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R2DB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2E6R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R2WB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R2WB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2E6R2WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R8BB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R8BB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2E6R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R8CB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R8CB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2E6R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R8DB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2E6R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R8WB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R8WB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2E6R8WB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E750FB12
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E750FB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195G2E750FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E750GB12
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E750GB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195G2E750GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E750JB12
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E750JB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195G2E750JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R0BB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R0BB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2E7R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R0CB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2E7R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R0DB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2E7R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R5BB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R5BB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2E7R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R5CB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R5CB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2E7R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R5DB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2E7R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E820FB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E820FB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E820FB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E820GB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E820GB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E820GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195G2E820JB12
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E820JB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195G2E820JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R0BB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R0BB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2E8R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R0CB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R0CB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2E8R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R0DB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2E8R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R2BB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R2BB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2E8R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R2CB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R2CB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2E8R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R2DB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R2DB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2E8R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R0BB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R0BB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195G2E9R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R0CB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R0CB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195G2E9R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R0DB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195G2E9R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R1BB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R1BB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195G2E9R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R1CB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R1CB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195G2E9R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E9R1DB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195G2E9R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/500[V]
* Murata P/N :GQM2195G2H100GB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2H100GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/500[V]
* Murata P/N :GQM2195G2H100JB12
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2H100JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/500[V]
* Murata P/N :GQM2195G2H110GB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2H110GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/500[V]
* Murata P/N :GQM2195G2H110JB12
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2H110JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-05[uF]/500[V]
* Murata P/N :GQM2195G2H120GB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2H120GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-05[uF]/500[V]
* Murata P/N :GQM2195G2H120JB12
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H120JB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2H120JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/500[V]
* Murata P/N :GQM2195G2H130GB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H130GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/500[V]
* Murata P/N :GQM2195G2H130JB12
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H130JB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H130JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-05[uF]/500[V]
* Murata P/N :GQM2195G2H150GB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H150GB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H150GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-05[uF]/500[V]
* Murata P/N :GQM2195G2H150JB12
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 3.73e-02
L04 N03 N04 1.90e-12
R04 N03 N04 2.17e-02
C05 N04 N05 2.41e-11
L05 N04 N05 5.69e-11
R05 N04 N05 8.20e+01
C06 N05 N06 8.32e-12
L06 N05 N06 6.55e-11
R06 N05 N06 1.74e+02
C07 N06 N07 5.50e-11
L07 N06 N07 6.06e-12
R07 N06 N07 1.93e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 1.84e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H150JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-05[uF]/500[V]
* Murata P/N :GQM2195G2H160GB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H160GB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H160GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-05[uF]/500[V]
* Murata P/N :GQM2195G2H160JB12
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H160JB12 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.49e-11
R03 N02 N03 3.66e-02
L04 N03 N04 6.20e-12
R04 N03 N04 1.76e-02
C05 N04 N05 2.78e-11
L05 N04 N05 5.29e-11
R05 N04 N05 8.30e+01
C06 N05 N06 8.82e-12
L06 N05 N06 6.64e-11
R06 N05 N06 1.42e+02
C07 N06 N07 1.56e-12
L07 N06 N07 1.72e-10
R07 N06 N07 2.74e+02
C08 N07 Port2 9.73e-13
L08 N07 Port2 3.47e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H160JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-05[uF]/500[V]
* Murata P/N :GQM2195G2H180GB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H180GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-05[uF]/500[V]
* Murata P/N :GQM2195G2H180JB12
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H180JB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.31e-11
R03 N02 N03 3.00e-02
L04 N03 N04 7.79e-12
R04 N03 N04 4.89e-02
C05 N04 N05 3.59e-11
L05 N04 N05 4.52e-11
R05 N04 N05 8.16e+01
C06 N05 N06 1.21e-11
L06 N05 N06 5.34e-11
R06 N05 N06 9.52e+01
C07 N06 N07 1.90e-11
L07 N06 N07 1.72e-11
R07 N06 N07 1.92e+01
C08 N07 Port2 1.30e-12
L08 N07 Port2 1.85e-10
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H180JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R0BB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R0BB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2H1R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R0CB12
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2H1R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R1BB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R1BB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2H1R1BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R1CB12
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R1CB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2H1R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R2BB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R2BB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2H1R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R2CB12
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195G2H1R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R3BB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R3BB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2H1R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R3CB12
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R3CB12 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 1.60e-01
C04 N03 N04 1.51e-12
L04 N03 N04 1.52e-10
C05 N04 Port2 1.04e-10
L05 N04 Port2 3.37e-12
R05 N04 Port2 1.87e+00
.ENDS GQM2195G2H1R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R5BB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R5BB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2H1R5BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R5CB12
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R5CB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2H1R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R6BB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2H1R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R6CB12
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R6CB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.00e-12
L04 N03 N04 1.24e-10
C05 N04 Port2 1.90e-10
L05 N04 Port2 1.84e-12
R05 N04 Port2 3.92e-01
.ENDS GQM2195G2H1R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R8BB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2H1R8BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.80e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R8CB12
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R8CB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.20e-01
C04 N03 N04 1.37e-12
L04 N03 N04 1.81e-10
C05 N04 Port2 1.35e-10
L05 N04 Port2 2.59e-12
R05 N04 Port2 5.52e-01
.ENDS GQM2195G2H1R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/500[V]
* Murata P/N :GQM2195G2H200GB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2H200GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/500[V]
* Murata P/N :GQM2195G2H200JB12
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H200JB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2H200JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-05[uF]/500[V]
* Murata P/N :GQM2195G2H220GB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H220GB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-05[uF]/500[V]
* Murata P/N :GQM2195G2H220JB12
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H220JB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 4.07e-02
L04 N03 N04 6.56e-12
R04 N03 N04 2.03e-01
C05 N04 N05 4.26e-11
L05 N04 N05 4.80e-11
R05 N04 N05 7.63e+01
C06 N05 N06 1.82e-11
L06 N05 N06 4.41e-11
R06 N05 N06 9.53e+01
C07 N06 N07 2.62e-11
L07 N06 N07 1.49e-11
R07 N06 N07 5.36e+01
C08 N07 Port2 5.52e-12
L08 N07 Port2 5.14e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2H220JB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R0BB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R0BB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2H2R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R0CB12
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2H2R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R2BB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R2BB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2H2R2BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R2CB12
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 7.00e-02
L04 N03 N04 3.83e-12
R04 N03 N04 1.44e-01
C05 N04 Port2 1.68e-12
L05 N04 Port2 1.68e-10
R05 N04 Port2 1.20e+03
.ENDS GQM2195G2H2R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R4BB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2H2R4BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.40e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R4CB12
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R4CB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 8.00e-02
C04 N03 N04 2.08e-12
L04 N03 N04 1.43e-10
C05 N04 Port2 9.68e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.33e-01
.ENDS GQM2195G2H2R4CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R7BB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R7BB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2H2R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R7CB12
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195G2H2R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R0BB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R0BB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2H3R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R0CB12
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2H3R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R3BB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R3BB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2H3R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R3CB12
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R3CB12 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.22e-12
R04 N03 N04 1.56e-01
C05 N04 Port2 3.26e-12
L05 N04 Port2 1.13e-10
R05 N04 Port2 7.39e+02
.ENDS GQM2195G2H3R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R6BB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R6BB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2H3R6BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R6CB12
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R6CB12 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.88e-10
R03 N02 N03 6.00e-02
L04 N03 N04 2.68e-12
R04 N03 N04 1.51e-01
C05 N04 Port2 4.11e-12
L05 N04 Port2 9.33e-11
R05 N04 Port2 4.29e+02
.ENDS GQM2195G2H3R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R9BB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R9BB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2H3R9BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-06[uF]/500[V]
* Murata P/N :GQM2195G2H3R9CB12
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H3R9CB12 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.06e-12
R04 N03 N04 4.57e-01
C05 N04 N05 2.90e-12
L05 N04 N05 8.50e-11
C06 N05 Port2 4.52e-12
L06 N05 Port2 9.24e-11
R06 N05 Port2 2.92e+02
.ENDS GQM2195G2H3R9CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R0BB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2H4R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R0CB12
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R0CB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 4.50e-02
L04 N03 N04 7.38e-12
R04 N03 N04 5.50e-01
C05 N04 N05 1.10e-12
L05 N04 N05 1.80e-10
R05 N04 N05 2.00e+03
C06 N05 Port2 4.78e-12
L06 N05 Port2 8.82e-11
R06 N05 Port2 3.91e+02
.ENDS GQM2195G2H4R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R3BB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R3BB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2H4R3BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R3CB12
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 5.00e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.30e-01
C05 N04 N05 4.62e-12
L05 N04 N05 6.10e-11
R05 N04 N05 2.67e+02
C06 N05 Port2 4.77e-12
L06 N05 Port2 9.02e-11
R06 N05 Port2 4.22e+02
.ENDS GQM2195G2H4R3CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R7BB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R7BB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2H4R7BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.70e-06[uF]/500[V]
* Murata P/N :GQM2195G2H4R7CB12
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195G2H4R7CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R0BB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2H5R0BB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R0CB12
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195G2H5R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R1CB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2H5R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R1DB12
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R1DB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.73e-12
R04 N03 N04 1.76e-01
C05 N04 N05 1.96e-12
L05 N04 N05 1.21e-10
C06 N05 Port2 6.93e-12
L06 N05 Port2 7.19e-11
R06 N05 Port2 2.43e+02
.ENDS GQM2195G2H5R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R6CB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R6CB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2H5R6CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/500[V]
* Murata P/N :GQM2195G2H5R6DB12
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H5R6DB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2H5R6DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R0CB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2H6R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R0DB12
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R0DB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.29e-12
R04 N03 N04 2.07e-02
C05 N04 N05 2.16e-12
L05 N04 N05 1.38e-10
R05 N04 N05 4.80e+02
C06 N05 Port2 6.74e-12
L06 N05 Port2 8.53e-11
R06 N05 Port2 2.36e+02
.ENDS GQM2195G2H6R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R2CB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R2CB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2H6R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R2DB12
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R2DB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2H6R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R8CB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R8CB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2H6R8CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-06[uF]/500[V]
* Murata P/N :GQM2195G2H6R8DB12
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195G2H6R8DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H7R0CB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2H7R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H7R0DB12
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2H7R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/500[V]
* Murata P/N :GQM2195G2H7R5CB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H7R5CB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2H7R5CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/500[V]
* Murata P/N :GQM2195G2H7R5DB12
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2H7R5DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H8R0CB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H8R0CB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2H8R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H8R0DB12
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2H8R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H8R2CB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H8R2CB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2H8R2CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/500[V]
* Murata P/N :GQM2195G2H8R2DB12
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H8R2DB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2H8R2DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H9R0CB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H9R0CB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195G2H9R0CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H9R0DB12
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.42e-12
R04 N03 N04 2.78e-02
C05 N04 N05 1.93e-12
L05 N04 N05 1.62e-10
R05 N04 N05 5.50e+02
C06 N05 Port2 1.64e-11
L06 N05 Port2 5.27e-11
R06 N05 Port2 1.21e+02
.ENDS GQM2195G2H9R0DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H9R1CB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H9R1CB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195G2H9R1CB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/9.10e-06[uF]/500[V]
* Murata P/N :GQM2195G2H9R1DB12
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195G2H9R1DB12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.36e-12
R03 N02 N03 2.99e-02
C04 N03 N04 6.42e-12
L04 N03 N04 1.72e-10
R04 N03 N04 3.41e+02
C05 N04 N05 2.33e-12
L05 N04 N05 2.13e-10
R05 N04 N05 8.87e+02
C06 N05 Port2 2.38e-11
L06 N05 Port2 1.26e-11
R06 N05 Port2 8.80e+00
.ENDS GQM22M5C2H100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.36e-12
R03 N02 N03 2.99e-02
C04 N03 N04 6.42e-12
L04 N03 N04 1.72e-10
R04 N03 N04 3.41e+02
C05 N04 N05 2.33e-12
L05 N04 N05 2.13e-10
R05 N04 N05 8.87e+02
C06 N05 Port2 2.38e-11
L06 N05 Port2 1.26e-11
R06 N05 Port2 8.80e+00
.ENDS GQM22M5C2H100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-04[uF]/500[V]
* Murata P/N :GQM22M5C2H101GB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H101GB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.34e-02
C04 N03 N04 1.39e-10
L04 N03 N04 7.10e-11
R04 N03 N04 6.49e+01
C05 N04 N05 7.42e-11
L05 N04 N05 4.51e-11
R05 N04 N05 5.62e+01
C06 N05 N06 9.93e-11
L06 N05 N06 1.57e-11
R06 N05 N06 2.40e+01
C07 N06 N07 4.21e-11
L07 N06 N07 2.22e-11
R07 N06 N07 3.66e+01
C08 N07 N08 2.87e-11
L08 N07 N08 2.14e-11
R08 N07 N08 3.94e+01
C09 N08 N09 6.73e-12
L09 N08 N09 6.89e-11
R09 N08 N09 1.11e+02
C10 N09 Port2 4.91e-12
L10 N09 Port2 7.65e-11
R10 N09 Port2 9.44e+01
.ENDS GQM22M5C2H101GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-04[uF]/500[V]
* Murata P/N :GQM22M5C2H101JB01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.34e-02
C04 N03 N04 1.39e-10
L04 N03 N04 7.10e-11
R04 N03 N04 6.49e+01
C05 N04 N05 7.42e-11
L05 N04 N05 4.51e-11
R05 N04 N05 5.62e+01
C06 N05 N06 9.93e-11
L06 N05 N06 1.57e-11
R06 N05 N06 2.40e+01
C07 N06 N07 4.21e-11
L07 N06 N07 2.22e-11
R07 N06 N07 3.66e+01
C08 N07 N08 2.87e-11
L08 N07 N08 2.14e-11
R08 N07 N08 3.94e+01
C09 N08 N09 6.73e-12
L09 N08 N09 6.89e-11
R09 N08 N09 1.11e+02
C10 N09 Port2 4.91e-12
L10 N09 Port2 7.65e-11
R10 N09 Port2 9.44e+01
.ENDS GQM22M5C2H101JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 2.95e-02
L04 N03 N04 1.71e-13
R04 N03 N04 4.21e-03
C05 N04 N05 7.40e-12
L05 N04 N05 1.70e-10
R05 N04 N05 4.09e+02
C06 N05 N06 5.04e-12
L06 N05 N06 1.29e-10
R06 N05 N06 3.56e+02
C07 N06 N07 1.55e-10
L07 N06 N07 2.13e-12
R07 N06 N07 2.90e+00
C08 N07 Port2 1.97e-10
L08 N07 Port2 8.53e-14
R08 N07 Port2 1.86e+00
.ENDS GQM22M5C2H110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 2.95e-02
L04 N03 N04 1.71e-13
R04 N03 N04 4.21e-03
C05 N04 N05 7.40e-12
L05 N04 N05 1.70e-10
R05 N04 N05 4.09e+02
C06 N05 N06 5.04e-12
L06 N05 N06 1.29e-10
R06 N05 N06 3.56e+02
C07 N06 N07 1.55e-10
L07 N06 N07 2.13e-12
R07 N06 N07 2.90e+00
C08 N07 Port2 1.97e-10
L08 N07 Port2 8.53e-14
R08 N07 Port2 1.86e+00
.ENDS GQM22M5C2H110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.13e-11
R03 N02 N03 2.94e-02
C04 N03 N04 8.31e-12
L04 N03 N04 1.54e-10
R04 N03 N04 3.25e+02
C05 N04 N05 2.51e-12
L05 N04 N05 2.06e-10
R05 N04 N05 1.01e+03
C06 N05 Port2 8.57e-12
L06 N05 Port2 3.77e-11
R06 N05 Port2 2.18e+02
.ENDS GQM22M5C2H120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.13e-11
R03 N02 N03 2.94e-02
C04 N03 N04 8.31e-12
L04 N03 N04 1.54e-10
R04 N03 N04 3.25e+02
C05 N04 N05 2.51e-12
L05 N04 N05 2.06e-10
R05 N04 N05 1.01e+03
C06 N05 Port2 8.57e-12
L06 N05 Port2 3.77e-11
R06 N05 Port2 2.18e+02
.ENDS GQM22M5C2H120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.60e-11
R03 N02 N03 2.93e-02
C04 N03 N04 8.97e-12
L04 N03 N04 1.61e-10
R04 N03 N04 4.08e+02
C05 N04 N05 4.05e-12
L05 N04 N05 1.69e-10
R05 N04 N05 4.20e+02
C06 N05 Port2 1.92e-11
L06 N05 Port2 1.94e-11
R06 N05 Port2 7.40e+01
.ENDS GQM22M5C2H130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.60e-11
R03 N02 N03 2.93e-02
C04 N03 N04 8.97e-12
L04 N03 N04 1.61e-10
R04 N03 N04 4.08e+02
C05 N04 N05 4.05e-12
L05 N04 N05 1.69e-10
R05 N04 N05 4.20e+02
C06 N05 Port2 1.92e-11
L06 N05 Port2 1.94e-11
R06 N05 Port2 7.40e+01
.ENDS GQM22M5C2H130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.25e-11
R03 N02 N03 3.02e-02
C04 N03 N04 1.26e-11
L04 N03 N04 1.31e-10
R04 N03 N04 2.59e+02
C05 N04 N05 4.00e-12
L05 N04 N05 1.73e-10
R05 N04 N05 3.90e+02
C06 N05 Port2 6.06e-12
L06 N05 Port2 6.49e-11
R06 N05 Port2 1.81e+02
.ENDS GQM22M5C2H150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.25e-11
R03 N02 N03 3.02e-02
C04 N03 N04 1.26e-11
L04 N03 N04 1.31e-10
R04 N03 N04 2.59e+02
C05 N04 N05 4.00e-12
L05 N04 N05 1.73e-10
R05 N04 N05 3.90e+02
C06 N05 Port2 6.06e-12
L06 N05 Port2 6.49e-11
R06 N05 Port2 1.81e+02
.ENDS GQM22M5C2H150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.88e-11
R03 N02 N03 2.89e-02
C04 N03 N04 1.23e-11
L04 N03 N04 1.41e-10
R04 N03 N04 2.42e+02
C05 N04 N05 4.82e-12
L05 N04 N05 1.58e-10
R05 N04 N05 2.81e+02
C06 N05 Port2 1.18e-11
L06 N05 Port2 3.74e-11
R06 N05 Port2 7.04e+01
.ENDS GQM22M5C2H160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.88e-11
R03 N02 N03 2.89e-02
C04 N03 N04 1.23e-11
L04 N03 N04 1.41e-10
R04 N03 N04 2.42e+02
C05 N04 N05 4.82e-12
L05 N04 N05 1.58e-10
R05 N04 N05 2.81e+02
C06 N05 Port2 1.18e-11
L06 N05 Port2 3.74e-11
R06 N05 Port2 7.04e+01
.ENDS GQM22M5C2H160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.80e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.29e-11
R03 N02 N03 3.10e-02
C04 N03 N04 1.61e-11
L04 N03 N04 1.18e-10
R04 N03 N04 2.21e+02
C05 N04 N05 4.17e-12
L05 N04 N05 1.79e-10
R05 N04 N05 3.79e+02
C06 N05 Port2 3.61e-12
L06 N05 Port2 1.16e-10
R06 N05 Port2 4.50e+02
.ENDS GQM22M5C2H180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.80e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.29e-11
R03 N02 N03 3.10e-02
C04 N03 N04 1.61e-11
L04 N03 N04 1.18e-10
R04 N03 N04 2.21e+02
C05 N04 N05 4.17e-12
L05 N04 N05 1.79e-10
R05 N04 N05 3.79e+02
C06 N05 Port2 3.61e-12
L06 N05 Port2 1.16e-10
R06 N05 Port2 4.50e+02
.ENDS GQM22M5C2H180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.59e-10
R03 N02 N03 2.30e-01
C04 N03 N04 6.00e-12
L04 N03 N04 5.59e-11
C05 N04 Port2 8.17e-11
L05 N04 Port2 3.78e-12
R05 N04 Port2 1.08e+00
.ENDS GQM22M5C2H1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.59e-10
R03 N02 N03 2.30e-01
C04 N03 N04 6.00e-12
L04 N03 N04 5.59e-11
C05 N04 Port2 8.17e-11
L05 N04 Port2 3.78e-12
R05 N04 Port2 1.08e+00
.ENDS GQM22M5C2H1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 1.70e-01
C04 N03 N04 2.95e-12
L04 N03 N04 1.02e-10
C05 N04 Port2 1.87e-10
L05 N04 Port2 1.89e-12
R05 N04 Port2 8.53e-01
.ENDS GQM22M5C2H1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 1.70e-01
C04 N03 N04 2.95e-12
L04 N03 N04 1.02e-10
C05 N04 Port2 1.87e-10
L05 N04 Port2 1.89e-12
R05 N04 Port2 8.53e-01
.ENDS GQM22M5C2H1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.92e-10
R03 N02 N03 1.40e-01
C04 N03 Port2 4.29e-12
L04 N03 Port2 8.84e-11
R04 N03 Port2 6.40e+02
.ENDS GQM22M5C2H1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.92e-10
R03 N02 N03 1.40e-01
C04 N03 Port2 4.29e-12
L04 N03 Port2 8.84e-11
R04 N03 Port2 6.40e+02
.ENDS GQM22M5C2H1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.56e-10
R03 N02 N03 1.30e-01
C04 N03 Port2 4.04e-12
L04 N03 Port2 9.86e-11
R04 N03 Port2 7.88e+02
.ENDS GQM22M5C2H1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.56e-10
R03 N02 N03 1.30e-01
C04 N03 Port2 4.04e-12
L04 N03 Port2 9.86e-11
R04 N03 Port2 7.88e+02
.ENDS GQM22M5C2H1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.50e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.30e-01
C04 N03 Port2 3.68e-12
L04 N03 Port2 1.14e-10
R04 N03 Port2 1.24e+03
.ENDS GQM22M5C2H1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.50e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.30e-01
C04 N03 Port2 3.68e-12
L04 N03 Port2 1.14e-10
R04 N03 Port2 1.24e+03
.ENDS GQM22M5C2H1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 4.80e-12
L04 N03 Port2 8.26e-11
R04 N03 Port2 5.52e+02
.ENDS GQM22M5C2H1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.27e-10
R03 N02 N03 1.10e-01
C04 N03 Port2 4.80e-12
L04 N03 Port2 8.26e-11
R04 N03 Port2 5.52e+02
.ENDS GQM22M5C2H1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.80e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 3.92e-12
L04 N03 Port2 1.23e-10
R04 N03 Port2 6.75e+02
.ENDS GQM22M5C2H1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.80e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 1.00e-01
C04 N03 Port2 3.92e-12
L04 N03 Port2 1.23e-10
R04 N03 Port2 6.75e+02
.ENDS GQM22M5C2H1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.89e-11
R03 N02 N03 2.78e-02
C04 N03 N04 2.08e-11
L04 N03 N04 1.02e-10
R04 N03 N04 2.27e+02
C05 N04 N05 6.42e-12
L05 N04 N05 1.34e-10
R05 N04 N05 3.47e+02
C06 N05 N06 3.86e-12
L06 N05 N06 1.29e-10
R06 N05 N06 4.17e+02
C07 N06 Port2 8.24e-12
L07 N06 Port2 4.43e-11
R07 N06 Port2 3.01e+02
.ENDS GQM22M5C2H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.89e-11
R03 N02 N03 2.78e-02
C04 N03 N04 2.08e-11
L04 N03 N04 1.02e-10
R04 N03 N04 2.27e+02
C05 N04 N05 6.42e-12
L05 N04 N05 1.34e-10
R05 N04 N05 3.47e+02
C06 N05 N06 3.86e-12
L06 N05 N06 1.29e-10
R06 N05 N06 4.17e+02
C07 N06 Port2 8.24e-12
L07 N06 Port2 4.43e-11
R07 N06 Port2 3.01e+02
.ENDS GQM22M5C2H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-13
R03 N02 N03 3.00e-02
C04 N03 N04 2.80e-11
L04 N03 N04 8.06e-11
R04 N03 N04 1.18e+02
C05 N04 N05 6.48e-12
L05 N04 N05 1.34e-10
R05 N04 N05 4.83e+02
C06 N05 N06 2.91e-12
L06 N05 N06 1.57e-10
R06 N05 N06 5.11e+02
C07 N06 Port2 3.58e-12
L07 N06 Port2 8.80e-11
R07 N06 Port2 3.45e+02
.ENDS GQM22M5C2H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-13
R03 N02 N03 3.00e-02
C04 N03 N04 2.80e-11
L04 N03 N04 8.06e-11
R04 N03 N04 1.18e+02
C05 N04 N05 6.48e-12
L05 N04 N05 1.34e-10
R05 N04 N05 4.83e+02
C06 N05 N06 2.91e-12
L06 N05 N06 1.57e-10
R06 N05 N06 5.11e+02
C07 N06 Port2 3.58e-12
L07 N06 Port2 8.80e-11
R07 N06 Port2 3.45e+02
.ENDS GQM22M5C2H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.40e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.05e-11
R03 N02 N03 3.02e-02
C04 N03 N04 2.65e-11
L04 N03 N04 9.36e-11
R04 N03 N04 1.71e+02
C05 N04 N05 7.37e-12
L05 N04 N05 1.39e-10
R05 N04 N05 3.59e+02
C06 N05 N06 5.42e-12
L06 N05 N06 1.16e-10
R06 N05 N06 3.39e+02
C07 N06 N07 2.93e-11
L07 N06 N07 1.54e-11
R07 N06 N07 3.48e+01
C08 N07 Port2 4.04e-11
L08 N07 Port2 7.47e-12
R08 N07 Port2 3.41e+01
.ENDS GQM22M5C2H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.40e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.05e-11
R03 N02 N03 3.02e-02
C04 N03 N04 2.65e-11
L04 N03 N04 9.36e-11
R04 N03 N04 1.71e+02
C05 N04 N05 7.37e-12
L05 N04 N05 1.39e-10
R05 N04 N05 3.59e+02
C06 N05 N06 5.42e-12
L06 N05 N06 1.16e-10
R06 N05 N06 3.39e+02
C07 N06 N07 2.93e-11
L07 N06 N07 1.54e-11
R07 N06 N07 3.48e+01
C08 N07 Port2 4.04e-11
L08 N07 Port2 7.47e-12
R08 N07 Port2 3.41e+01
.ENDS GQM22M5C2H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.72e-12
R03 N02 N03 2.91e-02
C04 N03 N04 3.71e-11
L04 N03 N04 7.39e-11
R04 N03 N04 1.33e+02
C05 N04 N05 9.45e-12
L05 N04 N05 1.07e-10
R05 N04 N05 2.47e+02
C06 N05 N06 3.73e-12
L06 N05 N06 1.42e-10
R06 N05 N06 4.20e+02
C07 N06 Port2 2.71e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 9.23e+02
.ENDS GQM22M5C2H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.72e-12
R03 N02 N03 2.91e-02
C04 N03 N04 3.71e-11
L04 N03 N04 7.39e-11
R04 N03 N04 1.33e+02
C05 N04 N05 9.45e-12
L05 N04 N05 1.07e-10
R05 N04 N05 2.47e+02
C06 N05 N06 3.73e-12
L06 N05 N06 1.42e-10
R06 N05 N06 4.20e+02
C07 N06 Port2 2.71e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 9.23e+02
.ENDS GQM22M5C2H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 7.00e-02
C04 N03 Port2 2.98e-12
L04 N03 Port2 1.69e-10
R04 N03 Port2 2.14e+03
.ENDS GQM22M5C2H2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 7.00e-02
C04 N03 Port2 2.98e-12
L04 N03 Port2 1.69e-10
R04 N03 Port2 2.14e+03
.ENDS GQM22M5C2H2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.42e-09
L04 N03 N04 2.44e-13
C05 N04 Port2 3.02e-12
L05 N04 Port2 1.69e-10
R05 N04 Port2 1.76e+03
.ENDS GQM22M5C2H2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.42e-09
L04 N03 N04 2.44e-13
C05 N04 Port2 3.02e-12
L05 N04 Port2 1.69e-10
R05 N04 Port2 1.76e+03
.ENDS GQM22M5C2H2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.40e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 7.00e-02
C04 N03 Port2 3.13e-12
L04 N03 Port2 1.80e-10
R04 N03 Port2 1.69e+03
.ENDS GQM22M5C2H2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.40e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 7.00e-02
C04 N03 Port2 3.13e-12
L04 N03 Port2 1.80e-10
R04 N03 Port2 1.69e+03
.ENDS GQM22M5C2H2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 6.00e-02
C04 N03 N04 7.07e-10
L04 N03 N04 4.85e-13
C05 N04 Port2 2.93e-12
L05 N04 Port2 1.93e-10
R05 N04 Port2 2.72e+03
.ENDS GQM22M5C2H2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 6.00e-02
C04 N03 N04 7.07e-10
L04 N03 N04 4.85e-13
C05 N04 Port2 2.93e-12
L05 N04 Port2 1.93e-10
R05 N04 Port2 2.72e+03
.ENDS GQM22M5C2H2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.49e-11
R03 N02 N03 2.90e-02
C04 N03 N04 3.17e-11
L04 N03 N04 9.59e-11
R04 N03 N04 1.38e+02
C05 N04 N05 9.55e-12
L05 N04 N05 1.23e-10
R05 N04 N05 2.78e+02
C06 N05 N06 4.91e-12
L06 N05 N06 1.39e-10
R06 N05 N06 3.72e+02
C07 N06 N07 1.57e-11
L07 N06 N07 3.24e-11
R07 N06 N07 9.62e+01
C08 N07 Port2 5.98e-11
L08 N07 Port2 6.21e-12
R08 N07 Port2 2.13e+01
.ENDS GQM22M5C2H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.00e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.49e-11
R03 N02 N03 2.90e-02
C04 N03 N04 3.17e-11
L04 N03 N04 9.59e-11
R04 N03 N04 1.38e+02
C05 N04 N05 9.55e-12
L05 N04 N05 1.23e-10
R05 N04 N05 2.78e+02
C06 N05 N06 4.91e-12
L06 N05 N06 1.39e-10
R06 N05 N06 3.72e+02
C07 N06 N07 1.57e-11
L07 N06 N07 3.24e-11
R07 N06 N07 9.62e+01
C08 N07 Port2 5.98e-11
L08 N07 Port2 6.21e-12
R08 N07 Port2 2.13e+01
.ENDS GQM22M5C2H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.00e-11
R03 N02 N03 2.99e-02
C04 N03 N04 4.72e-11
L04 N03 N04 6.95e-11
R04 N03 N04 8.43e+01
C05 N04 N05 1.33e-11
L05 N04 N05 8.89e-11
R05 N04 N05 2.00e+02
C06 N05 N06 4.33e-12
L06 N05 N06 1.40e-10
R06 N05 N06 3.34e+02
C07 N06 N07 7.09e-12
L07 N06 N07 6.41e-11
R07 N06 N07 2.49e+02
C08 N07 Port2 1.42e-11
L08 N07 Port2 2.21e-11
R08 N07 Port2 1.87e+01
.ENDS GQM22M5C2H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.00e-11
R03 N02 N03 2.99e-02
C04 N03 N04 4.72e-11
L04 N03 N04 6.95e-11
R04 N03 N04 8.43e+01
C05 N04 N05 1.33e-11
L05 N04 N05 8.89e-11
R05 N04 N05 2.00e+02
C06 N05 N06 4.33e-12
L06 N05 N06 1.40e-10
R06 N05 N06 3.34e+02
C07 N06 N07 7.09e-12
L07 N06 N07 6.41e-11
R07 N06 N07 2.49e+02
C08 N07 Port2 1.42e-11
L08 N07 Port2 2.21e-11
R08 N07 Port2 1.87e+01
.ENDS GQM22M5C2H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.13e-11
R03 N02 N03 3.01e-02
C04 N03 N04 3.86e-11
L04 N03 N04 9.54e-11
R04 N03 N04 1.09e+02
C05 N04 N05 1.28e-11
L05 N04 N05 1.07e-10
R05 N04 N05 1.93e+02
C06 N05 N06 5.19e-12
L06 N05 N06 1.42e-10
R06 N05 N06 3.63e+02
C07 N06 N07 9.41e-12
L07 N06 N07 5.92e-11
R07 N06 N07 1.72e+02
C08 N07 Port2 4.33e-11
L08 N07 Port2 8.92e-12
R08 N07 Port2 2.84e+01
.ENDS GQM22M5C2H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.13e-11
R03 N02 N03 3.01e-02
C04 N03 N04 3.86e-11
L04 N03 N04 9.54e-11
R04 N03 N04 1.09e+02
C05 N04 N05 1.28e-11
L05 N04 N05 1.07e-10
R05 N04 N05 1.93e+02
C06 N05 N06 5.19e-12
L06 N05 N06 1.42e-10
R06 N05 N06 3.63e+02
C07 N06 N07 9.41e-12
L07 N06 N07 5.92e-11
R07 N06 N07 1.72e+02
C08 N07 Port2 4.33e-11
L08 N07 Port2 8.92e-12
R08 N07 Port2 2.84e+01
.ENDS GQM22M5C2H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.90e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 4.16e-11
L04 N03 N04 9.69e-11
R04 N03 N04 1.28e+02
C05 N04 N05 1.76e-11
L05 N04 N05 8.32e-11
R05 N04 N05 1.36e+02
C06 N05 N06 1.34e-11
L06 N05 N06 5.58e-11
R06 N05 N06 1.21e+02
C07 N06 N07 4.97e-12
L07 N06 N07 1.06e-10
R07 N06 N07 2.65e+02
C08 N07 N08 4.35e-12
L08 N07 N08 9.14e-11
R08 N07 N08 2.12e+02
C09 N08 Port2 8.81e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 2.08e+02
.ENDS GQM22M5C2H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.90e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 4.16e-11
L04 N03 N04 9.69e-11
R04 N03 N04 1.28e+02
C05 N04 N05 1.76e-11
L05 N04 N05 8.32e-11
R05 N04 N05 1.36e+02
C06 N05 N06 1.34e-11
L06 N05 N06 5.58e-11
R06 N05 N06 1.21e+02
C07 N06 N07 4.97e-12
L07 N06 N07 1.06e-10
R07 N06 N07 2.65e+02
C08 N07 N08 4.35e-12
L08 N07 N08 9.14e-11
R08 N07 N08 2.12e+02
C09 N08 Port2 8.81e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 2.08e+02
.ENDS GQM22M5C2H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 5.50e-02
C04 N03 Port2 3.08e-12
L04 N03 Port2 1.98e-10
R04 N03 Port2 1.03e+03
.ENDS GQM22M5C2H3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 5.50e-02
C04 N03 Port2 3.08e-12
L04 N03 Port2 1.98e-10
R04 N03 Port2 1.03e+03
.ENDS GQM22M5C2H3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.50e-02
C04 N03 Port2 2.90e-12
L04 N03 Port2 2.10e-10
R04 N03 Port2 1.83e+03
.ENDS GQM22M5C2H3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.50e-02
C04 N03 Port2 2.90e-12
L04 N03 Port2 2.10e-10
R04 N03 Port2 1.83e+03
.ENDS GQM22M5C2H3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 5.50e-02
C04 N03 N04 1.93e-09
L04 N03 N04 1.80e-13
C05 N04 N05 3.73e-10
L05 N04 N05 8.39e-13
R05 N04 N05 5.22e-01
C06 N05 Port2 3.00e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.32e+03
.ENDS GQM22M5C2H3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 5.50e-02
C04 N03 N04 1.93e-09
L04 N03 N04 1.80e-13
C05 N04 N05 3.73e-10
L05 N04 N05 8.39e-13
R05 N04 N05 5.22e-01
C06 N05 Port2 3.00e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.32e+03
.ENDS GQM22M5C2H3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.90e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 5.50e-02
C04 N03 N04 1.05e-11
L04 N03 N04 2.76e-11
R04 N03 N04 2.90e+02
C05 N04 Port2 2.72e-12
L05 N04 Port2 2.31e-10
R05 N04 Port2 2.09e+03
.ENDS GQM22M5C2H3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.90e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 5.50e-02
C04 N03 N04 1.05e-11
L04 N03 N04 2.76e-11
R04 N03 N04 2.90e+02
C05 N04 Port2 2.72e-12
L05 N04 Port2 2.31e-10
R05 N04 Port2 2.09e+03
.ENDS GQM22M5C2H3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.28e-11
R03 N02 N03 2.69e-02
C04 N03 N04 5.05e-11
L04 N03 N04 8.63e-11
R04 N03 N04 1.27e+02
C05 N04 N05 1.86e-11
L05 N04 N05 8.31e-11
R05 N04 N05 1.75e+02
C06 N05 N06 6.86e-12
L06 N05 N06 1.15e-10
R06 N05 N06 2.97e+02
C07 N06 N07 6.08e-12
L07 N06 N07 9.86e-11
R07 N06 N07 3.14e+02
C08 N07 Port2 2.91e-11
L08 N07 Port2 1.44e-11
R08 N07 Port2 4.69e+01
.ENDS GQM22M5C2H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.28e-11
R03 N02 N03 2.69e-02
C04 N03 N04 5.05e-11
L04 N03 N04 8.63e-11
R04 N03 N04 1.27e+02
C05 N04 N05 1.86e-11
L05 N04 N05 8.31e-11
R05 N04 N05 1.75e+02
C06 N05 N06 6.86e-12
L06 N05 N06 1.15e-10
R06 N05 N06 2.97e+02
C07 N06 N07 6.08e-12
L07 N06 N07 9.86e-11
R07 N06 N07 3.14e+02
C08 N07 Port2 2.91e-11
L08 N07 Port2 1.44e-11
R08 N07 Port2 4.69e+01
.ENDS GQM22M5C2H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 6.74e-11
L04 N03 N04 6.77e-11
R04 N03 N04 1.31e+02
C05 N04 N05 2.14e-11
L05 N04 N05 7.53e-11
R05 N04 N05 1.71e+02
C06 N05 N06 1.24e-11
L06 N05 N06 6.08e-11
R06 N05 N06 1.38e+02
C07 N06 N07 3.04e-12
L07 N06 N07 1.61e-10
R07 N06 N07 3.82e+02
C08 N07 Port2 2.06e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.24e+02
.ENDS GQM22M5C2H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 6.74e-11
L04 N03 N04 6.77e-11
R04 N03 N04 1.31e+02
C05 N04 N05 2.14e-11
L05 N04 N05 7.53e-11
R05 N04 N05 1.71e+02
C06 N05 N06 1.24e-11
L06 N05 N06 6.08e-11
R06 N05 N06 1.38e+02
C07 N06 N07 3.04e-12
L07 N06 N07 1.61e-10
R07 N06 N07 3.82e+02
C08 N07 Port2 2.06e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.24e+02
.ENDS GQM22M5C2H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
C04 N03 N04 8.91e-12
L04 N03 N04 3.00e-11
R04 N03 N04 3.57e+02
C05 N04 Port2 2.84e-12
L05 N04 Port2 2.27e-10
R05 N04 Port2 2.04e+03
.ENDS GQM22M5C2H4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.00e-02
C04 N03 N04 8.91e-12
L04 N03 N04 3.00e-11
R04 N03 N04 3.57e+02
C05 N04 Port2 2.84e-12
L05 N04 Port2 2.27e-10
R05 N04 Port2 2.04e+03
.ENDS GQM22M5C2H4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 4.50e-02
C04 N03 N04 7.07e-11
L04 N03 N04 3.98e-12
C05 N04 N05 9.34e-12
L05 N04 N05 3.40e-11
R05 N04 N05 3.41e+02
C06 N05 Port2 3.06e-12
L06 N05 Port2 2.20e-10
R06 N05 Port2 2.74e+03
.ENDS GQM22M5C2H4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 4.50e-02
C04 N03 N04 7.07e-11
L04 N03 N04 3.98e-12
C05 N04 N05 9.34e-12
L05 N04 N05 3.40e-11
R05 N04 N05 3.41e+02
C06 N05 Port2 3.06e-12
L06 N05 Port2 2.20e-10
R06 N05 Port2 2.74e+03
.ENDS GQM22M5C2H4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.79e-12
R04 N03 N04 8.94e-02
C05 N04 N05 7.84e-12
L05 N04 N05 4.22e-11
C06 N05 N06 4.78e-11
L06 N05 N06 7.33e-12
R06 N05 N06 1.10e+01
C07 N06 Port2 3.06e-12
L07 N06 Port2 2.33e-10
R07 N06 Port2 3.72e+03
.ENDS GQM22M5C2H4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.79e-12
R04 N03 N04 8.94e-02
C05 N04 N05 7.84e-12
L05 N04 N05 4.22e-11
C06 N05 N06 4.78e-11
L06 N05 N06 7.33e-12
R06 N05 N06 1.10e+01
C07 N06 Port2 3.06e-12
L07 N06 Port2 2.33e-10
R07 N06 Port2 3.72e+03
.ENDS GQM22M5C2H4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H510GB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.96e-11
R03 N02 N03 2.93e-02
C04 N03 N04 5.82e-11
L04 N03 N04 8.75e-11
R04 N03 N04 1.06e+02
C05 N04 N05 2.27e-11
L05 N04 N05 7.77e-11
R05 N04 N05 1.34e+02
C06 N05 N06 9.18e-12
L06 N05 N06 9.44e-11
R06 N05 N06 2.12e+02
C07 N06 N07 4.83e-12
L07 N06 N07 1.34e-10
R07 N06 N07 3.76e+02
C08 N07 N08 2.15e-11
L08 N07 N08 2.14e-11
R08 N07 N08 5.82e+01
C09 N08 Port2 3.89e-10
L09 N08 Port2 8.74e-13
R09 N08 Port2 1.03e+00
.ENDS GQM22M5C2H510GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H510JB01
* Property : C = 5.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H510JB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.96e-11
R03 N02 N03 2.93e-02
C04 N03 N04 5.82e-11
L04 N03 N04 8.75e-11
R04 N03 N04 1.06e+02
C05 N04 N05 2.27e-11
L05 N04 N05 7.77e-11
R05 N04 N05 1.34e+02
C06 N05 N06 9.18e-12
L06 N05 N06 9.44e-11
R06 N05 N06 2.12e+02
C07 N06 N07 4.83e-12
L07 N06 N07 1.34e-10
R07 N06 N07 3.76e+02
C08 N07 N08 2.15e-11
L08 N07 N08 2.14e-11
R08 N07 N08 5.82e+01
C09 N08 Port2 3.89e-10
L09 N08 Port2 8.74e-13
R09 N08 Port2 1.03e+00
.ENDS GQM22M5C2H510JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H560GB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H560GB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.58e-11
R03 N02 N03 2.75e-02
C04 N03 N04 8.31e-11
L04 N03 N04 6.57e-11
R04 N03 N04 6.70e+01
C05 N04 N05 3.32e-11
L05 N04 N05 5.94e-11
R05 N04 N05 9.84e+01
C06 N05 N06 2.22e-11
L06 N05 N06 4.31e-11
R06 N05 N06 5.82e+01
C07 N06 N07 6.53e-12
L07 N06 N07 1.01e-10
R07 N06 N07 2.40e+02
C08 N07 N08 5.02e-12
L08 N07 N08 1.02e-10
R08 N07 N08 2.38e+02
C09 N08 N09 1.49e-11
L09 N08 N09 2.82e-11
R09 N08 N09 5.90e+01
C10 N09 Port2 2.17e-11
L10 N09 Port2 1.60e-11
R10 N09 Port2 4.19e+01
.ENDS GQM22M5C2H560GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H560JB01
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.58e-11
R03 N02 N03 2.75e-02
C04 N03 N04 8.31e-11
L04 N03 N04 6.57e-11
R04 N03 N04 6.70e+01
C05 N04 N05 3.32e-11
L05 N04 N05 5.94e-11
R05 N04 N05 9.84e+01
C06 N05 N06 2.22e-11
L06 N05 N06 4.31e-11
R06 N05 N06 5.82e+01
C07 N06 N07 6.53e-12
L07 N06 N07 1.01e-10
R07 N06 N07 2.40e+02
C08 N07 N08 5.02e-12
L08 N07 N08 1.02e-10
R08 N07 N08 2.38e+02
C09 N08 N09 1.49e-11
L09 N08 N09 2.82e-11
R09 N08 N09 5.90e+01
C10 N09 Port2 2.17e-11
L10 N09 Port2 1.60e-11
R10 N09 Port2 4.19e+01
.ENDS GQM22M5C2H560JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.54e-12
R04 N03 N04 3.42e-01
C05 N04 N05 5.10e-12
L05 N04 N05 6.54e-11
R05 N04 N05 2.40e+02
C06 N05 Port2 3.12e-12
L06 N05 Port2 2.28e-10
R06 N05 Port2 1.96e+03
.ENDS GQM22M5C2H5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.54e-12
R04 N03 N04 3.42e-01
C05 N04 N05 5.10e-12
L05 N04 N05 6.54e-11
R05 N04 N05 2.40e+02
C06 N05 Port2 3.12e-12
L06 N05 Port2 2.28e-10
R06 N05 Port2 1.96e+03
.ENDS GQM22M5C2H5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.14e-12
R04 N03 N04 1.46e-01
C05 N04 N05 3.91e-11
L05 N04 N05 8.52e-12
C06 N05 N06 7.37e-12
L06 N05 N06 4.78e-11
R06 N05 N06 2.16e+02
C07 N06 Port2 3.22e-12
L07 N06 Port2 2.21e-10
R07 N06 Port2 4.94e+03
.ENDS GQM22M5C2H5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.14e-12
R04 N03 N04 1.46e-01
C05 N04 N05 3.91e-11
L05 N04 N05 8.52e-12
C06 N05 N06 7.37e-12
L06 N05 N06 4.78e-11
R06 N05 N06 2.16e+02
C07 N06 Port2 3.22e-12
L07 N06 Port2 2.21e-10
R07 N06 Port2 4.94e+03
.ENDS GQM22M5C2H5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 1.63e-12
R04 N03 N04 8.37e-02
C05 N04 N05 7.34e-11
L05 N04 N05 4.38e-12
C06 N05 N06 5.17e-12
L06 N05 N06 7.24e-11
R06 N05 N06 2.20e+03
C07 N06 Port2 3.43e-12
L07 N06 Port2 2.28e-10
R07 N06 Port2 2.89e+03
.ENDS GQM22M5C2H5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 1.63e-12
R04 N03 N04 8.37e-02
C05 N04 N05 7.34e-11
L05 N04 N05 4.38e-12
C06 N05 N06 5.17e-12
L06 N05 N06 7.24e-11
R06 N05 N06 2.20e+03
C07 N06 Port2 3.43e-12
L07 N06 Port2 2.28e-10
R07 N06 Port2 2.89e+03
.ENDS GQM22M5C2H5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H620GB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-11
R03 N02 N03 2.69e-02
C04 N03 N04 7.63e-11
L04 N03 N04 7.91e-11
R04 N03 N04 8.39e+01
C05 N04 N05 3.04e-11
L05 N04 N05 6.87e-11
R05 N04 N05 1.04e+02
C06 N05 N06 1.53e-11
L06 N05 N06 6.47e-11
R06 N05 N06 1.23e+02
C07 N06 N07 4.28e-12
L07 N06 N07 1.65e-10
R07 N06 N07 3.78e+02
C08 N07 N08 1.28e-11
L08 N07 N08 4.07e-11
R08 N07 N08 9.50e+01
C09 N08 Port2 9.18e-11
L09 N08 Port2 4.08e-12
R09 N08 Port2 8.71e+00
.ENDS GQM22M5C2H620GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H620JB01
* Property : C = 6.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H620JB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-11
R03 N02 N03 2.69e-02
C04 N03 N04 7.63e-11
L04 N03 N04 7.91e-11
R04 N03 N04 8.39e+01
C05 N04 N05 3.04e-11
L05 N04 N05 6.87e-11
R05 N04 N05 1.04e+02
C06 N05 N06 1.53e-11
L06 N05 N06 6.47e-11
R06 N05 N06 1.23e+02
C07 N06 N07 4.28e-12
L07 N06 N07 1.65e-10
R07 N06 N07 3.78e+02
C08 N07 N08 1.28e-11
L08 N07 N08 4.07e-11
R08 N07 N08 9.50e+01
C09 N08 Port2 9.18e-11
L09 N08 Port2 4.08e-12
R09 N08 Port2 8.71e+00
.ENDS GQM22M5C2H620JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H680GB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H680GB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-11
R03 N02 N03 2.48e-02
C04 N03 N04 9.11e-11
L04 N03 N04 7.29e-11
R04 N03 N04 6.73e+01
C05 N04 N05 3.84e-11
L05 N04 N05 6.02e-11
R05 N04 N05 6.94e+01
C06 N05 N06 3.24e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.60e+01
C07 N06 N07 8.60e-12
L07 N06 N07 8.54e-11
R07 N06 N07 1.76e+02
C08 N07 N08 4.50e-12
L08 N07 N08 1.22e-10
R08 N07 N08 3.06e+02
C09 N08 N09 8.72e-12
L09 N08 N09 5.29e-11
R09 N08 N09 1.42e+02
C10 N09 N10 1.67e-11
L10 N09 N10 2.30e-11
R10 N09 N10 5.04e+01
C11 N10 Port2 1.32e-11
L11 N10 Port2 2.73e-11
R11 N10 Port2 2.54e+02
.ENDS GQM22M5C2H680GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H680JB01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-11
R03 N02 N03 2.48e-02
C04 N03 N04 9.11e-11
L04 N03 N04 7.29e-11
R04 N03 N04 6.73e+01
C05 N04 N05 3.84e-11
L05 N04 N05 6.02e-11
R05 N04 N05 6.94e+01
C06 N05 N06 3.24e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.60e+01
C07 N06 N07 8.60e-12
L07 N06 N07 8.54e-11
R07 N06 N07 1.76e+02
C08 N07 N08 4.50e-12
L08 N07 N08 1.22e-10
R08 N07 N08 3.06e+02
C09 N08 N09 8.72e-12
L09 N08 N09 5.29e-11
R09 N08 N09 1.42e+02
C10 N09 N10 1.67e-11
L10 N09 N10 2.30e-11
R10 N09 N10 5.04e+01
C11 N10 Port2 1.32e-11
L11 N10 Port2 2.73e-11
R11 N10 Port2 2.54e+02
.ENDS GQM22M5C2H680JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.50e-11
R03 N02 N03 3.50e-02
C04 N03 N04 4.96e-12
L04 N03 N04 8.20e-11
R04 N03 N04 4.58e+02
C05 N04 Port2 3.48e-12
L05 N04 Port2 2.37e-10
R05 N04 Port2 1.27e+03
.ENDS GQM22M5C2H6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.50e-11
R03 N02 N03 3.50e-02
C04 N03 N04 4.96e-12
L04 N03 N04 8.20e-11
R04 N03 N04 4.58e+02
C05 N04 Port2 3.48e-12
L05 N04 Port2 2.37e-10
R05 N04 Port2 1.27e+03
.ENDS GQM22M5C2H6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 3.50e-02
C04 N03 N04 4.60e-12
L04 N03 N04 8.88e-11
R04 N03 N04 3.14e+02
C05 N04 Port2 3.40e-12
L05 N04 Port2 2.43e-10
R05 N04 Port2 7.52e+02
.ENDS GQM22M5C2H6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 3.50e-02
C04 N03 N04 4.60e-12
L04 N03 N04 8.88e-11
R04 N03 N04 3.14e+02
C05 N04 Port2 3.40e-12
L05 N04 Port2 2.43e-10
R05 N04 Port2 7.52e+02
.ENDS GQM22M5C2H6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 3.09e-12
R04 N03 N04 1.30e-01
C05 N04 N05 3.12e-12
L05 N04 N05 1.35e-10
R05 N04 N05 2.83e+03
C06 N05 Port2 3.74e-12
L06 N05 Port2 2.28e-10
R06 N05 Port2 2.36e+03
.ENDS GQM22M5C2H6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 3.09e-12
R04 N03 N04 1.30e-01
C05 N04 N05 3.12e-12
L05 N04 N05 1.35e-10
R05 N04 N05 2.83e+03
C06 N05 Port2 3.74e-12
L06 N05 Port2 2.28e-10
R06 N05 Port2 2.36e+03
.ENDS GQM22M5C2H6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H750GB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H750GB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.88e-11
R03 N02 N03 2.74e-02
C04 N03 N04 9.72e-11
L04 N03 N04 7.64e-11
R04 N03 N04 5.45e+01
C05 N04 N05 4.68e-11
L05 N04 N05 5.56e-11
R05 N04 N05 5.76e+01
C06 N05 N06 4.60e-11
L06 N05 N06 2.73e-11
R06 N05 N06 4.04e+01
C07 N06 N07 1.21e-11
L07 N06 N07 6.71e-11
R07 N06 N07 1.17e+02
C08 N07 N08 4.85e-12
L08 N07 N08 1.25e-10
R08 N07 N08 2.88e+02
C09 N08 N09 1.25e-11
L09 N08 N09 4.10e-11
R09 N08 N09 9.04e+01
C10 N09 Port2 4.94e-11
L10 N09 Port2 8.20e-12
R10 N09 Port2 1.66e+01
.ENDS GQM22M5C2H750GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H750JB01
* Property : C = 7.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.88e-11
R03 N02 N03 2.74e-02
C04 N03 N04 9.72e-11
L04 N03 N04 7.64e-11
R04 N03 N04 5.45e+01
C05 N04 N05 4.68e-11
L05 N04 N05 5.56e-11
R05 N04 N05 5.76e+01
C06 N05 N06 4.60e-11
L06 N05 N06 2.73e-11
R06 N05 N06 4.04e+01
C07 N06 N07 1.21e-11
L07 N06 N07 6.71e-11
R07 N06 N07 1.17e+02
C08 N07 N08 4.85e-12
L08 N07 N08 1.25e-10
R08 N07 N08 2.88e+02
C09 N08 N09 1.25e-11
L09 N08 N09 4.10e-11
R09 N08 N09 9.04e+01
C10 N09 Port2 4.94e-11
L10 N09 Port2 8.20e-12
R10 N09 Port2 1.66e+01
.ENDS GQM22M5C2H750JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.30e-11
R03 N02 N03 3.50e-02
C04 N03 N04 3.98e-12
L04 N03 N04 1.12e-10
R04 N03 N04 6.64e+02
C05 N04 Port2 3.73e-12
L05 N04 Port2 2.34e-10
R05 N04 Port2 1.06e+03
.ENDS GQM22M5C2H7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.30e-11
R03 N02 N03 3.50e-02
C04 N03 N04 3.98e-12
L04 N03 N04 1.12e-10
R04 N03 N04 6.64e+02
C05 N04 Port2 3.73e-12
L05 N04 Port2 2.34e-10
R05 N04 Port2 1.06e+03
.ENDS GQM22M5C2H7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.50e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-11
R03 N02 N03 3.50e-02
C04 N03 N04 2.60e-12
L04 N03 N04 1.66e-10
R04 N03 N04 8.16e+02
C05 N04 Port2 4.31e-12
L05 N04 Port2 2.13e-10
R05 N04 Port2 5.11e+02
.ENDS GQM22M5C2H7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.50e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-11
R03 N02 N03 3.50e-02
C04 N03 N04 2.60e-12
L04 N03 N04 1.66e-10
R04 N03 N04 8.16e+02
C05 N04 Port2 4.31e-12
L05 N04 Port2 2.13e-10
R05 N04 Port2 5.11e+02
.ENDS GQM22M5C2H7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H820GB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H820GB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 2.14e-02
C04 N03 N04 1.34e-10
L04 N03 N04 5.97e-11
R04 N03 N04 4.62e+01
C05 N04 N05 4.79e-11
L05 N04 N05 5.77e-11
R05 N04 N05 5.54e+01
C06 N05 N06 4.62e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 N07 1.31e-11
L07 N06 N07 6.22e-11
R07 N06 N07 1.04e+02
C08 N07 N08 4.70e-12
L08 N07 N08 1.20e-10
R08 N07 N08 2.84e+02
C09 N08 N09 3.99e-12
L09 N08 N09 1.19e-10
R09 N08 N09 3.15e+02
C10 N09 Port2 9.66e-12
L10 N09 Port2 3.85e-11
R10 N09 Port2 1.62e+02
.ENDS GQM22M5C2H820GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H820JB01
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H820JB01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 2.14e-02
C04 N03 N04 1.34e-10
L04 N03 N04 5.97e-11
R04 N03 N04 4.62e+01
C05 N04 N05 4.79e-11
L05 N04 N05 5.77e-11
R05 N04 N05 5.54e+01
C06 N05 N06 4.62e-11
L06 N05 N06 2.81e-11
R06 N05 N06 3.84e+01
C07 N06 N07 1.31e-11
L07 N06 N07 6.22e-11
R07 N06 N07 1.04e+02
C08 N07 N08 4.70e-12
L08 N07 N08 1.20e-10
R08 N07 N08 2.84e+02
C09 N08 N09 3.99e-12
L09 N08 N09 1.19e-10
R09 N08 N09 3.15e+02
C10 N09 Port2 9.66e-12
L10 N09 Port2 3.85e-11
R10 N09 Port2 1.62e+02
.ENDS GQM22M5C2H820JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-12
R03 N02 N03 3.00e-02
C04 N03 N04 2.15e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.95e+03
C05 N04 Port2 4.71e-12
L05 N04 Port2 2.01e-10
R05 N04 Port2 5.45e+02
.ENDS GQM22M5C2H8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-12
R03 N02 N03 3.00e-02
C04 N03 N04 2.15e-12
L04 N03 N04 1.99e-10
R04 N03 N04 1.95e+03
C05 N04 Port2 4.71e-12
L05 N04 Port2 2.01e-10
R05 N04 Port2 5.45e+02
.ENDS GQM22M5C2H8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.20e-11
R03 N02 N03 3.00e-02
C04 N03 N04 2.34e-12
L04 N03 N04 1.88e-10
R04 N03 N04 1.13e+03
C05 N04 Port2 5.17e-12
L05 N04 Port2 1.85e-10
R05 N04 Port2 3.65e+02
.ENDS GQM22M5C2H8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/8.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.20e-11
R03 N02 N03 3.00e-02
C04 N03 N04 2.34e-12
L04 N03 N04 1.88e-10
R04 N03 N04 1.13e+03
C05 N04 Port2 5.17e-12
L05 N04 Port2 1.85e-10
R05 N04 Port2 3.65e+02
.ENDS GQM22M5C2H8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H910GB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H910GB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.91e-11
R03 N02 N03 2.62e-02
C04 N03 N04 1.23e-10
L04 N03 N04 7.29e-11
R04 N03 N04 5.58e+01
C05 N04 N05 6.01e-11
L05 N04 N05 5.20e-11
R05 N04 N05 5.71e+01
C06 N05 N06 5.99e-11
L06 N05 N06 2.49e-11
R06 N05 N06 3.80e+01
C07 N06 N07 1.58e-11
L07 N06 N07 6.04e-11
R07 N06 N07 1.03e+02
C08 N07 N08 5.12e-12
L08 N07 N08 1.36e-10
R08 N07 N08 3.02e+02
C09 N08 N09 1.00e-11
L09 N08 N09 5.90e-11
R09 N08 N09 1.25e+02
C10 N09 N10 4.38e-11
L10 N09 N10 1.07e-11
R10 N09 N10 2.23e+01
C11 N10 N11 2.56e-10
L11 N10 N11 1.52e-12
R11 N10 N11 3.55e+00
C12 N11 Port2 2.50e-10
L12 N11 Port2 1.32e-12
R12 N11 Port2 4.72e-01
.ENDS GQM22M5C2H910GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H910JB01
* Property : C = 9.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.91e-11
R03 N02 N03 2.62e-02
C04 N03 N04 1.23e-10
L04 N03 N04 7.29e-11
R04 N03 N04 5.58e+01
C05 N04 N05 6.01e-11
L05 N04 N05 5.20e-11
R05 N04 N05 5.71e+01
C06 N05 N06 5.99e-11
L06 N05 N06 2.49e-11
R06 N05 N06 3.80e+01
C07 N06 N07 1.58e-11
L07 N06 N07 6.04e-11
R07 N06 N07 1.03e+02
C08 N07 N08 5.12e-12
L08 N07 N08 1.36e-10
R08 N07 N08 3.02e+02
C09 N08 N09 1.00e-11
L09 N08 N09 5.90e-11
R09 N08 N09 1.25e+02
C10 N09 N10 4.38e-11
L10 N09 N10 1.07e-11
R10 N09 N10 2.23e+01
C11 N10 N11 2.56e-10
L11 N10 N11 1.52e-12
R11 N10 N11 3.55e+00
C12 N11 Port2 2.50e-10
L12 N11 Port2 1.32e-12
R12 N11 Port2 4.72e-01
.ENDS GQM22M5C2H910JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-11
R03 N02 N03 3.00e-02
L04 N03 N04 4.51e-12
R04 N03 N04 3.40e-01
C05 N04 N05 1.88e-12
L05 N04 N05 2.32e-10
R05 N04 N05 2.02e+03
C06 N05 Port2 5.83e-12
L06 N05 Port2 1.77e-10
R06 N05 Port2 4.41e+02
.ENDS GQM22M5C2H9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-11
R03 N02 N03 3.00e-02
L04 N03 N04 4.51e-12
R04 N03 N04 3.40e-01
C05 N04 N05 1.88e-12
L05 N04 N05 2.32e-10
R05 N04 N05 2.02e+03
C06 N05 Port2 5.83e-12
L06 N05 Port2 1.77e-10
R06 N05 Port2 4.41e+02
.ENDS GQM22M5C2H9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.00e-11
R03 N02 N03 3.00e-02
C04 N03 N04 1.95e-12
L04 N03 N04 2.27e-10
R04 N03 N04 2.27e+03
C05 N04 Port2 6.12e-12
L05 N04 Port2 1.67e-10
R05 N04 Port2 4.19e+02
.ENDS GQM22M5C2H9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.00e-11
R03 N02 N03 3.00e-02
C04 N03 N04 1.95e-12
L04 N03 N04 2.27e-10
R04 N03 N04 2.27e+03
C05 N04 Port2 6.12e-12
L05 N04 Port2 1.67e-10
R05 N04 Port2 4.19e+02
.ENDS GQM22M5C2H9R1DB01
