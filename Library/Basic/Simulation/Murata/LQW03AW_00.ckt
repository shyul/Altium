*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW10NJ00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW10NJ00 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 1.79e-8
R2 1 port2 3.80e-1
R3 port1 port2 9.69e+3
L4 port1 2 2.23e-8
R4 2 port2 1.48
L5 port1 3 2.44e-7
R5 3 port2 256
L6 port1 4 3.30e-7
R6 4 port2 1.78e+3
L7 port1 5 1.74e-7
C7 5 6 3.63e-16
R7 6 port2 138
.ENDS LQW03AW10NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW11NJ00
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW11NJ00 port1 port2
C1 port1 port2 2.19e-14
L2 port1 1 1.45e-8
R2 1 port2 3.90e-1
R3 port1 port2 1.22e+4
L4 port1 2 3.88e-8
R4 2 port2 3.16
L5 port1 3 2.61e-7
R5 3 port2 511
L6 port1 4 4.66e-7
R6 4 port2 4.37e+3
L7 port1 5 2.56e-7
C7 5 6 3.76e-16
R7 6 port2 6.19e+3
.ENDS LQW03AW11NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW12NJ00
* Property : L = 12.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW12NJ00 port1 port2
C1 port1 port2 2.76e-14
L2 port1 1 1.66e-8
R2 1 port2 4.50e-1
R3 port1 port2 1.54e+4
L4 port1 2 5.00e-8
R4 2 port2 3.89
L5 port1 3 2.86e-7
R5 3 port2 600
L6 port1 4 6.89e-7
R6 4 port2 8.52e+3
L7 port1 5 8.99e-8
C7 5 6 8.85e-16
R7 6 port2 501
.ENDS LQW03AW12NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW13NJ00
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW13NJ00 port1 port2
C1 port1 port2 3.04e-14
L2 port1 1 1.32e-8
R2 1 port2 4.50e-1
R3 port1 port2 1.85e+4
L4 port1 2 2.87e-7
R4 2 port2 59.5
L5 port1 3 2.89e-7
R5 3 port2 900
.ENDS LQW03AW13NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW14NJ00
* Property : L = 13.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW14NJ00 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 2.09e-8
R2 1 port2 4.40e-1
R3 port1 port2 1.54e+4
L4 port1 2 3.79e-8
R4 2 port2 2.29
L5 port1 3 2.61e-7
R5 3 port2 511
L6 port1 4 7.55e-7
R6 4 port2 7.42e+3
L7 port1 5 7.30e-8
C7 5 6 1.63e-15
R7 6 port2 2.07e+3
.ENDS LQW03AW14NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW15NJ00
* Property : L = 15.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW15NJ00 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 2.57e-8
R2 1 port2 5.00e-1
R3 port1 port2 2.68e+4
L4 port1 2 3.88e-8
R4 2 port2 2.29
L5 port1 3 3.36e-7
R5 3 port2 643
L6 port1 4 6.73e-7
R6 4 port2 8.52e+3
L7 port1 5 7.30e-8
C7 5 6 1.63e-15
R7 6 port2 2.07e+3
.ENDS LQW03AW15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW1N0C00
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW1N0C00 port1 port2
C1 port1 port2 2.05e-15
L2 port1 1 2.40e-9
R2 1 port2 2.00e-2
R3 port1 port2 1.14e+3
L4 port1 2 1.18e-9
R4 2 port2 9.63e-2
L5 port1 3 1.60e-8
R5 3 port2 34.8
L6 port1 4 2.23e-8
R6 4 port2 87.6
.ENDS LQW03AW1N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW1N1C00
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW1N1C00 port1 port2
C1 port1 port2 1.52e-15
L2 port1 1 4.17e-9
R2 1 port2 4.50e-2
R3 port1 port2 1.14e+3
L4 port1 2 1.10e-9
R4 2 port2 9.63e-2
L5 port1 3 1.27e-8
R5 3 port2 25.2
L6 port1 4 2.03e-8
R6 4 port2 66.5
.ENDS LQW03AW1N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW1N7C00
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW1N7C00 port1 port2
C1 port1 port2 1.17e-14
L2 port1 1 2.69e-9
R2 1 port2 5.50e-2
R3 port1 port2 1.60e+3
L4 port1 2 3.06e-9
R4 2 port2 2.53e-1
L5 port1 3 2.78e-8
R5 3 port2 57.5
L6 port1 4 4.70e-8
R6 4 port2 137
.ENDS LQW03AW1N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW1N8C00
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW1N8C00 port1 port2
C1 port1 port2 2.44e-14
L2 port1 1 2.82e-9
R2 1 port2 7.70e-2
R3 port1 port2 1.67e+3
L4 port1 2 2.74e-9
R4 2 port2 2.91e-1
L5 port1 3 2.37e-8
R5 3 port2 75.8
L6 port1 4 3.82e-7
R6 4 port2 1.44e+3
.ENDS LQW03AW1N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW1N9C00
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW1N9C00 port1 port2
C1 port1 port2 3.87e-14
L2 port1 1 3.09e-9
R2 1 port2 6.00e-2
R3 port1 port2 2.10e+3
L4 port1 2 3.45e-9
R4 2 port2 3.50e-1
L5 port1 3 3.20e-8
R5 3 port2 93.3
L6 port1 4 1.18e-7
R6 4 port2 657
.ENDS LQW03AW1N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N0C00
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N0C00 port1 port2
C1 port1 port2 2.44e-14
L2 port1 1 1.78e-9
R2 1 port2 8.30e-2
R3 port1 port2 2.10e+3
L4 port1 2 5.71e-8
R4 2 port2 8.61e-1
L5 port1 3 2.54e-8
R5 3 port2 30.9
L6 port1 4 5.89e-8
R6 4 port2 361
.ENDS LQW03AW2N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N1C00
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N1C00 port1 port2
C1 port1 port2 2.44e-14
L2 port1 1 1.95e-9
R2 1 port2 1.30e-1
R3 port1 port2 2.10e+3
L4 port1 2 5.71e-8
R4 2 port2 8.61e-1
L5 port1 3 2.60e-8
R5 3 port2 30.9
L6 port1 4 5.37e-8
R6 4 port2 307
.ENDS LQW03AW2N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N2C00
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N2C00 port1 port2
C1 port1 port2 2.44e-14
L2 port1 1 2.14e-9
R2 1 port2 1.30e-1
R3 port1 port2 2.20e+3
L4 port1 2 5.71e-8
R4 2 port2 8.61e-1
L5 port1 3 2.60e-8
R5 3 port2 30.9
L6 port1 4 5.49e-8
R6 4 port2 307
.ENDS LQW03AW2N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N7C00
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N7C00 port1 port2
C1 port1 port2 3.21e-14
L2 port1 1 2.70e-9
R2 1 port2 5.00e-2
R3 port1 port2 3.04e+3
L4 port1 2 5.98e-8
R4 2 port2 6.38e-1
L5 port1 3 4.62e-8
R5 3 port2 35.5
L6 port1 4 8.70e-8
R6 4 port2 387
.ENDS LQW03AW2N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N8C00
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N8C00 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 4.39e-9
R2 1 port2 6.00e-2
R3 port1 port2 2.55e+3
L4 port1 2 6.46e-9
R4 2 port2 5.33e-1
L5 port1 3 6.12e-8
R5 3 port2 54.5
L6 port1 4 6.42e-8
R6 4 port2 230
.ENDS LQW03AW2N8C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW2N9C00
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW2N9C00 port1 port2
C1 port1 port2 3.24e-14
L2 port1 1 2.97e-9
R2 1 port2 8.00e-2
R3 port1 port2 2.73e+3
L4 port1 2 2.04e-8
R4 2 port2 1.62
L5 port1 3 6.12e-8
R5 3 port2 75.2
L6 port1 4 7.04e-8
R6 4 port2 290
.ENDS LQW03AW2N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N0C00
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N0C00 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 3.41e-9
R2 1 port2 1.80e-1
R3 port1 port2 2.49e+3
L4 port1 2 1.41e-8
R4 2 port2 1.66
L5 port1 3 6.12e-8
R5 3 port2 99.1
L6 port1 4 8.27e-8
R6 4 port2 283
.ENDS LQW03AW3N0C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N1C00
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N1C00 port1 port2
C1 port1 port2 3.89e-14
L2 port1 1 3.74e-9
R2 1 port2 5.20e-2
R3 port1 port2 3.44e+3
L4 port1 2 1.41e-8
R4 2 port2 1.66
L5 port1 3 6.71e-8
R5 3 port2 99.1
L6 port1 4 1.09e-7
R6 4 port2 564
.ENDS LQW03AW3N1C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N2C00
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N2C00 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 3.65e-9
R2 1 port2 6.60e-2
R3 port1 port2 3.44e+3
L4 port1 2 1.35e-8
R4 2 port2 1.41
L5 port1 3 6.71e-8
R5 3 port2 90.4
L6 port1 4 1.22e-7
R6 4 port2 564
.ENDS LQW03AW3N2C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N3C00
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N3C00 port1 port2
C1 port1 port2 2.69e-14
L2 port1 1 3.65e-9
R2 1 port2 8.80e-2
R3 port1 port2 3.44e+3
L4 port1 2 1.48e-8
R4 2 port2 1.41
L5 port1 3 6.12e-8
R5 3 port2 90.4
L6 port1 4 1.22e-7
R6 4 port2 710
.ENDS LQW03AW3N3C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N4C00
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N4C00 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 4.10e-9
R2 1 port2 1.20e-1
R3 port1 port2 3.44e+3
L4 port1 2 1.59e-8
R4 2 port2 1.38
L5 port1 3 6.26e-8
R5 3 port2 67.0
L6 port1 4 9.46e-8
R6 4 port2 428
.ENDS LQW03AW3N4C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N5C00
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N5C00 port1 port2
C1 port1 port2 2.51e-14
L2 port1 1 3.92e-9
R2 1 port2 1.20e-1
R3 port1 port2 3.44e+3
L4 port1 2 1.70e-8
R4 2 port2 1.38
L5 port1 3 5.98e-8
R5 3 port2 73.5
L6 port1 4 9.03e-8
R6 4 port2 459
.ENDS LQW03AW3N5C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N6C00
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N6C00 port1 port2
C1 port1 port2 2.69e-14
L2 port1 1 4.20e-9
R2 1 port2 1.90e-1
R3 port1 port2 3.21e+3
L4 port1 2 1.32e-8
R4 2 port2 1.29
L5 port1 3 6.56e-8
R5 3 port2 75.2
L6 port1 4 9.03e-8
R6 4 port2 492
.ENDS LQW03AW3N6C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N7C00
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N7C00 port1 port2
C1 port1 port2 2.69e-14
L2 port1 1 4.30e-9
R2 1 port2 1.90e-1
R3 port1 port2 3.21e+3
L4 port1 2 1.32e-8
R4 2 port2 1.29
L5 port1 3 6.56e-8
R5 3 port2 75.2
L6 port1 4 9.90e-8
R6 4 port2 492
.ENDS LQW03AW3N7C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW3N9C00
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW3N9C00 port1 port2
C1 port1 port2 2.82e-14
L2 port1 1 4.82e-9
R2 1 port2 5.80e-2
R3 port1 port2 4.23e+3
L4 port1 2 1.74e-8
R4 2 port2 1.29
L5 port1 3 6.12e-8
R5 3 port2 75.2
L6 port1 4 1.72e-7
R6 4 port2 982
.ENDS LQW03AW3N9C00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW4N3J00
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW4N3J00 port1 port2
C1 port1 port2 2.14e-14
L2 port1 1 5.41e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.04e+3
L4 port1 2 1.74e-8
R4 2 port2 1.29
L5 port1 3 7.88e-8
R5 3 port2 75.2
L6 port1 4 1.37e-7
R6 4 port2 620
.ENDS LQW03AW4N3J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW4N7J00
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW4N7J00 port1 port2
C1 port1 port2 3.02e-14
L2 port1 1 5.66e-9
R2 1 port2 6.70e-2
R3 port1 port2 4.23e+3
L4 port1 2 2.29e-8
R4 2 port2 1.29
L5 port1 3 8.64e-8
R5 3 port2 75.2
L6 port1 4 1.50e-7
R6 4 port2 565
.ENDS LQW03AW4N7J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW5N1J00
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW5N1J00 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 6.50e-9
R2 1 port2 1.10e-1
R3 port1 port2 4.53e+3
L4 port1 2 2.29e-8
R4 2 port2 1.29
L5 port1 3 9.47e-8
R5 3 port2 75.2
L6 port1 4 1.61e-7
R6 4 port2 605
.ENDS LQW03AW5N1J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW5N4J00
* Property : L = 5.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW5N4J00 port1 port2
C1 port1 port2 2.47e-14
L2 port1 1 5.25e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.85e+4
L4 port1 2 7.67e-8
R4 2 port2 56.2
L5 port1 3 1.70e-7
R5 3 port2 749
.ENDS LQW03AW5N4J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW5N6J00
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW5N6J00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 5.37e-9
R2 1 port2 2.70e-1
R3 port1 port2 1.85e+4
L4 port1 2 9.66e-8
R4 2 port2 56.2
L5 port1 3 1.55e-7
R5 3 port2 715
.ENDS LQW03AW5N6J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW5N8J00
* Property : L = 5.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW5N8J00 port1 port2
C1 port1 port2 2.53e-14
L2 port1 1 5.37e-9
R2 1 port2 1.30e-1
R3 port1 port2 1.85e+4
L4 port1 2 8.41e-8
R4 2 port2 56.2
L5 port1 3 1.74e-7
R5 3 port2 715
.ENDS LQW03AW5N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW6N2J00
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW6N2J00 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 8.37e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.84e+3
L4 port1 2 2.29e-8
R4 2 port2 1.29
L5 port1 3 1.09e-7
R5 3 port2 75.2
L6 port1 4 1.65e-7
R6 4 port2 727
.ENDS LQW03AW6N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW6N8J00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW6N8J00 port1 port2
C1 port1 port2 2.65e-14
L2 port1 1 6.76e-9
R2 1 port2 1.50e-1
R3 port1 port2 1.85e+4
L4 port1 2 1.13e-7
R4 2 port2 56.2
L5 port1 3 1.95e-7
R5 3 port2 715
.ENDS LQW03AW6N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW7N5J00
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW7N5J00 port1 port2
C1 port1 port2 3.11e-14
L2 port1 1 7.41e-9
R2 1 port2 2.00e-1
R3 port1 port2 1.85e+4
L4 port1 2 1.13e-7
R4 2 port2 56.2
L5 port1 3 2.00e-7
R5 3 port2 715
.ENDS LQW03AW7N5J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW8N2J00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW8N2J00 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 1.13e-8
R2 1 port2 2.10e-1
R3 port1 port2 7.70e+3
L4 port1 2 2.45e-8
R4 2 port2 1.29
L5 port1 3 1.37e-7
R5 3 port2 104
L6 port1 4 2.18e-7
R6 4 port2 1.00e+3
L7 port1 5 3.01e-7
C7 5 6 2.42e-16
R7 6 port2 3.98e+3
.ENDS LQW03AW8N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW8N7J00
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW8N7J00 port1 port2
C1 port1 port2 2.71e-14
L2 port1 1 8.31e-9
R2 1 port2 3.50e-1
R3 port1 port2 1.85e+4
L4 port1 2 2.31e-7
R4 2 port2 120
L5 port1 3 2.00e-7
R5 3 port2 749
.ENDS LQW03AW8N7J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW03AW9N1J00
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW03AW9N1J00 port1 port2
C1 port1 port2 2.84e-14
L2 port1 1 9.11e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.85e+4
L4 port1 2 1.09e-7
R4 2 port2 39.3
L5 port1 3 2.19e-7
R5 3 port2 766
.ENDS LQW03AW9N1J00
*----------------------------------------------------------------------
