*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRJ155R60J106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ155R60J106ME11 Port1 Port2
C01 Port1 N01 8.77e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.61e-10
R03 N02 N03 1.82e-02
C04 N03 N04 2.96e-04
R04 N03 N04 2.30e+01
C05 N04 N05 6.91e-04
R05 N04 N05 1.27e+00
C06 N05 N06 6.25e-04
R06 N05 N06 1.91e-01
C07 N06 N07 4.37e-04
R07 N06 N07 1.79e-02
L08 N07 N08 4.83e-11
R08 N07 N08 8.67e-02
L09 N08 N09 1.77e-10
R09 N08 N09 2.35e-02
C10 N09 N10 5.60e-06
L10 N09 N10 1.34e-10
R10 N09 N10 3.87e-03
C11 N10 Port2 7.93e-11
L11 N10 Port2 1.04e-11
R11 N10 Port2 1.70e-01
.ENDS GRJ155R60J106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188C70J475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188C70J475KE11 Port1 Port2
C01 Port1 N01 3.26e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.40e-10
R03 N02 N03 1.32e-02
C04 N03 N04 2.01e-04
R04 N03 N04 3.90e+01
C05 N04 N05 2.03e-04
R05 N04 N05 5.64e+00
C06 N05 N06 1.67e-04
R06 N05 N06 9.05e-01
C07 N06 N07 1.64e-04
R07 N06 N07 1.05e-01
C08 N07 N08 1.02e-04
R08 N07 N08 1.95e-02
L09 N08 N09 1.46e-11
R09 N08 N09 1.14e-01
L10 N09 N10 4.70e-11
R10 N09 N10 5.57e-02
L11 N10 N11 3.24e-10
R11 N10 N11 2.66e-02
C12 N11 N12 2.00e-05
L12 N11 N12 3.44e-11
R12 N11 N12 3.89e-03
C13 N12 N13 5.07e-06
L13 N12 N13 6.48e-11
R13 N12 N13 6.28e-03
C14 N13 Port2 5.95e-12
L14 N13 Port2 4.85e-11
R14 N13 Port2 1.14e+01
.ENDS GRJ188C70J475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188C70J475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188C70J475ME11 Port1 Port2
C01 Port1 N01 3.26e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.40e-10
R03 N02 N03 1.32e-02
C04 N03 N04 2.01e-04
R04 N03 N04 3.90e+01
C05 N04 N05 2.03e-04
R05 N04 N05 5.64e+00
C06 N05 N06 1.67e-04
R06 N05 N06 9.05e-01
C07 N06 N07 1.64e-04
R07 N06 N07 1.05e-01
C08 N07 N08 1.02e-04
R08 N07 N08 1.95e-02
L09 N08 N09 1.46e-11
R09 N08 N09 1.14e-01
L10 N09 N10 4.70e-11
R10 N09 N10 5.57e-02
L11 N10 N11 3.24e-10
R11 N10 N11 2.66e-02
C12 N11 N12 2.00e-05
L12 N11 N12 3.44e-11
R12 N11 N12 3.89e-03
C13 N12 N13 5.07e-06
L13 N12 N13 6.48e-11
R13 N12 N13 6.28e-03
C14 N13 Port2 5.95e-12
L14 N13 Port2 4.85e-11
R14 N13 Port2 1.14e+01
.ENDS GRJ188C70J475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRJ188R60J106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R60J106ME11 Port1 Port2
C01 Port1 N01 7.30e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 8.93e-12
R03 N02 N03 7.43e-03
C04 N03 N04 3.22e-04
R04 N03 N04 1.61e+01
C05 N04 N05 4.10e-04
R05 N04 N05 1.22e+00
C06 N05 N06 5.95e-04
R06 N05 N06 1.01e-01
C07 N06 N07 6.64e-04
R07 N06 N07 1.65e-02
C08 N07 N08 2.91e-04
R08 N07 N08 4.03e-03
L09 N08 N09 2.04e-11
R09 N08 N09 9.19e-02
L10 N09 N10 5.81e-11
R10 N09 N10 2.83e-02
L11 N10 N11 2.90e-10
R11 N10 N11 1.54e-02
C12 N11 N12 1.90e-05
L12 N11 N12 6.40e-11
R12 N11 N12 2.53e-03
C13 N12 N13 3.71e-05
L13 N12 N13 1.91e-11
R13 N12 N13 1.62e-03
C14 N13 Port2 7.07e-13
L14 N13 Port2 2.29e-10
R14 N13 Port2 1.03e+02
.ENDS GRJ188R60J106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188R60J475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R60J475KE11 Port1 Port2
C01 Port1 N01 3.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.48e-10
R03 N02 N03 1.02e-02
C04 N03 N04 2.98e-04
R04 N03 N04 1.78e+01
C05 N04 N05 2.38e-04
R05 N04 N05 3.10e+00
C06 N05 N06 2.69e-04
R06 N05 N06 3.18e-01
C07 N06 N07 2.31e-04
R07 N06 N07 3.47e-02
C08 N07 N08 1.54e-04
R08 N07 N08 5.37e-03
L09 N08 N09 2.43e-11
R09 N08 N09 1.14e-01
L10 N09 N10 2.55e-10
R10 N09 N10 2.25e-02
L11 N10 N11 3.81e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.22e-05
L12 N11 N12 5.18e-11
R12 N11 N12 3.31e-03
C13 N12 N13 5.47e-06
L13 N12 N13 5.02e-11
R13 N12 N13 4.25e-03
C14 N13 Port2 4.22e-12
L14 N13 Port2 8.11e-11
R14 N13 Port2 3.37e+01
.ENDS GRJ188R60J475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188R60J475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R60J475ME11 Port1 Port2
C01 Port1 N01 3.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.48e-10
R03 N02 N03 1.02e-02
C04 N03 N04 2.98e-04
R04 N03 N04 1.78e+01
C05 N04 N05 2.38e-04
R05 N04 N05 3.10e+00
C06 N05 N06 2.69e-04
R06 N05 N06 3.18e-01
C07 N06 N07 2.31e-04
R07 N06 N07 3.47e-02
C08 N07 N08 1.54e-04
R08 N07 N08 5.37e-03
L09 N08 N09 2.43e-11
R09 N08 N09 1.14e-01
L10 N09 N10 2.55e-10
R10 N09 N10 2.25e-02
L11 N10 N11 3.81e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.22e-05
L12 N11 N12 5.18e-11
R12 N11 N12 3.31e-03
C13 N12 N13 5.47e-06
L13 N12 N13 5.02e-11
R13 N12 N13 4.25e-03
C14 N13 Port2 4.22e-12
L14 N13 Port2 8.11e-11
R14 N13 Port2 3.37e+01
.ENDS GRJ188R60J475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ188R61A106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61A106ME11 Port1 Port2
C01 Port1 N01 7.30e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 8.93e-12
R03 N02 N03 7.43e-03
C04 N03 N04 3.22e-04
R04 N03 N04 1.61e+01
C05 N04 N05 4.10e-04
R05 N04 N05 1.22e+00
C06 N05 N06 5.95e-04
R06 N05 N06 1.01e-01
C07 N06 N07 6.64e-04
R07 N06 N07 1.65e-02
C08 N07 N08 2.91e-04
R08 N07 N08 4.03e-03
L09 N08 N09 2.04e-11
R09 N08 N09 9.19e-02
L10 N09 N10 5.81e-11
R10 N09 N10 2.83e-02
L11 N10 N11 2.90e-10
R11 N10 N11 1.54e-02
C12 N11 N12 1.90e-05
L12 N11 N12 6.40e-11
R12 N11 N12 2.53e-03
C13 N12 N13 3.71e-05
L13 N12 N13 1.91e-11
R13 N12 N13 1.62e-03
C14 N13 Port2 7.07e-13
L14 N13 Port2 2.29e-10
R14 N13 Port2 1.03e+02
.ENDS GRJ188R61A106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRJ188R61A475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61A475KE11 Port1 Port2
C01 Port1 N01 3.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.48e-10
R03 N02 N03 1.02e-02
C04 N03 N04 2.98e-04
R04 N03 N04 1.78e+01
C05 N04 N05 2.38e-04
R05 N04 N05 3.10e+00
C06 N05 N06 2.69e-04
R06 N05 N06 3.18e-01
C07 N06 N07 2.31e-04
R07 N06 N07 3.47e-02
C08 N07 N08 1.54e-04
R08 N07 N08 5.37e-03
L09 N08 N09 2.43e-11
R09 N08 N09 1.14e-01
L10 N09 N10 2.55e-10
R10 N09 N10 2.25e-02
L11 N10 N11 3.81e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.22e-05
L12 N11 N12 5.18e-11
R12 N11 N12 3.31e-03
C13 N12 N13 5.47e-06
L13 N12 N13 5.02e-11
R13 N12 N13 4.25e-03
C14 N13 Port2 4.22e-12
L14 N13 Port2 8.11e-11
R14 N13 Port2 3.37e+01
.ENDS GRJ188R61A475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRJ188R61A475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61A475ME11 Port1 Port2
C01 Port1 N01 3.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.48e-10
R03 N02 N03 1.02e-02
C04 N03 N04 2.98e-04
R04 N03 N04 1.78e+01
C05 N04 N05 2.38e-04
R05 N04 N05 3.10e+00
C06 N05 N06 2.69e-04
R06 N05 N06 3.18e-01
C07 N06 N07 2.31e-04
R07 N06 N07 3.47e-02
C08 N07 N08 1.54e-04
R08 N07 N08 5.37e-03
L09 N08 N09 2.43e-11
R09 N08 N09 1.14e-01
L10 N09 N10 2.55e-10
R10 N09 N10 2.25e-02
L11 N10 N11 3.81e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.22e-05
L12 N11 N12 5.18e-11
R12 N11 N12 3.31e-03
C13 N12 N13 5.47e-06
L13 N12 N13 5.02e-11
R13 N12 N13 4.25e-03
C14 N13 Port2 4.22e-12
L14 N13 Port2 8.11e-11
R14 N13 Port2 3.37e+01
.ENDS GRJ188R61A475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRJ188R61C105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61C105KE11 Port1 Port2
C01 Port1 N01 7.52e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.12e-10
R03 N02 N03 1.54e-02
C04 N03 N04 8.11e-06
R04 N03 N04 7.17e+02
C05 N04 N05 4.11e-05
R05 N04 N05 1.75e+01
C06 N05 N06 2.33e-05
R06 N05 N06 5.06e+00
C07 N06 N07 2.04e-05
R07 N06 N07 5.64e-01
C08 N07 N08 1.42e-05
R08 N07 N08 9.33e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.11e-02
L10 N09 N10 3.50e-11
R10 N09 N10 1.17e-01
L11 N10 N11 2.16e-10
R11 N10 N11 4.56e-02
C12 N11 N12 4.45e-06
L12 N11 N12 2.30e-11
R12 N11 N12 7.82e-03
C13 N12 N13 1.53e-06
L13 N12 N13 3.38e-11
R13 N12 N13 1.36e-02
C14 N13 Port2 6.50e-12
L14 N13 Port2 7.56e-11
R14 N13 Port2 1.11e+01
.ENDS GRJ188R61C105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRJ188R61C105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61C105ME11 Port1 Port2
C01 Port1 N01 7.52e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.12e-10
R03 N02 N03 1.54e-02
C04 N03 N04 8.11e-06
R04 N03 N04 7.17e+02
C05 N04 N05 4.11e-05
R05 N04 N05 1.75e+01
C06 N05 N06 2.33e-05
R06 N05 N06 5.06e+00
C07 N06 N07 2.04e-05
R07 N06 N07 5.64e-01
C08 N07 N08 1.42e-05
R08 N07 N08 9.33e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.11e-02
L10 N09 N10 3.50e-11
R10 N09 N10 1.17e-01
L11 N10 N11 2.16e-10
R11 N10 N11 4.56e-02
C12 N11 N12 4.45e-06
L12 N11 N12 2.30e-11
R12 N11 N12 7.82e-03
C13 N12 N13 1.53e-06
L13 N12 N13 3.38e-11
R13 N12 N13 1.36e-02
C14 N13 Port2 6.50e-12
L14 N13 Port2 7.56e-11
R14 N13 Port2 1.11e+01
.ENDS GRJ188R61C105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRJ188R6YA105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R6YA105KE11 Port1 Port2
C01 Port1 N01 8.98e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.97e-10
R03 N02 N03 1.07e-02
C04 N03 N04 2.22e-06
R04 N03 N04 4.99e+03
C05 N04 N05 2.74e-05
R05 N04 N05 1.61e+01
C06 N05 N06 2.56e-05
R06 N05 N06 3.00e+00
C07 N06 N07 1.94e-05
R07 N06 N07 4.60e-01
C08 N07 N08 1.51e-05
R08 N07 N08 7.42e-02
C09 N08 N09 1.20e-05
R09 N08 N09 1.58e-02
L10 N09 N10 3.19e-11
R10 N09 N10 7.88e-02
L11 N10 N11 2.14e-10
R11 N10 N11 3.98e-02
C12 N11 N12 5.54e-06
L12 N11 N12 1.69e-11
R12 N11 N12 6.12e-03
C13 N12 N13 1.50e-06
L13 N12 N13 3.13e-11
R13 N12 N13 1.13e-02
C14 N13 N14 1.88e-11
L14 N13 N14 2.97e-11
R14 N13 N14 5.71e+00
C15 N14 Port2 3.99e-12
L15 N14 Port2 6.78e-11
R15 N14 Port2 6.86e+00
.ENDS GRJ188R6YA105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRJ188R70J225KE11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R70J225KE11 Port1 Port2
C01 Port1 N01 1.60e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.00e-10
R03 N02 N03 1.41e-02
C04 N03 N04 3.17e-05
R04 N03 N04 1.68e+02
C05 N04 N05 5.65e-05
R05 N04 N05 9.52e+00
C06 N05 N06 5.33e-05
R06 N05 N06 1.43e+00
C07 N06 N07 4.56e-05
R07 N06 N07 2.22e-01
C08 N07 N08 4.05e-05
R08 N07 N08 3.50e-02
C09 N08 N09 3.62e-05
R09 N08 N09 1.02e-02
L10 N09 N10 4.14e-11
R10 N09 N10 1.13e-01
L11 N10 N11 2.49e-10
R11 N10 N11 3.62e-02
C12 N11 N12 1.90e-05
L12 N11 N12 1.26e-11
R12 N11 N12 3.92e-03
C13 N12 N13 2.79e-06
L13 N12 N13 4.95e-11
R13 N12 N13 9.65e-03
C14 N13 Port2 6.35e-12
L14 N13 Port2 7.06e-11
R14 N13 Port2 1.08e+01
.ENDS GRJ188R70J225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRJ188R70J225ME11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R70J225ME11 Port1 Port2
C01 Port1 N01 1.60e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.00e-10
R03 N02 N03 1.41e-02
C04 N03 N04 3.17e-05
R04 N03 N04 1.68e+02
C05 N04 N05 5.65e-05
R05 N04 N05 9.52e+00
C06 N05 N06 5.33e-05
R06 N05 N06 1.43e+00
C07 N06 N07 4.56e-05
R07 N06 N07 2.22e-01
C08 N07 N08 4.05e-05
R08 N07 N08 3.50e-02
C09 N08 N09 3.62e-05
R09 N08 N09 1.02e-02
L10 N09 N10 4.14e-11
R10 N09 N10 1.13e-01
L11 N10 N11 2.49e-10
R11 N10 N11 3.62e-02
C12 N11 N12 1.90e-05
L12 N11 N12 1.26e-11
R12 N11 N12 3.92e-03
C13 N12 N13 2.79e-06
L13 N12 N13 4.95e-11
R13 N12 N13 9.65e-03
C14 N13 Port2 6.35e-12
L14 N13 Port2 7.06e-11
R14 N13 Port2 1.08e+01
.ENDS GRJ188R70J225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRJ188R71C474KE11
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71C474KE11 Port1 Port2
C01 Port1 N01 4.13e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.45e-10
R03 N02 N03 3.44e-02
C04 N03 N04 2.24e-05
R04 N03 N04 8.93e-02
C05 N04 N05 3.47e-05
R05 N04 N05 4.30e-03
L06 N05 N06 2.76e-11
R06 N05 N06 1.41e-01
L07 N06 N07 1.40e-10
R07 N06 N07 5.69e-02
C08 N07 N08 8.54e-07
L08 N07 N08 6.63e-11
R08 N07 N08 1.00e-02
C09 N08 N09 5.64e-07
L09 N08 N09 4.03e-11
R09 N08 N09 1.31e-02
C10 N09 N10 6.46e-12
L10 N09 N10 8.40e-11
R10 N09 N10 1.36e+01
C11 N10 Port2 2.15e-12
L11 N10 Port2 1.25e-10
R11 N10 Port2 6.35e+01
.ENDS GRJ188R71C474KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRJ188R71C474ME11
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71C474ME11 Port1 Port2
C01 Port1 N01 4.13e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.45e-10
R03 N02 N03 3.44e-02
C04 N03 N04 2.24e-05
R04 N03 N04 8.93e-02
C05 N04 N05 3.47e-05
R05 N04 N05 4.30e-03
L06 N05 N06 2.76e-11
R06 N05 N06 1.41e-01
L07 N06 N07 1.40e-10
R07 N06 N07 5.69e-02
C08 N07 N08 8.54e-07
L08 N07 N08 6.63e-11
R08 N07 N08 1.00e-02
C09 N08 N09 5.64e-07
L09 N08 N09 4.03e-11
R09 N08 N09 1.31e-02
C10 N09 N10 6.46e-12
L10 N09 N10 8.40e-11
R10 N09 N10 1.36e+01
C11 N10 Port2 2.15e-12
L11 N10 Port2 1.25e-10
R11 N10 Port2 6.35e+01
.ENDS GRJ188R71C474ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ188R71E105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E105KE11 Port1 Port2
C01 Port1 N01 7.52e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.12e-10
R03 N02 N03 1.54e-02
C04 N03 N04 8.11e-06
R04 N03 N04 7.17e+02
C05 N04 N05 4.11e-05
R05 N04 N05 1.75e+01
C06 N05 N06 2.33e-05
R06 N05 N06 5.06e+00
C07 N06 N07 2.04e-05
R07 N06 N07 5.64e-01
C08 N07 N08 1.42e-05
R08 N07 N08 9.33e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.11e-02
L10 N09 N10 3.50e-11
R10 N09 N10 1.17e-01
L11 N10 N11 2.16e-10
R11 N10 N11 4.56e-02
C12 N11 N12 4.45e-06
L12 N11 N12 2.30e-11
R12 N11 N12 7.82e-03
C13 N12 N13 1.53e-06
L13 N12 N13 3.38e-11
R13 N12 N13 1.36e-02
C14 N13 Port2 6.50e-12
L14 N13 Port2 7.56e-11
R14 N13 Port2 1.11e+01
.ENDS GRJ188R71E105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ188R71E105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E105ME11 Port1 Port2
C01 Port1 N01 7.52e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.12e-10
R03 N02 N03 1.54e-02
C04 N03 N04 8.11e-06
R04 N03 N04 7.17e+02
C05 N04 N05 4.11e-05
R05 N04 N05 1.75e+01
C06 N05 N06 2.33e-05
R06 N05 N06 5.06e+00
C07 N06 N07 2.04e-05
R07 N06 N07 5.64e-01
C08 N07 N08 1.42e-05
R08 N07 N08 9.33e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.11e-02
L10 N09 N10 3.50e-11
R10 N09 N10 1.17e-01
L11 N10 N11 2.16e-10
R11 N10 N11 4.56e-02
C12 N11 N12 4.45e-06
L12 N11 N12 2.30e-11
R12 N11 N12 7.82e-03
C13 N12 N13 1.53e-06
L13 N12 N13 3.38e-11
R13 N12 N13 1.36e-02
C14 N13 Port2 6.50e-12
L14 N13 Port2 7.56e-11
R14 N13 Port2 1.11e+01
.ENDS GRJ188R71E105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRJ188R71E224KE11
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E224KE11 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.14e-10
R03 N02 N03 2.07e-02
C04 N03 N04 1.14e-05
R04 N03 N04 2.32e-01
C05 N04 N05 1.62e-05
R05 N04 N05 1.61e-02
L06 N05 N06 1.99e-11
R06 N05 N06 9.36e-02
L07 N06 N07 1.43e-10
R07 N06 N07 6.18e-02
C08 N07 N08 9.45e-07
L08 N07 N08 2.66e-11
R08 N07 N08 1.36e-02
C09 N08 N09 3.50e-07
L09 N08 N09 3.55e-11
R09 N08 N09 2.05e-02
C10 N09 Port2 3.20e-12
L10 N09 Port2 1.19e-10
R10 N09 Port2 1.58e+01
.ENDS GRJ188R71E224KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRJ188R71E224ME11
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E224ME11 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.14e-10
R03 N02 N03 2.07e-02
C04 N03 N04 1.14e-05
R04 N03 N04 2.32e-01
C05 N04 N05 1.62e-05
R05 N04 N05 1.61e-02
L06 N05 N06 1.99e-11
R06 N05 N06 9.36e-02
L07 N06 N07 1.43e-10
R07 N06 N07 6.18e-02
C08 N07 N08 9.45e-07
L08 N07 N08 2.66e-11
R08 N07 N08 1.36e-02
C09 N08 N09 3.50e-07
L09 N08 N09 3.55e-11
R09 N08 N09 2.05e-02
C10 N09 Port2 3.20e-12
L10 N09 Port2 1.19e-10
R10 N09 Port2 1.58e+01
.ENDS GRJ188R71E224ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GRJ188R71E473KE11
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E473KE11 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GRJ188R71E473KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GRJ188R71E473ME11
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E473ME11 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GRJ188R71E473ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRJ188R71H102KE11
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H102KE11 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GRJ188R71H102KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRJ188R71H102ME11
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H102ME11 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GRJ188R71H102ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRJ188R71H103KE11
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H103KE11 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GRJ188R71H103KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRJ188R71H103ME11
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H103ME11 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GRJ188R71H103ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ188R71H104KE11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H104KE11 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GRJ188R71H104KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ188R71H104ME11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H104ME11 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GRJ188R71H104ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRJ188R71H222KE11
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H222KE11 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GRJ188R71H222KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRJ188R71H222ME11
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H222ME11 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GRJ188R71H222ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRJ188R71H223KE11
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H223KE11 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GRJ188R71H223KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRJ188R71H223ME11
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H223ME11 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GRJ188R71H223ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ188R71H224KE11
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H224KE11 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.13e-10
R03 N02 N03 2.24e-02
C04 N03 N04 1.93e-05
R04 N03 N04 1.65e-01
C05 N04 N05 2.93e-05
R05 N04 N05 8.09e-03
L06 N05 N06 1.84e-11
R06 N05 N06 7.72e-02
L07 N06 N07 1.64e-10
R07 N06 N07 5.98e-02
C08 N07 N08 1.11e-06
L08 N07 N08 2.52e-11
R08 N07 N08 1.07e-02
C09 N08 N09 5.44e-07
L09 N08 N09 2.77e-11
R09 N08 N09 2.14e-02
C10 N09 N10 5.72e-12
L10 N09 N10 9.27e-11
R10 N09 N10 1.17e+01
C11 N10 Port2 1.48e-11
L11 N10 Port2 2.28e-11
R11 N10 Port2 1.55e+01
.ENDS GRJ188R71H224KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ188R71H224ME11
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H224ME11 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.13e-10
R03 N02 N03 2.24e-02
C04 N03 N04 1.93e-05
R04 N03 N04 1.65e-01
C05 N04 N05 2.93e-05
R05 N04 N05 8.09e-03
L06 N05 N06 1.84e-11
R06 N05 N06 7.72e-02
L07 N06 N07 1.64e-10
R07 N06 N07 5.98e-02
C08 N07 N08 1.11e-06
L08 N07 N08 2.52e-11
R08 N07 N08 1.07e-02
C09 N08 N09 5.44e-07
L09 N08 N09 2.77e-11
R09 N08 N09 2.14e-02
C10 N09 N10 5.72e-12
L10 N09 N10 9.27e-11
R10 N09 N10 1.17e+01
C11 N10 Port2 1.48e-11
L11 N10 Port2 2.28e-11
R11 N10 Port2 1.55e+01
.ENDS GRJ188R71H224ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRJ188R71H472KE11
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H472KE11 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GRJ188R71H472KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRJ188R71H472ME11
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H472ME11 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GRJ188R71H472ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRJ188R71H473KE11
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H473KE11 Port1 Port2
C01 Port1 N01 4.71e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.89e-10
R03 N02 N03 2.83e-02
C04 N03 N04 2.79e-06
R04 N03 N04 9.48e-01
C05 N04 N05 4.59e-06
R05 N04 N05 5.50e-02
C06 N05 N06 6.17e-06
R06 N05 N06 1.52e-02
L07 N06 N07 1.71e-11
R07 N06 N07 1.50e-01
L08 N07 N08 1.34e-10
R08 N07 N08 1.16e-01
C09 N08 N09 1.95e-07
L09 N08 N09 2.92e-11
R09 N08 N09 3.78e-02
C10 N09 N10 9.35e-08
L10 N09 N10 2.90e-11
R10 N09 N10 4.94e-02
C11 N10 Port2 3.95e-12
L11 N10 Port2 9.63e-11
R11 N10 Port2 1.36e+01
.ENDS GRJ188R71H473KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRJ188R71H473ME11
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H473ME11 Port1 Port2
C01 Port1 N01 4.71e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.89e-10
R03 N02 N03 2.83e-02
C04 N03 N04 2.79e-06
R04 N03 N04 9.48e-01
C05 N04 N05 4.59e-06
R05 N04 N05 5.50e-02
C06 N05 N06 6.17e-06
R06 N05 N06 1.52e-02
L07 N06 N07 1.71e-11
R07 N06 N07 1.50e-01
L08 N07 N08 1.34e-10
R08 N07 N08 1.16e-01
C09 N08 N09 1.95e-07
L09 N08 N09 2.92e-11
R09 N08 N09 3.78e-02
C10 N09 N10 9.35e-08
L10 N09 N10 2.90e-11
R10 N09 N10 4.94e-02
C11 N10 Port2 3.95e-12
L11 N10 Port2 9.63e-11
R11 N10 Port2 1.36e+01
.ENDS GRJ188R71H473ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRJ188R72A102KE11
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A102KE11 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GRJ188R72A102KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRJ188R72A102ME11
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A102ME11 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GRJ188R72A102ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRJ188R72A103KE11
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A103KE11 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GRJ188R72A103KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRJ188R72A103ME11
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A103ME11 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GRJ188R72A103ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ188R72A104KE11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A104KE11 Port1 Port2
C01 Port1 N01 9.71e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.03e-10
R03 N02 N03 2.56e-02
C04 N03 N04 6.56e-06
R04 N03 N04 3.20e-01
C05 N04 N05 9.31e-06
R05 N04 N05 2.22e-02
C06 N05 N06 8.31e-06
R06 N05 N06 1.75e-03
L07 N06 N07 1.39e-11
R07 N06 N07 8.95e-02
L08 N07 N08 1.18e-10
R08 N07 N08 8.03e-02
C09 N08 N09 5.96e-07
L09 N08 N09 2.15e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.35e-07
L10 N09 N10 2.86e-11
R10 N09 N10 2.10e-02
C11 N10 Port2 4.42e-12
L11 N10 Port2 9.41e-11
R11 N10 Port2 1.34e+01
.ENDS GRJ188R72A104KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ188R72A104ME11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A104ME11 Port1 Port2
C01 Port1 N01 9.71e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.03e-10
R03 N02 N03 2.56e-02
C04 N03 N04 6.56e-06
R04 N03 N04 3.20e-01
C05 N04 N05 9.31e-06
R05 N04 N05 2.22e-02
C06 N05 N06 8.31e-06
R06 N05 N06 1.75e-03
L07 N06 N07 1.39e-11
R07 N06 N07 8.95e-02
L08 N07 N08 1.18e-10
R08 N07 N08 8.03e-02
C09 N08 N09 5.96e-07
L09 N08 N09 2.15e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.35e-07
L10 N09 N10 2.86e-11
R10 N09 N10 2.10e-02
C11 N10 Port2 4.42e-12
L11 N10 Port2 9.41e-11
R11 N10 Port2 1.34e+01
.ENDS GRJ188R72A104ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRJ188R72A222KE11
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A222KE11 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GRJ188R72A222KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRJ188R72A222ME11
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A222ME11 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GRJ188R72A222ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRJ188R72A223KE11
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A223KE11 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GRJ188R72A223KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRJ188R72A223ME11
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A223ME11 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GRJ188R72A223ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRJ188R72A472KE11
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A472KE11 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GRJ188R72A472KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRJ188R72A472ME11
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A472ME11 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GRJ188R72A472ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRJ216R71H102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H102KE01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GRJ216R71H102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRJ216R71H102ME01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H102ME01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GRJ216R71H102ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRJ216R71H103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H103KE01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GRJ216R71H103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRJ216R71H103ME01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H103ME01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GRJ216R71H103ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRJ216R71H222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H222KE01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GRJ216R71H222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRJ216R71H222ME01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H222ME01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GRJ216R71H222ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRJ216R71H223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H223KE01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GRJ216R71H223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRJ216R71H223ME01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H223ME01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GRJ216R71H223ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRJ216R71H471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H471KE01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GRJ216R71H471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRJ216R71H471ME01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H471ME01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GRJ216R71H471ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRJ216R71H472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H472KE01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GRJ216R71H472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRJ216R71H472ME01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H472ME01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GRJ216R71H472ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRJ216R72A102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A102KE01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GRJ216R72A102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRJ216R72A102ME01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A102ME01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GRJ216R72A102ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRJ216R72A103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A103KE01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GRJ216R72A103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRJ216R72A103ME01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A103ME01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GRJ216R72A103ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRJ216R72A222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A222KE01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GRJ216R72A222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRJ216R72A222ME01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A222ME01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GRJ216R72A222ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRJ216R72A223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A223KE01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GRJ216R72A223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRJ216R72A223ME01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A223ME01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GRJ216R72A223ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRJ216R72A472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A472KE01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GRJ216R72A472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRJ216R72A472ME01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A472ME01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GRJ216R72A472ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRJ219R72A221KE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ219R72A221KE01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GRJ219R72A221KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRJ219R72A221ME01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ219R72A221ME01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GRJ219R72A221ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GRJ219R72A471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ219R72A471KE01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GRJ219R72A471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GRJ219R72A471ME01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ219R72A471ME01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GRJ219R72A471ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E102KWJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E102KWJ1 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 3.31e-01
C04 N03 N04 1.21e-08
R04 N03 N04 2.09e+02
C05 N04 N05 4.59e-08
R05 N04 N05 1.38e+00
C06 N05 N06 1.59e-08
R06 N05 N06 2.88e-01
C07 N06 N07 3.95e-11
L07 N06 N07 1.89e-10
R07 N06 N07 3.31e+00
C08 N07 Port2 2.93e-12
L08 N07 Port2 2.33e-10
R08 N07 Port2 2.24e+01
.ENDS GRJ21AR72E102KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E152KWJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E152KWJ1 Port1 Port2
C01 Port1 N01 1.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 2.72e-01
C04 N03 N04 2.76e-08
R04 N03 N04 7.78e+01
C05 N04 N05 7.26e-08
R05 N04 N05 1.38e+00
C06 N05 N06 2.70e-08
R06 N05 N06 2.30e-01
C07 N06 N07 4.12e-11
L07 N06 N07 1.58e-10
R07 N06 N07 2.58e+00
C08 N07 Port2 2.42e-12
L08 N07 Port2 2.95e-10
R08 N07 Port2 2.77e+01
.ENDS GRJ21AR72E152KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E222KWJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E222KWJ1 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.05e-01
C04 N03 N04 4.91e-08
R04 N03 N04 4.27e+01
C05 N04 N05 1.07e-07
R05 N04 N05 9.34e-01
C06 N05 N06 4.48e-08
R06 N05 N06 1.78e-01
C07 N06 N07 1.17e-09
L07 N06 N07 5.34e-11
R07 N06 N07 2.82e-01
C08 N07 N08 5.71e-11
L08 N07 N08 1.04e-10
R08 N07 N08 2.09e+00
C09 N08 Port2 2.33e-12
L09 N08 Port2 2.44e-10
R09 N08 Port2 2.57e+01
.ENDS GRJ21AR72E222KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E332KWJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E332KWJ1 Port1 Port2
C01 Port1 N01 3.27e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 1.95e-01
C04 N03 N04 9.81e-08
R04 N03 N04 2.04e+01
C05 N04 N05 1.63e-07
R05 N04 N05 8.13e-01
C06 N05 N06 8.16e-08
R06 N05 N06 1.32e-01
C07 N06 N07 6.37e-11
L07 N06 N07 1.17e-10
R07 N06 N07 1.13e+00
C08 N07 Port2 2.48e-12
L08 N07 Port2 3.16e-10
R08 N07 Port2 2.90e+01
.ENDS GRJ21AR72E332KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E472KWJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E472KWJ1 Port1 Port2
C01 Port1 N01 4.46e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 1.54e-01
C04 N03 N04 1.55e-07
R04 N03 N04 1.59e+01
C05 N04 N05 2.46e-07
R05 N04 N05 6.47e-01
C06 N05 N06 1.35e-07
R06 N05 N06 9.35e-02
C07 N06 N07 1.71e-09
L07 N06 N07 7.28e-11
R07 N06 N07 2.16e-01
C08 N07 N08 1.32e-10
L08 N07 N08 5.92e-11
R08 N07 N08 6.68e-01
C09 N08 Port2 2.41e-12
L09 N08 Port2 2.83e-10
R09 N08 Port2 2.72e+01
.ENDS GRJ21AR72E472KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E682KWJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E682KWJ1 Port1 Port2
C01 Port1 N01 6.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 9.46e-02
C04 N03 N04 3.22e-07
R04 N03 N04 4.94e+00
C05 N04 N05 3.70e-07
R05 N04 N05 3.42e-01
C06 N05 N06 2.33e-07
R06 N05 N06 4.30e-02
L07 N06 N07 1.00e-10
R07 N06 N07 5.35e-01
C08 N07 N08 5.21e-09
L08 N07 N08 5.22e-11
R08 N07 N08 1.32e-01
C09 N08 Port2 2.67e-12
L09 N08 Port2 1.94e-10
R09 N08 Port2 2.69e+01
.ENDS GRJ21AR72E682KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ21BC72A105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BC72A105KE11 Port1 Port2
C01 Port1 N01 1.07e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.52e-10
R03 N02 N03 7.37e-03
C04 N03 N04 1.13e-05
R04 N03 N04 6.77e+02
C05 N04 N05 1.08e-04
R05 N04 N05 6.82e+00
C06 N05 N06 7.89e-05
R06 N05 N06 1.11e+00
C07 N06 N07 7.86e-05
R07 N06 N07 1.04e-01
C08 N07 N08 4.71e-05
R08 N07 N08 1.41e-02
L09 N08 N09 3.39e-11
R09 N08 N09 5.22e-02
L10 N09 N10 2.64e-10
R10 N09 N10 3.98e-02
C11 N10 N11 2.90e-06
L11 N10 N11 6.21e-11
R11 N10 N11 1.44e-02
C12 N11 N12 2.01e-06
L12 N11 N12 3.86e-11
R12 N11 N12 1.26e-02
C13 N12 N13 8.30e-12
L13 N12 N13 8.90e-11
R13 N12 N13 5.94e+00
C14 N13 Port2 6.93e-12
L14 N13 Port2 4.53e-11
R14 N13 Port2 1.15e+01
.ENDS GRJ21BC72A105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ21BC72A105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BC72A105ME11 Port1 Port2
C01 Port1 N01 1.07e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.52e-10
R03 N02 N03 7.37e-03
C04 N03 N04 1.13e-05
R04 N03 N04 6.77e+02
C05 N04 N05 1.08e-04
R05 N04 N05 6.82e+00
C06 N05 N06 7.89e-05
R06 N05 N06 1.11e+00
C07 N06 N07 7.86e-05
R07 N06 N07 1.04e-01
C08 N07 N08 4.71e-05
R08 N07 N08 1.41e-02
L09 N08 N09 3.39e-11
R09 N08 N09 5.22e-02
L10 N09 N10 2.64e-10
R10 N09 N10 3.98e-02
C11 N10 N11 2.90e-06
L11 N10 N11 6.21e-11
R11 N10 N11 1.44e-02
C12 N11 N12 2.01e-06
L12 N11 N12 3.86e-11
R12 N11 N12 1.26e-02
C13 N12 N13 8.30e-12
L13 N12 N13 8.90e-11
R13 N12 N13 5.94e+00
C14 N13 Port2 6.93e-12
L14 N13 Port2 4.53e-11
R14 N13 Port2 1.15e+01
.ENDS GRJ21BC72A105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ21BR61E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR61E106KE01 Port1 Port2
C01 Port1 N01 6.93e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.86e-10
R03 N02 N03 5.13e-03
C04 N03 N04 1.99e-04
R04 N03 N04 2.66e+01
C05 N04 N05 2.37e-04
R05 N04 N05 2.08e+00
C06 N05 N06 2.37e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.95e-04
R07 N06 N07 3.43e-02
C08 N07 N08 1.55e-04
R08 N07 N08 4.86e-03
L09 N08 N09 1.53e-11
R09 N08 N09 1.30e-01
L10 N09 N10 4.52e-11
R10 N09 N10 3.31e-02
L11 N10 N11 3.28e-10
R11 N10 N11 1.88e-02
C12 N11 N12 1.82e-05
L12 N11 N12 8.38e-11
R12 N11 N12 4.31e-03
C13 N12 N13 1.12e-05
L13 N12 N13 6.29e-11
R13 N12 N13 4.62e-03
C14 N13 Port2 9.26e-12
L14 N13 Port2 7.39e-11
R14 N13 Port2 1.17e+01
.ENDS GRJ21BR61E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ21BR71A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71A106KE01 Port1 Port2
C01 Port1 N01 6.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.67e-10
R03 N02 N03 1.19e-02
C04 N03 N04 1.32e-04
R04 N03 N04 4.01e+01
C05 N04 N05 2.39e-04
R05 N04 N05 2.54e+00
C06 N05 N06 2.03e-04
R06 N05 N06 3.96e-01
C07 N06 N07 1.72e-04
R07 N06 N07 4.65e-02
C08 N07 N08 1.64e-04
R08 N07 N08 8.09e-03
L09 N08 N09 1.39e-11
R09 N08 N09 8.39e-02
L10 N09 N10 5.05e-11
R10 N09 N10 4.37e-02
L11 N10 N11 3.12e-10
R11 N10 N11 2.08e-02
C12 N11 N12 2.32e-05
L12 N11 N12 5.11e-11
R12 N11 N12 4.64e-03
C13 N12 N13 1.35e-05
L13 N12 N13 4.19e-11
R13 N12 N13 5.36e-03
C14 N13 N14 1.28e-11
L14 N13 N14 5.64e-11
R14 N13 N14 4.71e+00
C15 N14 Port2 1.18e-11
L15 N14 Port2 2.91e-11
R15 N14 Port2 1.21e+01
.ENDS GRJ21BR71A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ21BR71A106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71A106ME01 Port1 Port2
C01 Port1 N01 6.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.67e-10
R03 N02 N03 1.19e-02
C04 N03 N04 1.32e-04
R04 N03 N04 4.01e+01
C05 N04 N05 2.39e-04
R05 N04 N05 2.54e+00
C06 N05 N06 2.03e-04
R06 N05 N06 3.96e-01
C07 N06 N07 1.72e-04
R07 N06 N07 4.65e-02
C08 N07 N08 1.64e-04
R08 N07 N08 8.09e-03
L09 N08 N09 1.39e-11
R09 N08 N09 8.39e-02
L10 N09 N10 5.05e-11
R10 N09 N10 4.37e-02
L11 N10 N11 3.12e-10
R11 N10 N11 2.08e-02
C12 N11 N12 2.32e-05
L12 N11 N12 5.11e-11
R12 N11 N12 4.64e-03
C13 N12 N13 1.35e-05
L13 N12 N13 4.19e-11
R13 N12 N13 5.36e-03
C14 N13 N14 1.28e-11
L14 N13 N14 5.64e-11
R14 N13 N14 4.71e+00
C15 N14 Port2 1.18e-11
L15 N14 Port2 2.91e-11
R15 N14 Port2 1.21e+01
.ENDS GRJ21BR71A106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ21BR71C475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71C475KE01 Port1 Port2
C01 Port1 N01 3.22e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.81e-10
R03 N02 N03 7.09e-03
C04 N03 N04 5.33e-05
R04 N03 N04 9.96e+01
C05 N04 N05 1.06e-04
R05 N04 N05 3.92e+00
C06 N05 N06 9.10e-05
R06 N05 N06 4.26e-01
C07 N06 N07 7.82e-05
R07 N06 N07 4.34e-02
C08 N07 N08 8.23e-05
R08 N07 N08 7.17e-03
L09 N08 N09 2.04e-11
R09 N08 N09 1.35e-01
L10 N09 N10 4.34e-11
R10 N09 N10 3.71e-02
L11 N10 N11 2.83e-10
R11 N10 N11 2.59e-02
C12 N11 N12 1.04e-05
L12 N11 N12 5.79e-11
R12 N11 N12 7.20e-03
C13 N12 N13 6.15e-06
L13 N12 N13 4.55e-11
R13 N12 N13 8.18e-03
C14 N13 N14 1.57e-11
L14 N13 N14 5.67e-11
R14 N13 N14 5.79e+00
C15 N14 Port2 8.13e-12
L15 N14 Port2 4.47e-11
R15 N14 Port2 8.78e+00
.ENDS GRJ21BR71C475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ21BR71C475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71C475ME01 Port1 Port2
C01 Port1 N01 3.22e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.81e-10
R03 N02 N03 7.09e-03
C04 N03 N04 5.33e-05
R04 N03 N04 9.96e+01
C05 N04 N05 1.06e-04
R05 N04 N05 3.92e+00
C06 N05 N06 9.10e-05
R06 N05 N06 4.26e-01
C07 N06 N07 7.82e-05
R07 N06 N07 4.34e-02
C08 N07 N08 8.23e-05
R08 N07 N08 7.17e-03
L09 N08 N09 2.04e-11
R09 N08 N09 1.35e-01
L10 N09 N10 4.34e-11
R10 N09 N10 3.71e-02
L11 N10 N11 2.83e-10
R11 N10 N11 2.59e-02
C12 N11 N12 1.04e-05
L12 N11 N12 5.79e-11
R12 N11 N12 7.20e-03
C13 N12 N13 6.15e-06
L13 N12 N13 4.55e-11
R13 N12 N13 8.18e-03
C14 N13 N14 1.57e-11
L14 N13 N14 5.67e-11
R14 N13 N14 5.79e+00
C15 N14 Port2 8.13e-12
L15 N14 Port2 4.47e-11
R15 N14 Port2 8.78e+00
.ENDS GRJ21BR71C475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ21BR71E105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71E105KE11 Port1 Port2
C01 Port1 N01 1.04e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.40e-10
R03 N02 N03 1.81e-02
C04 N03 N04 1.07e-05
R04 N03 N04 7.03e+02
C05 N04 N05 1.31e-04
R05 N04 N05 5.27e+00
C06 N05 N06 1.03e-04
R06 N05 N06 6.02e-01
C07 N06 N07 9.70e-05
R07 N06 N07 5.71e-02
C08 N07 N08 7.03e-05
R08 N07 N08 8.13e-03
L09 N08 N09 2.41e-11
R09 N08 N09 6.59e-02
L10 N09 N10 2.93e-10
R10 N09 N10 4.20e-02
C11 N10 N11 4.18e-06
L11 N10 N11 3.54e-11
R11 N10 N11 1.21e-02
C12 N11 N12 2.88e-06
L12 N11 N12 2.38e-11
R12 N11 N12 1.26e-02
C13 N12 N13 1.18e-11
L13 N12 N13 9.15e-11
R13 N12 N13 7.62e+00
C14 N13 Port2 3.77e-12
L14 N13 Port2 9.23e-11
R14 N13 Port2 1.96e+01
.ENDS GRJ21BR71E105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ21BR71E105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71E105ME11 Port1 Port2
C01 Port1 N01 1.04e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.40e-10
R03 N02 N03 1.81e-02
C04 N03 N04 1.07e-05
R04 N03 N04 7.03e+02
C05 N04 N05 1.31e-04
R05 N04 N05 5.27e+00
C06 N05 N06 1.03e-04
R06 N05 N06 6.02e-01
C07 N06 N07 9.70e-05
R07 N06 N07 5.71e-02
C08 N07 N08 7.03e-05
R08 N07 N08 8.13e-03
L09 N08 N09 2.41e-11
R09 N08 N09 6.59e-02
L10 N09 N10 2.93e-10
R10 N09 N10 4.20e-02
C11 N10 N11 4.18e-06
L11 N10 N11 3.54e-11
R11 N10 N11 1.21e-02
C12 N11 N12 2.88e-06
L12 N11 N12 2.38e-11
R12 N11 N12 1.26e-02
C13 N12 N13 1.18e-11
L13 N12 N13 9.15e-11
R13 N12 N13 7.62e+00
C14 N13 Port2 3.77e-12
L14 N13 Port2 9.23e-11
R14 N13 Port2 1.96e+01
.ENDS GRJ21BR71E105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRJ21BR71E225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71E225KE01 Port1 Port2
C01 Port1 N01 1.64e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.12e-10
R03 N02 N03 7.34e-03
C04 N03 N04 1.75e-05
R04 N03 N04 3.64e+02
C05 N04 N05 6.01e-05
R05 N04 N05 8.50e+00
C06 N05 N06 5.09e-05
R06 N05 N06 1.02e+00
C07 N06 N07 3.92e-05
R07 N06 N07 1.22e-01
C08 N07 N08 2.66e-05
R08 N07 N08 1.61e-02
L09 N08 N09 3.28e-11
R09 N08 N09 5.71e-02
L10 N09 N10 2.53e-10
R10 N09 N10 2.95e-02
C11 N10 N11 5.20e-06
L11 N10 N11 4.67e-11
R11 N10 N11 1.10e-02
C12 N11 N12 3.10e-06
L12 N11 N12 3.61e-11
R12 N11 N12 1.00e-02
C13 N12 N13 2.03e-11
L13 N12 N13 5.74e-11
R13 N12 N13 6.22e+00
C14 N13 Port2 1.99e-12
L14 N13 Port2 1.45e-10
R14 N13 Port2 2.72e+01
.ENDS GRJ21BR71E225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRJ21BR71E225ME01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71E225ME01 Port1 Port2
C01 Port1 N01 1.64e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.12e-10
R03 N02 N03 7.34e-03
C04 N03 N04 1.75e-05
R04 N03 N04 3.64e+02
C05 N04 N05 6.01e-05
R05 N04 N05 8.50e+00
C06 N05 N06 5.09e-05
R06 N05 N06 1.02e+00
C07 N06 N07 3.92e-05
R07 N06 N07 1.22e-01
C08 N07 N08 2.66e-05
R08 N07 N08 1.61e-02
L09 N08 N09 3.28e-11
R09 N08 N09 5.71e-02
L10 N09 N10 2.53e-10
R10 N09 N10 2.95e-02
C11 N10 N11 5.20e-06
L11 N10 N11 4.67e-11
R11 N10 N11 1.10e-02
C12 N11 N12 3.10e-06
L12 N11 N12 3.61e-11
R12 N11 N12 1.00e-02
C13 N12 N13 2.03e-11
L13 N12 N13 5.74e-11
R13 N12 N13 6.22e+00
C14 N13 Port2 1.99e-12
L14 N13 Port2 1.45e-10
R14 N13 Port2 2.72e+01
.ENDS GRJ21BR71E225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H104KE01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GRJ21BR71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H104ME01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H104ME01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GRJ21BR71H104ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ21BR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H105KE01 Port1 Port2
C01 Port1 N01 1.08e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.75e-10
R03 N02 N03 7.40e-03
C04 N03 N04 9.63e-06
R04 N03 N04 7.79e+02
C05 N04 N05 1.83e-04
R05 N04 N05 2.42e+00
C06 N05 N06 1.57e-04
R06 N05 N06 2.78e-01
C07 N06 N07 1.41e-04
R07 N06 N07 2.69e-02
C08 N07 N08 1.51e-04
R08 N07 N08 1.97e-03
L09 N08 N09 3.16e-11
R09 N08 N09 6.31e-02
L10 N09 N10 2.66e-10
R10 N09 N10 3.91e-02
C11 N10 N11 2.86e-06
L11 N10 N11 6.33e-11
R11 N10 N11 1.62e-02
C12 N11 N12 2.26e-06
L12 N11 N12 3.66e-11
R12 N11 N12 1.71e-02
C13 N12 N13 1.06e-11
L13 N12 N13 7.23e-11
R13 N12 N13 5.79e+00
C14 N13 Port2 8.30e-12
L14 N13 Port2 4.12e-11
R14 N13 Port2 1.40e+01
.ENDS GRJ21BR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ21BR71H105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H105ME01 Port1 Port2
C01 Port1 N01 1.08e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.75e-10
R03 N02 N03 7.40e-03
C04 N03 N04 9.63e-06
R04 N03 N04 7.79e+02
C05 N04 N05 1.83e-04
R05 N04 N05 2.42e+00
C06 N05 N06 1.57e-04
R06 N05 N06 2.78e-01
C07 N06 N07 1.41e-04
R07 N06 N07 2.69e-02
C08 N07 N08 1.51e-04
R08 N07 N08 1.97e-03
L09 N08 N09 3.16e-11
R09 N08 N09 6.31e-02
L10 N09 N10 2.66e-10
R10 N09 N10 3.91e-02
C11 N10 N11 2.86e-06
L11 N10 N11 6.33e-11
R11 N10 N11 1.62e-02
C12 N11 N12 2.26e-06
L12 N11 N12 3.66e-11
R12 N11 N12 1.71e-02
C13 N12 N13 1.06e-11
L13 N12 N13 7.23e-11
R13 N12 N13 5.79e+00
C14 N13 Port2 8.30e-12
L14 N13 Port2 4.12e-11
R14 N13 Port2 1.40e+01
.ENDS GRJ21BR71H105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H224KE01 Port1 Port2
C01 Port1 N01 2.11e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 2.28e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.91e-01
C05 N04 N05 2.24e-05
R05 N04 N05 2.16e-02
C06 N05 N06 2.43e-05
R06 N05 N06 3.69e-03
L07 N06 N07 1.77e-10
R07 N06 N07 6.47e-02
L08 N07 N08 1.12e-11
R08 N07 N08 3.05e-02
C09 N08 N09 7.77e-07
L09 N08 N09 3.77e-11
R09 N08 N09 2.83e-02
C10 N09 N10 4.02e-07
L10 N09 N10 3.15e-11
R10 N09 N10 2.83e-02
C11 N10 N11 2.01e-11
L11 N10 N11 5.61e-11
R11 N10 N11 4.74e+00
C12 N11 Port2 1.42e-12
L12 N11 Port2 1.55e-10
R12 N11 Port2 3.61e+01
.ENDS GRJ21BR71H224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H224ME01 Port1 Port2
C01 Port1 N01 2.11e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 2.28e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.91e-01
C05 N04 N05 2.24e-05
R05 N04 N05 2.16e-02
C06 N05 N06 2.43e-05
R06 N05 N06 3.69e-03
L07 N06 N07 1.77e-10
R07 N06 N07 6.47e-02
L08 N07 N08 1.12e-11
R08 N07 N08 3.05e-02
C09 N08 N09 7.77e-07
L09 N08 N09 3.77e-11
R09 N08 N09 2.83e-02
C10 N09 N10 4.02e-07
L10 N09 N10 3.15e-11
R10 N09 N10 2.83e-02
C11 N10 N11 2.01e-11
L11 N10 N11 5.61e-11
R11 N10 N11 4.74e+00
C12 N11 Port2 1.42e-12
L12 N11 Port2 1.55e-10
R12 N11 Port2 3.61e+01
.ENDS GRJ21BR71H224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRJ21BR71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H473KE01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GRJ21BR71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRJ21BR71H473ME01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H473ME01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GRJ21BR71H473ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H474KE01 Port1 Port2
C01 Port1 N01 4.55e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.17e-10
R03 N02 N03 9.74e-03
C04 N03 N04 2.83e-05
R04 N03 N04 7.76e-02
C05 N04 N05 4.72e-05
R05 N04 N05 5.52e-03
L06 N05 N06 2.00e-10
R06 N05 N06 5.06e-02
L07 N06 N07 1.26e-11
R07 N06 N07 5.01e-02
C08 N07 N08 1.59e-06
L08 N07 N08 3.89e-11
R08 N07 N08 1.60e-02
C09 N08 N09 7.83e-07
L09 N08 N09 3.74e-11
R09 N08 N09 1.94e-02
C10 N09 N10 1.50e-11
L10 N09 N10 8.57e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 1.61e-12
L11 N10 Port2 1.98e-10
R11 N10 Port2 3.66e+01
.ENDS GRJ21BR71H474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H474ME01 Port1 Port2
C01 Port1 N01 4.55e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.17e-10
R03 N02 N03 9.74e-03
C04 N03 N04 2.83e-05
R04 N03 N04 7.76e-02
C05 N04 N05 4.72e-05
R05 N04 N05 5.52e-03
L06 N05 N06 2.00e-10
R06 N05 N06 5.06e-02
L07 N06 N07 1.26e-11
R07 N06 N07 5.01e-02
C08 N07 N08 1.59e-06
L08 N07 N08 3.89e-11
R08 N07 N08 1.60e-02
C09 N08 N09 7.83e-07
L09 N08 N09 3.74e-11
R09 N08 N09 1.94e-02
C10 N09 N10 1.50e-11
L10 N09 N10 8.57e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 1.61e-12
L11 N10 Port2 1.98e-10
R11 N10 Port2 3.66e+01
.ENDS GRJ21BR71H474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ21BR72A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72A104KE01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GRJ21BR72A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ21BR72A104ME01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72A104ME01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GRJ21BR72A104ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GRJ21BR72A473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72A473KE01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GRJ21BR72A473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GRJ21BR72A473ME01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72A473ME01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GRJ21BR72A473ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GRJ21BR72E103KWJ3
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72E103KWJ3 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 7.72e-02
C04 N03 N04 5.33e-07
R04 N03 N04 2.98e+00
C05 N04 N05 6.56e-07
R05 N04 N05 2.43e-01
C06 N05 N06 4.86e-07
R06 N05 N06 4.41e-02
L07 N06 N07 8.35e-11
R07 N06 N07 1.78e-01
C08 N07 N08 3.42e-08
L08 N07 N08 1.66e-11
R08 N07 N08 4.61e-02
C09 N08 Port2 2.91e-12
L09 N08 Port2 3.09e-10
R09 N08 Port2 3.26e+01
.ENDS GRJ21BR72E103KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GRJ21BR72E153KWJ3
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72E153KWJ3 Port1 Port2
C01 Port1 N01 1.35e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 2.85e-10
R03 N02 N03 6.46e-02
C04 N03 N04 5.24e-07
R04 N03 N04 7.62e+00
C05 N04 N05 1.10e-06
R05 N04 N05 2.90e-01
C06 N05 N06 1.17e-06
R06 N05 N06 4.81e-02
C07 N06 N07 1.17e-06
R07 N06 N07 1.36e-02
L08 N07 N08 6.96e-11
R08 N07 N08 2.09e-01
L09 N08 N09 6.80e-12
R09 N08 N09 9.12e-02
C10 N09 N10 1.06e-08
L10 N09 N10 5.14e-11
R10 N09 N10 6.97e-02
C11 N10 Port2 4.83e-12
L11 N10 Port2 2.70e-10
R11 N10 Port2 2.59e+01
.ENDS GRJ21BR72E153KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GRJ21BR72E223KWJ3
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR72E223KWJ3 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 2.46e-10
R03 N02 N03 4.90e-02
C04 N03 N04 1.18e-06
R04 N03 N04 2.13e+00
C05 N04 N05 1.97e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.30e-06
R06 N05 N06 4.35e-02
L07 N06 N07 7.92e-11
R07 N06 N07 1.61e-01
C08 N07 N08 3.28e-08
L08 N07 N08 3.29e-11
R08 N07 N08 5.02e-02
C09 N08 Port2 4.23e-12
L09 N08 Port2 1.94e-10
R09 N08 Port2 2.24e+01
.ENDS GRJ21BR72E223KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ319R71H104KE11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ319R71H104KE11 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GRJ319R71H104KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ319R71H104ME11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ319R71H104ME11 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GRJ319R71H104ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ319R72A104KE11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ319R72A104KE11 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GRJ319R72A104KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ319R72A104ME11
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ319R72A104ME11 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GRJ319R72A104ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GRJ31BR72E153KWJ1
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72E153KWJ1 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 1.88e-10
R03 N02 N03 9.66e-02
C04 N03 N04 7.66e-07
R04 N03 N04 2.03e+00
C05 N04 N05 7.15e-07
R05 N04 N05 1.31e-01
L06 N05 N06 9.91e-11
R06 N05 N06 1.71e-01
C07 N06 N07 5.85e-12
L07 N06 N07 3.52e-10
R07 N06 N07 2.95e+01
C08 N07 Port2 2.74e-12
L08 N07 Port2 3.29e-10
R08 N07 Port2 3.46e+01
.ENDS GRJ31BR72E153KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GRJ31BR72E223KWJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72E223KWJ1 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 2.95e-10
R03 N02 N03 6.42e-02
C04 N03 N04 1.65e-06
R04 N03 N04 9.63e-01
C05 N04 N05 2.08e-06
R05 N04 N05 1.75e-01
C06 N05 N06 1.09e-06
R06 N05 N06 4.20e-02
L07 N06 N07 1.08e-10
R07 N06 N07 3.23e-01
L08 N07 N08 2.05e-11
R08 N07 N08 3.16e-02
C09 N08 N09 1.79e-08
L09 N08 N09 5.26e-11
R09 N08 N09 5.42e-02
C10 N09 Port2 3.74e-12
L10 N09 Port2 4.58e-10
R10 N09 Port2 7.15e+01
.ENDS GRJ31BR72E223KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GRJ31BR72E683KWJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72E683KWJ1 Port1 Port2
C01 Port1 N01 6.78e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 4.62e-10
R03 N02 N03 3.46e-02
C04 N03 N04 4.52e-06
R04 N03 N04 3.52e-01
C05 N04 N05 8.23e-06
R05 N04 N05 3.07e-02
C06 N05 N06 9.02e-06
R06 N05 N06 1.34e-02
L07 N06 N07 3.17e-11
R07 N06 N07 1.69e-01
L08 N07 N08 1.48e-10
R08 N07 N08 1.02e-01
C09 N08 N09 9.76e-08
L09 N08 N09 4.84e-11
R09 N08 N09 3.15e-02
C10 N09 Port2 9.54e-12
L10 N09 Port2 1.80e-10
R10 N09 Port2 1.37e+01
.ENDS GRJ31BR72E683KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J102KWJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J102KWJ1 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.01e-10
R03 N02 N03 2.49e-01
C04 N03 N04 1.23e-08
R04 N03 N04 2.05e+02
C05 N04 N05 2.09e-07
R05 N04 N05 1.91e+00
C06 N05 N06 7.94e-08
R06 N05 N06 1.27e+00
C07 N06 N07 3.31e-08
R07 N06 N07 4.49e-01
C08 N07 N08 6.60e-09
R08 N07 N08 2.36e-01
L09 N08 N09 1.32e-10
R09 N08 N09 1.69e+00
C10 N09 N10 5.86e-10
L10 N09 N10 6.71e-11
R10 N09 N10 5.36e-01
C11 N10 Port2 3.45e-12
L11 N10 Port2 3.60e-10
R11 N10 Port2 2.29e+01
.ENDS GRJ31BR72J102KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GRJ31BR72J103KWJ1
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J103KWJ1 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.88e-10
R03 N02 N03 6.53e-02
C04 N03 N04 5.19e-07
R04 N03 N04 4.86e+00
C05 N04 N05 1.25e-06
R05 N04 N05 2.79e-01
C06 N05 N06 1.01e-06
R06 N05 N06 9.92e-02
C07 N06 N07 4.03e-07
R07 N06 N07 4.64e-02
L08 N07 N08 1.39e-10
R08 N07 N08 5.52e-01
C09 N08 N09 6.45e-08
L09 N08 N09 2.11e-11
R09 N08 N09 5.72e-02
C10 N09 N10 8.70e-09
L10 N09 N10 5.68e-11
R10 N09 N10 1.28e-01
C11 N10 Port2 5.49e-12
L11 N10 Port2 2.37e-10
R11 N10 Port2 2.13e+01
.ENDS GRJ31BR72J103KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J152KWJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J152KWJ1 Port1 Port2
C01 Port1 N01 1.53e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.56e-10
R03 N02 N03 2.45e-01
C04 N03 N04 3.23e-08
R04 N03 N04 6.96e+01
C05 N04 N05 2.09e-07
R05 N04 N05 6.06e+00
C06 N05 N06 2.24e-07
R06 N05 N06 7.12e-01
C07 N06 N07 2.40e-07
R07 N06 N07 4.19e-01
C08 N07 N08 6.30e-08
R08 N07 N08 3.25e-01
C09 N08 N09 8.50e-09
R09 N08 N09 1.67e-01
L10 N09 N10 2.57e-10
R10 N09 N10 3.45e+00
C11 N10 Port2 1.01e-11
L11 N10 Port2 2.56e-10
R11 N10 Port2 1.59e+01
.ENDS GRJ31BR72J152KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J222KWJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J222KWJ1 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.77e-10
R03 N02 N03 1.69e-01
C04 N03 N04 5.36e-08
R04 N03 N04 4.10e+01
C05 N04 N05 4.67e-07
R05 N04 N05 6.80e-01
C06 N05 N06 1.48e-07
R06 N05 N06 6.80e-01
C07 N06 N07 9.76e-08
R07 N06 N07 1.63e-01
C08 N07 N08 3.09e-08
R08 N07 N08 1.01e-01
L09 N08 N09 8.10e-11
R09 N08 N09 1.40e+00
C10 N09 N10 1.17e-08
L10 N09 N10 1.53e-11
R10 N09 N10 8.10e-02
C11 N10 N11 1.77e-09
L11 N10 N11 3.35e-11
R11 N10 N11 2.18e-01
C12 N11 Port2 6.90e-12
L12 N11 Port2 2.99e-10
R12 N11 Port2 2.08e+01
.ENDS GRJ31BR72J222KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J332KWJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J332KWJ1 Port1 Port2
C01 Port1 N01 3.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.37e-10
R03 N02 N03 1.12e-01
C04 N03 N04 1.02e-07
R04 N03 N04 1.83e+01
C05 N04 N05 2.62e-07
R05 N04 N05 6.07e-01
C06 N05 N06 1.69e-07
R06 N05 N06 2.15e-01
C07 N06 N07 3.01e-08
R07 N06 N07 8.57e-02
L08 N07 N08 1.52e-10
R08 N07 N08 8.29e-01
C09 N08 N09 1.94e-09
L09 N08 N09 4.86e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 5.59e-12
L10 N09 Port2 3.36e-10
R10 N09 Port2 2.45e+01
.ENDS GRJ31BR72J332KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J472KWJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J472KWJ1 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.93e-10
R03 N02 N03 9.50e-02
C04 N03 N04 1.91e-07
R04 N03 N04 9.56e+00
C05 N04 N05 5.77e-07
R05 N04 N05 5.50e-01
C06 N05 N06 2.25e-07
R06 N05 N06 2.46e-01
C07 N06 N07 7.10e-08
R07 N06 N07 6.46e-02
L08 N07 N08 1.82e-10
R08 N07 N08 6.41e-01
C09 N08 N09 7.01e-08
L09 N08 N09 8.10e-12
R09 N08 N09 3.40e-02
C10 N09 N10 6.25e-09
L10 N09 N10 2.74e-11
R10 N09 N10 1.32e-01
C11 N10 Port2 5.83e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.70e+01
.ENDS GRJ31BR72J472KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J682KWJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J682KWJ1 Port1 Port2
C01 Port1 N01 6.83e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.74e-10
R03 N02 N03 9.84e-02
C04 N03 N04 3.31e-07
R04 N03 N04 4.81e+00
C05 N04 N05 4.07e-07
R05 N04 N05 3.91e-01
C06 N05 N06 2.34e-07
R06 N05 N06 7.12e-02
L07 N06 N07 9.84e-11
R07 N06 N07 4.79e-01
C08 N07 N08 4.96e-08
L08 N07 N08 1.38e-11
R08 N07 N08 4.19e-02
C09 N08 N09 8.42e-09
L09 N08 N09 2.45e-11
R09 N08 N09 1.08e-01
C10 N09 Port2 7.68e-12
L10 N09 Port2 2.81e-10
R10 N09 Port2 2.20e+01
.ENDS GRJ31BR72J682KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A102KWJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A102KWJ1 Port1 Port2
C01 Port1 N01 1.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.80e-10
R03 N02 N03 2.90e-01
C04 N03 N04 1.35e-08
R04 N03 N04 1.82e+02
C05 N04 N05 1.05e-07
R05 N04 N05 1.62e+00
C06 N05 N06 7.79e-08
R06 N05 N06 5.13e-01
C07 N06 N07 3.90e-08
R07 N06 N07 2.57e-01
C08 N07 N08 8.94e-09
R08 N07 N08 1.74e-01
C09 N08 N09 4.17e-10
L09 N08 N09 7.14e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 2.63e-12
L10 N09 Port2 4.51e-10
R10 N09 Port2 2.61e+01
.ENDS GRJ31BR73A102KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A152KWJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A152KWJ1 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.68e-10
R03 N02 N03 2.22e-01
C04 N03 N04 2.66e-08
R04 N03 N04 9.69e+01
C05 N04 N05 4.85e-07
R05 N04 N05 1.65e+00
C06 N05 N06 1.01e-07
R06 N05 N06 1.14e+00
C07 N06 N07 5.69e-08
R07 N06 N07 2.80e-01
C08 N07 N08 2.16e-08
R08 N07 N08 1.06e-01
L09 N08 N09 1.76e-10
R09 N08 N09 2.36e+00
C10 N09 N10 1.95e-09
L10 N09 N10 1.92e-11
R10 N09 N10 2.27e-01
C11 N10 Port2 7.59e-12
L11 N10 Port2 2.71e-10
R11 N10 Port2 2.17e+01
.ENDS GRJ31BR73A152KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A222KWJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A222KWJ1 Port1 Port2
C01 Port1 N01 2.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-10
R03 N02 N03 2.12e-01
C04 N03 N04 4.34e-08
R04 N03 N04 5.81e+01
C05 N04 N05 1.20e-07
R05 N04 N05 1.03e+00
C06 N05 N06 9.72e-08
R06 N05 N06 1.64e-01
C07 N06 N07 3.45e-08
R07 N06 N07 1.03e-01
C08 N07 N08 9.15e-10
L08 N07 N08 5.66e-11
R08 N07 N08 2.49e-01
C09 N08 Port2 5.51e-12
L09 N08 Port2 3.74e-10
R09 N08 Port2 2.07e+01
.ENDS GRJ31BR73A222KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A332KWJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A332KWJ1 Port1 Port2
C01 Port1 N01 3.41e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.65e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.11e-07
R04 N03 N04 1.57e+01
C05 N04 N05 2.38e-07
R05 N04 N05 6.70e-01
C06 N05 N06 1.93e-06
R06 N05 N06 4.13e-01
C07 N06 N07 2.22e-07
R07 N06 N07 1.43e-01
C08 N07 N08 6.25e-08
R08 N07 N08 9.68e-02
C09 N08 N09 1.86e-09
L09 N08 N09 3.05e-11
R09 N08 N09 1.37e-01
C10 N09 Port2 5.88e-12
L10 N09 Port2 4.41e-10
R10 N09 Port2 2.50e+01
.ENDS GRJ31BR73A332KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-04[uF]/1000[V]
* Murata P/N :GRJ31BR73A471KWJ1
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A471KWJ1 Port1 Port2
C01 Port1 N01 4.73e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.60e-10
R03 N02 N03 2.93e-01
C04 N03 N04 8.63e-09
R04 N03 N04 9.24e+01
C05 N04 N05 6.25e-08
R05 N04 N05 2.55e+00
C06 N05 N06 2.73e-08
R06 N05 N06 1.64e+00
C07 N06 N07 1.50e-08
R07 N06 N07 5.32e-01
C08 N07 N08 1.90e-09
R08 N07 N08 4.87e-01
C09 N08 Port2 4.23e-12
L09 N08 Port2 6.73e-10
R09 N08 Port2 3.03e+01
.ENDS GRJ31BR73A471KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A472KWJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A472KWJ1 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.99e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.88e-07
R04 N03 N04 8.65e+00
C05 N04 N05 4.12e-07
R05 N04 N05 4.14e-01
C06 N05 N06 2.32e-07
R06 N05 N06 1.34e-01
C07 N06 N07 1.19e-07
R07 N06 N07 2.80e-02
L08 N07 N08 1.29e-10
R08 N07 N08 9.58e-01
C09 N08 N09 5.72e-08
L09 N08 N09 9.93e-12
R09 N08 N09 5.25e-02
C10 N09 N10 2.87e-09
L10 N09 N10 5.98e-11
R10 N09 N10 1.99e-01
C11 N10 Port2 5.85e-12
L11 N10 Port2 2.67e-10
R11 N10 Port2 2.63e+01
.ENDS GRJ31BR73A472KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-04[uF]/1000[V]
* Murata P/N :GRJ31BR73A681KWJ1
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A681KWJ1 Port1 Port2
C01 Port1 N01 6.91e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.12e-10
R03 N02 N03 2.62e-01
C04 N03 N04 2.47e-08
R04 N03 N04 2.34e+01
C05 N04 N05 5.65e-08
R05 N04 N05 2.24e+00
C06 N05 N06 7.45e-07
R06 N05 N06 1.07e+00
C07 N06 N07 2.30e-08
R07 N06 N07 6.91e-01
C08 N07 N08 4.29e-09
R08 N07 N08 3.31e-01
C09 N08 Port2 3.01e-12
L09 N08 Port2 6.54e-10
R09 N08 Port2 2.68e+01
.ENDS GRJ31BR73A681KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CC71E106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC71E106KE11 Port1 Port2
C01 Port1 N01 9.55e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.18e-11
R03 N02 N03 6.29e-03
C04 N03 N04 7.06e-04
R04 N03 N04 8.06e+00
C05 N04 N05 1.61e-03
R05 N04 N05 3.56e-01
C06 N05 N06 1.29e-03
R06 N05 N06 5.20e-02
C07 N06 N07 1.25e-03
R07 N06 N07 4.04e-03
L08 N07 N08 1.24e-11
R08 N07 N08 5.53e-02
L09 N08 N09 5.61e-11
R09 N08 N09 3.44e-02
L10 N09 N10 5.35e-10
R10 N09 N10 1.94e-02
C11 N10 N11 1.98e-05
L11 N10 N11 1.66e-10
R11 N10 N11 7.88e-03
C12 N11 N12 2.72e-05
L12 N11 N12 5.30e-11
R12 N11 N12 6.45e-03
C13 N12 Port2 1.00e-12
L13 N12 Port2 3.67e-10
R13 N12 Port2 1.51e+02
.ENDS GRJ31CC71E106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CC71E106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC71E106ME11 Port1 Port2
C01 Port1 N01 9.55e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.18e-11
R03 N02 N03 6.29e-03
C04 N03 N04 7.06e-04
R04 N03 N04 8.06e+00
C05 N04 N05 1.61e-03
R05 N04 N05 3.56e-01
C06 N05 N06 1.29e-03
R06 N05 N06 5.20e-02
C07 N06 N07 1.25e-03
R07 N06 N07 4.04e-03
L08 N07 N08 1.24e-11
R08 N07 N08 5.53e-02
L09 N08 N09 5.61e-11
R09 N08 N09 3.44e-02
L10 N09 N10 5.35e-10
R10 N09 N10 1.94e-02
C11 N10 N11 1.98e-05
L11 N10 N11 1.66e-10
R11 N10 N11 7.88e-03
C12 N11 N12 2.72e-05
L12 N11 N12 5.30e-11
R12 N11 N12 6.45e-03
C13 N12 Port2 1.00e-12
L13 N12 Port2 3.67e-10
R13 N12 Port2 1.51e+02
.ENDS GRJ31CC71E106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ31CC72A475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC72A475KE01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.05e-11
R03 N02 N03 8.01e-03
C04 N03 N04 3.70e-04
R04 N03 N04 1.43e+01
C05 N04 N05 4.47e-04
R05 N04 N05 1.41e+00
C06 N05 N06 3.64e-04
R06 N05 N06 2.06e-01
C07 N06 N07 3.43e-04
R07 N06 N07 2.16e-02
C08 N07 N08 2.47e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.90e-11
R09 N08 N09 5.93e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.60e-02
L11 N10 N11 4.23e-10
R11 N10 N11 2.36e-02
C12 N11 N12 1.10e-05
L12 N11 N12 1.10e-10
R12 N11 N12 9.95e-03
C13 N12 N13 7.92e-06
L13 N12 N13 6.98e-11
R13 N12 N13 8.94e-03
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.56e-10
R14 N13 Port2 1.06e+02
.ENDS GRJ31CC72A475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ31CC72A475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC72A475ME01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.05e-11
R03 N02 N03 8.01e-03
C04 N03 N04 3.70e-04
R04 N03 N04 1.43e+01
C05 N04 N05 4.47e-04
R05 N04 N05 1.41e+00
C06 N05 N06 3.64e-04
R06 N05 N06 2.06e-01
C07 N06 N07 3.43e-04
R07 N06 N07 2.16e-02
C08 N07 N08 2.47e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.90e-11
R09 N08 N09 5.93e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.60e-02
L11 N10 N11 4.23e-10
R11 N10 N11 2.36e-02
C12 N11 N12 1.10e-05
L12 N11 N12 1.10e-10
R12 N11 N12 9.95e-03
C13 N12 N13 7.92e-06
L13 N12 N13 6.98e-11
R13 N12 N13 8.94e-03
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.56e-10
R14 N13 Port2 1.06e+02
.ENDS GRJ31CC72A475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRJ31CC8YA106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC8YA106KE01 Port1 Port2
C01 Port1 N01 6.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.31e-11
R03 N02 N03 4.41e-03
C04 N03 N04 1.76e-04
R04 N03 N04 5.69e+00
C05 N04 N05 2.05e-04
R05 N04 N05 4.90e-01
C06 N05 N06 1.91e-04
R06 N05 N06 6.67e-02
C07 N06 N07 1.20e-04
R07 N06 N07 1.04e-02
L08 N07 N08 1.54e-11
R08 N07 N08 7.26e-02
L09 N08 N09 6.79e-11
R09 N08 N09 4.01e-02
L10 N09 N10 4.95e-10
R10 N09 N10 2.38e-02
C11 N10 N11 3.43e-05
L11 N10 N11 5.79e-11
R11 N10 N11 6.34e-03
C12 N11 N12 9.60e-06
L12 N11 N12 9.76e-11
R12 N11 N12 7.06e-03
C13 N12 N13 3.63e-11
L13 N12 N13 3.84e-11
R13 N12 N13 7.10e+00
C14 N13 Port2 1.47e-12
L14 N13 Port2 3.52e-10
R14 N13 Port2 1.19e+02
.ENDS GRJ31CC8YA106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRJ31CC8YA106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC8YA106ME01 Port1 Port2
C01 Port1 N01 6.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.31e-11
R03 N02 N03 4.41e-03
C04 N03 N04 1.76e-04
R04 N03 N04 5.69e+00
C05 N04 N05 2.05e-04
R05 N04 N05 4.90e-01
C06 N05 N06 1.91e-04
R06 N05 N06 6.67e-02
C07 N06 N07 1.20e-04
R07 N06 N07 1.04e-02
L08 N07 N08 1.54e-11
R08 N07 N08 7.26e-02
L09 N08 N09 6.79e-11
R09 N08 N09 4.01e-02
L10 N09 N10 4.95e-10
R10 N09 N10 2.38e-02
C11 N10 N11 3.43e-05
L11 N10 N11 5.79e-11
R11 N10 N11 6.34e-03
C12 N11 N12 9.60e-06
L12 N11 N12 9.76e-11
R12 N11 N12 7.06e-03
C13 N12 N13 3.63e-11
L13 N12 N13 3.84e-11
R13 N12 N13 7.10e+00
C14 N13 Port2 1.47e-12
L14 N13 Port2 3.52e-10
R14 N13 Port2 1.19e+02
.ENDS GRJ31CC8YA106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CR61E106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR61E106KE11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR61E106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRJ31CR70J226KE12
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR70J226KE12 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 5.80e-11
R03 N02 N03 7.95e-03
C04 N03 N04 3.60e-04
R04 N03 N04 1.54e+01
C05 N04 N05 4.76e-04
R05 N04 N05 9.76e-01
C06 N05 N06 4.58e-04
R06 N05 N06 1.05e-01
C07 N06 N07 2.96e-04
R07 N06 N07 1.30e-02
L08 N07 N08 1.55e-11
R08 N07 N08 5.62e-02
L09 N08 N09 7.83e-11
R09 N08 N09 3.82e-02
L10 N09 N10 5.31e-10
R10 N09 N10 1.50e-02
C11 N10 N11 5.33e-05
L11 N10 N11 9.61e-11
R11 N10 N11 3.97e-03
C12 N11 N12 3.22e-05
L12 N11 N12 7.85e-11
R12 N11 N12 4.48e-03
C13 N12 N13 4.77e-11
L13 N12 N13 2.78e-11
R13 N12 N13 3.76e+00
C14 N13 Port2 8.49e-13
L14 N13 Port2 3.74e-10
R14 N13 Port2 1.15e+02
.ENDS GRJ31CR70J226KE12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRJ31CR70J226ME12
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR70J226ME12 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 5.80e-11
R03 N02 N03 7.95e-03
C04 N03 N04 3.60e-04
R04 N03 N04 1.54e+01
C05 N04 N05 4.76e-04
R05 N04 N05 9.76e-01
C06 N05 N06 4.58e-04
R06 N05 N06 1.05e-01
C07 N06 N07 2.96e-04
R07 N06 N07 1.30e-02
L08 N07 N08 1.55e-11
R08 N07 N08 5.62e-02
L09 N08 N09 7.83e-11
R09 N08 N09 3.82e-02
L10 N09 N10 5.31e-10
R10 N09 N10 1.50e-02
C11 N10 N11 5.33e-05
L11 N10 N11 9.61e-11
R11 N10 N11 3.97e-03
C12 N11 N12 3.22e-05
L12 N11 N12 7.85e-11
R12 N11 N12 4.48e-03
C13 N12 N13 4.77e-11
L13 N12 N13 2.78e-11
R13 N12 N13 3.76e+00
C14 N13 Port2 8.49e-13
L14 N13 Port2 3.74e-10
R14 N13 Port2 1.15e+02
.ENDS GRJ31CR70J226ME12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A106KE11 Port1 Port2
C01 Port1 N01 9.75e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.86e-11
R03 N02 N03 1.02e-02
C04 N03 N04 8.30e-04
R04 N03 N04 6.39e+00
C05 N04 N05 1.16e-03
R05 N04 N05 4.22e-01
C06 N05 N06 1.03e-03
R06 N05 N06 5.43e-02
C07 N06 N07 1.93e-03
R07 N06 N07 5.77e-03
C08 N07 N08 6.88e-04
R08 N07 N08 1.37e-03
L09 N08 N09 2.36e-11
R09 N08 N09 4.68e-02
L10 N09 N10 7.02e-11
R10 N09 N10 2.93e-02
L11 N10 N11 5.65e-10
R11 N10 N11 1.79e-02
C12 N11 N12 3.36e-05
L12 N11 N12 1.05e-10
R12 N11 N12 5.30e-03
C13 N12 N13 2.19e-05
L13 N12 N13 7.31e-11
R13 N12 N13 5.22e-03
C14 N13 N14 2.77e-11
L14 N13 N14 2.93e-11
R14 N13 N14 3.00e+00
C15 N14 Port2 9.69e-13
L15 N14 Port2 2.94e-10
R15 N14 Port2 1.09e+02
.ENDS GRJ31CR71A106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A106ME11 Port1 Port2
C01 Port1 N01 9.75e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.86e-11
R03 N02 N03 1.02e-02
C04 N03 N04 8.30e-04
R04 N03 N04 6.39e+00
C05 N04 N05 1.16e-03
R05 N04 N05 4.22e-01
C06 N05 N06 1.03e-03
R06 N05 N06 5.43e-02
C07 N06 N07 1.93e-03
R07 N06 N07 5.77e-03
C08 N07 N08 6.88e-04
R08 N07 N08 1.37e-03
L09 N08 N09 2.36e-11
R09 N08 N09 4.68e-02
L10 N09 N10 7.02e-11
R10 N09 N10 2.93e-02
L11 N10 N11 5.65e-10
R11 N10 N11 1.79e-02
C12 N11 N12 3.36e-05
L12 N11 N12 1.05e-10
R12 N11 N12 5.30e-03
C13 N12 N13 2.19e-05
L13 N12 N13 7.31e-11
R13 N12 N13 5.22e-03
C14 N13 N14 2.77e-11
L14 N13 N14 2.93e-11
R14 N13 N14 3.00e+00
C15 N14 Port2 9.69e-13
L15 N14 Port2 2.94e-10
R15 N14 Port2 1.09e+02
.ENDS GRJ31CR71A106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A226KE12
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A226KE12 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.64e-11
R03 N02 N03 4.68e-03
C04 N03 N04 3.12e-04
R04 N03 N04 1.63e+01
C05 N04 N05 4.46e-04
R05 N04 N05 9.80e-01
C06 N05 N06 4.06e-04
R06 N05 N06 1.09e-01
C07 N06 N07 3.97e-04
R07 N06 N07 1.08e-02
C08 N07 N08 2.72e-04
R08 N07 N08 2.42e-03
L09 N08 N09 1.74e-11
R09 N08 N09 7.27e-02
L10 N09 N10 7.97e-11
R10 N09 N10 3.89e-02
L11 N10 N11 5.64e-10
R11 N10 N11 1.39e-02
C12 N11 N12 5.13e-05
L12 N11 N12 8.38e-11
R12 N11 N12 4.28e-03
C13 N12 N13 4.15e-05
L13 N12 N13 4.86e-11
R13 N12 N13 3.96e-03
C14 N13 N14 1.88e-11
L14 N13 N14 5.51e-11
R14 N13 N14 6.71e+00
C15 N14 Port2 1.01e-12
L15 N14 Port2 3.65e-10
R15 N14 Port2 1.40e+02
.ENDS GRJ31CR71A226KE12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A226ME12
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A226ME12 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.64e-11
R03 N02 N03 4.68e-03
C04 N03 N04 3.12e-04
R04 N03 N04 1.63e+01
C05 N04 N05 4.46e-04
R05 N04 N05 9.80e-01
C06 N05 N06 4.06e-04
R06 N05 N06 1.09e-01
C07 N06 N07 3.97e-04
R07 N06 N07 1.08e-02
C08 N07 N08 2.72e-04
R08 N07 N08 2.42e-03
L09 N08 N09 1.74e-11
R09 N08 N09 7.27e-02
L10 N09 N10 7.97e-11
R10 N09 N10 3.89e-02
L11 N10 N11 5.64e-10
R11 N10 N11 1.39e-02
C12 N11 N12 5.13e-05
L12 N11 N12 8.38e-11
R12 N11 N12 4.28e-03
C13 N12 N13 4.15e-05
L13 N12 N13 4.86e-11
R13 N12 N13 3.96e-03
C14 N13 N14 1.88e-11
L14 N13 N14 5.51e-11
R14 N13 N14 6.71e+00
C15 N14 Port2 1.01e-12
L15 N14 Port2 3.65e-10
R15 N14 Port2 1.40e+02
.ENDS GRJ31CR71A226ME12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRJ31CR71C106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71C106KE11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR71C106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRJ31CR71C106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71C106ME11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR71C106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ31CR71C475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71C475KE11 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.34e-10
R03 N02 N03 1.24e-02
C04 N03 N04 6.04e-04
R04 N03 N04 8.39e+00
C05 N04 N05 6.50e-04
R05 N04 N05 8.52e-01
C06 N05 N06 5.47e-04
R06 N05 N06 1.18e-01
C07 N06 N07 5.79e-04
R07 N06 N07 1.18e-02
C08 N07 N08 3.80e-04
R08 N07 N08 2.61e-03
L09 N08 N09 2.33e-11
R09 N08 N09 8.26e-02
L10 N09 N10 5.37e-11
R10 N09 N10 3.10e-02
L11 N10 N11 4.92e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.69e-05
L12 N11 N12 7.98e-11
R12 N11 N12 8.62e-03
C13 N12 N13 7.93e-06
L13 N12 N13 7.99e-11
R13 N12 N13 9.23e-03
C14 N13 N14 5.99e-11
L14 N13 N14 1.58e-11
R14 N13 N14 2.25e+00
C15 N14 Port2 1.03e-12
L15 N14 Port2 2.56e-10
R15 N14 Port2 5.04e+01
.ENDS GRJ31CR71C475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ31CR71C475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71C475ME11 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.34e-10
R03 N02 N03 1.24e-02
C04 N03 N04 6.04e-04
R04 N03 N04 8.39e+00
C05 N04 N05 6.50e-04
R05 N04 N05 8.52e-01
C06 N05 N06 5.47e-04
R06 N05 N06 1.18e-01
C07 N06 N07 5.79e-04
R07 N06 N07 1.18e-02
C08 N07 N08 3.80e-04
R08 N07 N08 2.61e-03
L09 N08 N09 2.33e-11
R09 N08 N09 8.26e-02
L10 N09 N10 5.37e-11
R10 N09 N10 3.10e-02
L11 N10 N11 4.92e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.69e-05
L12 N11 N12 7.98e-11
R12 N11 N12 8.62e-03
C13 N12 N13 7.93e-06
L13 N12 N13 7.99e-11
R13 N12 N13 9.23e-03
C14 N13 N14 5.99e-11
L14 N13 N14 1.58e-11
R14 N13 N14 2.25e+00
C15 N14 Port2 1.03e-12
L15 N14 Port2 2.56e-10
R15 N14 Port2 5.04e+01
.ENDS GRJ31CR71C475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CR71E106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71E106KE11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR71E106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CR71E106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71E106ME11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR71E106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H105KE11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.29e-10
R03 N02 N03 1.22e-02
C04 N03 N04 1.21e-04
R04 N03 N04 1.68e+01
C05 N04 N05 1.29e-04
R05 N04 N05 1.34e+00
C06 N05 N06 1.15e-04
R06 N05 N06 1.54e-01
C07 N06 N07 7.87e-05
R07 N06 N07 2.27e-02
C08 N07 N08 1.58e-04
R08 N07 N08 1.64e-03
L09 N08 N09 4.15e-11
R09 N08 N09 7.01e-02
L10 N09 N10 3.48e-10
R10 N09 N10 4.72e-02
C11 N10 N11 3.33e-06
L11 N10 N11 7.68e-11
R11 N10 N11 1.75e-02
C12 N11 N12 1.48e-06
L12 N11 N12 7.40e-11
R12 N11 N12 1.90e-02
C13 N12 N13 2.16e-11
L13 N12 N13 6.98e-11
R13 N12 N13 5.93e+00
C14 N13 Port2 1.30e-12
L14 N13 Port2 3.44e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ31CR71H105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H105ME11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.29e-10
R03 N02 N03 1.22e-02
C04 N03 N04 1.21e-04
R04 N03 N04 1.68e+01
C05 N04 N05 1.29e-04
R05 N04 N05 1.34e+00
C06 N05 N06 1.15e-04
R06 N05 N06 1.54e-01
C07 N06 N07 7.87e-05
R07 N06 N07 2.27e-02
C08 N07 N08 1.58e-04
R08 N07 N08 1.64e-03
L09 N08 N09 4.15e-11
R09 N08 N09 7.01e-02
L10 N09 N10 3.48e-10
R10 N09 N10 4.72e-02
C11 N10 N11 3.33e-06
L11 N10 N11 7.68e-11
R11 N10 N11 1.75e-02
C12 N11 N12 1.48e-06
L12 N11 N12 7.40e-11
R12 N11 N12 1.90e-02
C13 N12 N13 2.16e-11
L13 N12 N13 6.98e-11
R13 N12 N13 5.93e+00
C14 N13 Port2 1.30e-12
L14 N13 Port2 3.44e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ31CR71H105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H225KE11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H225KE11 Port1 Port2
C01 Port1 N01 2.19e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.62e-12
R03 N02 N03 1.11e-02
C04 N03 N04 2.64e-04
R04 N03 N04 7.40e+00
C05 N04 N05 2.76e-04
R05 N04 N05 5.48e-01
C06 N05 N06 2.34e-04
R06 N05 N06 7.20e-02
C07 N06 N07 1.83e-04
R07 N06 N07 8.91e-03
C08 N07 N08 1.58e-04
R08 N07 N08 6.03e-04
L09 N08 N09 5.15e-11
R09 N08 N09 6.18e-02
L10 N09 N10 4.55e-10
R10 N09 N10 3.57e-02
C11 N10 N11 7.11e-06
L11 N10 N11 8.96e-11
R11 N10 N11 1.51e-02
C12 N11 N12 3.87e-06
L12 N11 N12 7.30e-11
R12 N11 N12 1.34e-02
C13 N12 N13 2.01e-10
L13 N12 N13 4.12e-12
R13 N12 N13 7.64e-01
C14 N13 Port2 7.29e-13
L14 N13 Port2 4.03e-10
R14 N13 Port2 1.31e+02
.ENDS GRJ31CR71H225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H225ME11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H225ME11 Port1 Port2
C01 Port1 N01 2.19e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.62e-12
R03 N02 N03 1.11e-02
C04 N03 N04 2.64e-04
R04 N03 N04 7.40e+00
C05 N04 N05 2.76e-04
R05 N04 N05 5.48e-01
C06 N05 N06 2.34e-04
R06 N05 N06 7.20e-02
C07 N06 N07 1.83e-04
R07 N06 N07 8.91e-03
C08 N07 N08 1.58e-04
R08 N07 N08 6.03e-04
L09 N08 N09 5.15e-11
R09 N08 N09 6.18e-02
L10 N09 N10 4.55e-10
R10 N09 N10 3.57e-02
C11 N10 N11 7.11e-06
L11 N10 N11 8.96e-11
R11 N10 N11 1.51e-02
C12 N11 N12 3.87e-06
L12 N11 N12 7.30e-11
R12 N11 N12 1.34e-02
C13 N12 N13 2.01e-10
L13 N12 N13 4.12e-12
R13 N12 N13 7.64e-01
C14 N13 Port2 7.29e-13
L14 N13 Port2 4.03e-10
R14 N13 Port2 1.31e+02
.ENDS GRJ31CR71H225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H475KE11 Port1 Port2
C01 Port1 N01 4.35e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.45e-11
R03 N02 N03 7.37e-03
C04 N03 N04 9.15e-04
R04 N03 N04 2.42e+00
C05 N04 N05 8.37e-04
R05 N04 N05 3.40e-01
C06 N05 N06 8.24e-04
R06 N05 N06 4.81e-02
C07 N06 N07 8.98e-04
R07 N06 N07 8.45e-03
C08 N07 N08 5.09e-04
R08 N07 N08 1.67e-03
L09 N08 N09 1.50e-11
R09 N08 N09 7.49e-02
L10 N09 N10 6.58e-11
R10 N09 N10 4.33e-02
L11 N10 N11 5.35e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.44e-05
L12 N11 N12 1.07e-10
R12 N11 N12 8.46e-03
C13 N12 N13 7.84e-06
L13 N12 N13 8.26e-11
R13 N12 N13 7.47e-03
C14 N13 N14 2.27e-11
L14 N13 N14 4.78e-11
R14 N13 N14 3.67e+00
C15 N14 Port2 1.18e-12
L15 N14 Port2 2.93e-10
R15 N14 Port2 1.26e+02
.ENDS GRJ31CR71H475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H475ME11 Port1 Port2
C01 Port1 N01 4.35e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.45e-11
R03 N02 N03 7.37e-03
C04 N03 N04 9.15e-04
R04 N03 N04 2.42e+00
C05 N04 N05 8.37e-04
R05 N04 N05 3.40e-01
C06 N05 N06 8.24e-04
R06 N05 N06 4.81e-02
C07 N06 N07 8.98e-04
R07 N06 N07 8.45e-03
C08 N07 N08 5.09e-04
R08 N07 N08 1.67e-03
L09 N08 N09 1.50e-11
R09 N08 N09 7.49e-02
L10 N09 N10 6.58e-11
R10 N09 N10 4.33e-02
L11 N10 N11 5.35e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.44e-05
L12 N11 N12 1.07e-10
R12 N11 N12 8.46e-03
C13 N12 N13 7.84e-06
L13 N12 N13 8.26e-11
R13 N12 N13 7.47e-03
C14 N13 N14 2.27e-11
L14 N13 N14 4.78e-11
R14 N13 N14 3.67e+00
C15 N14 Port2 1.18e-12
L15 N14 Port2 2.93e-10
R15 N14 Port2 1.26e+02
.ENDS GRJ31CR71H475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ31CR72A105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72A105KE11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 9.26e-11
R03 N02 N03 7.37e-03
C04 N03 N04 1.63e-04
R04 N03 N04 1.03e+01
C05 N04 N05 2.81e-04
R05 N04 N05 1.08e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.88e-01
C07 N06 N07 2.01e-04
R07 N06 N07 6.65e-02
C08 N07 N08 1.09e-04
R08 N07 N08 2.34e-02
C09 N08 N09 1.46e-04
R09 N08 N09 1.71e-03
L10 N09 N10 3.32e-10
R10 N09 N10 3.68e-02
L11 N10 N11 4.65e-11
R11 N10 N11 3.62e-02
C12 N11 N12 3.28e-06
L12 N11 N12 7.89e-11
R12 N11 N12 2.50e-02
C13 N12 N13 1.42e-06
L13 N12 N13 7.79e-11
R13 N12 N13 1.87e-02
C14 N13 N14 5.46e-10
L14 N13 N14 4.75e-11
R14 N13 N14 3.72e-01
C15 N14 Port2 1.00e-12
L15 N14 Port2 3.42e-10
R15 N14 Port2 8.97e+01
.ENDS GRJ31CR72A105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ31CR72A105ME11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72A105ME11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 9.26e-11
R03 N02 N03 7.37e-03
C04 N03 N04 1.63e-04
R04 N03 N04 1.03e+01
C05 N04 N05 2.81e-04
R05 N04 N05 1.08e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.88e-01
C07 N06 N07 2.01e-04
R07 N06 N07 6.65e-02
C08 N07 N08 1.09e-04
R08 N07 N08 2.34e-02
C09 N08 N09 1.46e-04
R09 N08 N09 1.71e-03
L10 N09 N10 3.32e-10
R10 N09 N10 3.68e-02
L11 N10 N11 4.65e-11
R11 N10 N11 3.62e-02
C12 N11 N12 3.28e-06
L12 N11 N12 7.89e-11
R12 N11 N12 2.50e-02
C13 N12 N13 1.42e-06
L13 N12 N13 7.79e-11
R13 N12 N13 1.87e-02
C14 N13 N14 5.46e-10
L14 N13 N14 4.75e-11
R14 N13 N14 3.72e-01
C15 N14 Port2 1.00e-12
L15 N14 Port2 3.42e-10
R15 N14 Port2 8.97e+01
.ENDS GRJ31CR72A105ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/250[V]
* Murata P/N :GRJ31CR72E104KWJ3
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72E104KWJ3 Port1 Port2
C01 Port1 N01 9.84e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 4.77e-10
R03 N02 N03 2.41e-02
C04 N03 N04 7.33e-06
R04 N03 N04 2.17e-01
C05 N04 N05 1.93e-05
R05 N04 N05 2.07e-02
C06 N05 N06 9.02e-06
R06 N05 N06 1.40e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.43e-01
L08 N07 N08 1.51e-10
R08 N07 N08 1.01e-01
C09 N08 N09 3.64e-07
L09 N08 N09 5.41e-11
R09 N08 N09 2.43e-02
C10 N09 N10 9.15e-08
L10 N09 N10 8.18e-11
R10 N09 N10 4.74e-02
C11 N10 Port2 7.10e-12
L11 N10 Port2 1.92e-10
R11 N10 Port2 1.98e+01
.ENDS GRJ31CR72E104KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-02[uF]/250[V]
* Murata P/N :GRJ31CR72E333KWJ3
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72E333KWJ3 Port1 Port2
C01 Port1 N01 3.15e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 5.10e-10
R03 N02 N03 5.04e-02
C04 N03 N04 2.14e-06
R04 N03 N04 7.44e-01
C05 N04 N05 3.98e-06
R05 N04 N05 7.97e-02
C06 N05 N06 1.91e-06
R06 N05 N06 3.90e-02
L07 N06 N07 4.14e-11
R07 N06 N07 1.76e-01
L08 N07 N08 4.54e-11
R08 N07 N08 1.14e-01
C09 N08 N09 1.40e-07
L09 N08 N09 2.45e-11
R09 N08 N09 1.96e-02
C10 N09 N10 1.50e-08
L10 N09 N10 7.22e-11
R10 N09 N10 6.94e-02
C11 N10 Port2 7.69e-12
L11 N10 Port2 3.22e-10
R11 N10 Port2 3.48e+01
.ENDS GRJ31CR72E333KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-02[uF]/250[V]
* Murata P/N :GRJ31CR72E473KWJ3
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72E473KWJ3 Port1 Port2
C01 Port1 N01 4.79e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 4.40e-10
R03 N02 N03 3.46e-02
C04 N03 N04 4.55e-06
R04 N03 N04 3.50e-01
C05 N04 N05 5.11e-06
R05 N04 N05 9.41e-02
C06 N05 N06 2.94e-06
R06 N05 N06 2.16e-02
L07 N06 N07 1.38e-10
R07 N06 N07 1.37e-01
L08 N07 N08 1.70e-12
R08 N07 N08 2.28e-02
C09 N08 N09 2.26e-07
L09 N08 N09 3.97e-11
R09 N08 N09 3.33e-02
C10 N09 N10 4.73e-08
L10 N09 N10 6.30e-11
R10 N09 N10 5.78e-02
C11 N10 N11 2.26e-08
L11 N10 N11 6.59e-13
R11 N10 N11 1.32e-01
C12 N11 Port2 4.22e-12
L12 N11 Port2 3.08e-10
R12 N11 Port2 2.83e+01
.ENDS GRJ31CR72E473KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GRJ31CR72J153KWJ3
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72J153KWJ3 Port1 Port2
C01 Port1 N01 1.46e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.67e-10
R03 N02 N03 5.07e-02
C04 N03 N04 9.72e-07
R04 N03 N04 1.64e+00
C05 N04 N05 1.47e-06
R05 N04 N05 2.26e-01
C06 N05 N06 1.02e-06
R06 N05 N06 6.23e-02
C07 N06 N07 8.86e-07
R07 N06 N07 1.80e-02
L08 N07 N08 1.64e-10
R08 N07 N08 4.30e-01
C09 N08 N09 1.28e-07
L09 N08 N09 1.85e-11
R09 N08 N09 5.26e-02
C10 N09 N10 1.22e-08
L10 N09 N10 7.73e-11
R10 N09 N10 1.20e-01
C11 N10 Port2 1.04e-11
L11 N10 Port2 1.81e-10
R11 N10 Port2 1.52e+01
.ENDS GRJ31CR72J153KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GRJ31CR72J223KWJ3
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72J223KWJ3 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 4.41e-10
R03 N02 N03 3.92e-02
C04 N03 N04 1.00e-06
R04 N03 N04 3.99e+00
C05 N04 N05 1.55e-06
R05 N04 N05 1.91e-01
C06 N05 N06 7.78e-07
R06 N05 N06 3.40e-02
L07 N06 N07 1.87e-10
R07 N06 N07 2.76e-01
L08 N07 N08 3.04e-11
R08 N07 N08 1.62e-01
C09 N08 N09 1.15e-07
L09 N08 N09 3.58e-11
R09 N08 N09 6.12e-02
C10 N09 N10 2.57e-08
L10 N09 N10 6.37e-11
R10 N09 N10 9.93e-02
C11 N10 Port2 7.76e-12
L11 N10 Port2 1.60e-10
R11 N10 Port2 1.44e+01
.ENDS GRJ31CR72J223KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/1000[V]
* Murata P/N :GRJ31CR73A103KWJ3
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR73A103KWJ3 Port1 Port2
C01 Port1 N01 9.92e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.76e-10
R03 N02 N03 5.80e-02
C04 N03 N04 4.51e-07
R04 N03 N04 5.60e+00
C05 N04 N05 7.14e-07
R05 N04 N05 3.01e-01
C06 N05 N06 5.94e-07
R06 N05 N06 4.45e-02
C07 N06 N07 3.18e-07
R07 N06 N07 1.99e-02
L08 N07 N08 1.45e-10
R08 N07 N08 2.95e-01
C09 N08 N09 3.99e-08
L09 N08 N09 4.51e-11
R09 N08 N09 1.11e-01
C10 N09 N10 1.18e-08
L10 N09 N10 6.08e-11
R10 N09 N10 1.47e-01
C11 N10 Port2 5.63e-12
L11 N10 Port2 1.92e-10
R11 N10 Port2 1.65e+01
.ENDS GRJ31CR73A103KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/1000[V]
* Murata P/N :GRJ31CR73A682KWJ3
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR73A682KWJ3 Port1 Port2
C01 Port1 N01 6.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 8.09e-02
C04 N03 N04 3.05e-07
R04 N03 N04 8.26e+00
C05 N04 N05 7.85e-07
R05 N04 N05 3.77e-01
C06 N05 N06 5.56e-07
R06 N05 N06 1.43e-01
C07 N06 N07 2.60e-07
R07 N06 N07 4.86e-02
L08 N07 N08 9.18e-11
R08 N07 N08 3.02e-01
C09 N08 N09 3.51e-08
L09 N08 N09 2.94e-11
R09 N08 N09 7.27e-02
C10 N09 N10 1.11e-08
L10 N09 N10 3.38e-11
R10 N09 N10 1.35e-01
C11 N10 Port2 7.01e-12
L11 N10 Port2 2.94e-10
R11 N10 Port2 2.58e+01
.ENDS GRJ31CR73A682KWJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ31CZ72A475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CZ72A475KE01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.05e-11
R03 N02 N03 8.01e-03
C04 N03 N04 3.70e-04
R04 N03 N04 1.43e+01
C05 N04 N05 4.47e-04
R05 N04 N05 1.41e+00
C06 N05 N06 3.64e-04
R06 N05 N06 2.06e-01
C07 N06 N07 3.43e-04
R07 N06 N07 2.16e-02
C08 N07 N08 2.47e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.90e-11
R09 N08 N09 5.93e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.60e-02
L11 N10 N11 4.23e-10
R11 N10 N11 2.36e-02
C12 N11 N12 1.10e-05
L12 N11 N12 1.10e-10
R12 N11 N12 9.95e-03
C13 N12 N13 7.92e-06
L13 N12 N13 6.98e-11
R13 N12 N13 8.94e-03
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.56e-10
R14 N13 Port2 1.06e+02
.ENDS GRJ31CZ72A475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ31CZ72A475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CZ72A475ME01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.05e-11
R03 N02 N03 8.01e-03
C04 N03 N04 3.70e-04
R04 N03 N04 1.43e+01
C05 N04 N05 4.47e-04
R05 N04 N05 1.41e+00
C06 N05 N06 3.64e-04
R06 N05 N06 2.06e-01
C07 N06 N07 3.43e-04
R07 N06 N07 2.16e-02
C08 N07 N08 2.47e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.90e-11
R09 N08 N09 5.93e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.60e-02
L11 N10 N11 4.23e-10
R11 N10 N11 2.36e-02
C12 N11 N12 1.10e-05
L12 N11 N12 1.10e-10
R12 N11 N12 9.95e-03
C13 N12 N13 7.92e-06
L13 N12 N13 6.98e-11
R13 N12 N13 8.94e-03
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.56e-10
R14 N13 Port2 1.06e+02
.ENDS GRJ31CZ72A475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRJ31MR71C225KE11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71C225KE11 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.43e-10
R03 N02 N03 1.86e-02
C04 N03 N04 2.36e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.30e+00
C06 N05 N06 3.14e-04
R06 N05 N06 2.86e-01
C07 N06 N07 2.32e-04
R07 N06 N07 5.76e-02
C08 N07 N08 2.07e-04
R08 N07 N08 8.18e-03
L09 N08 N09 5.71e-11
R09 N08 N09 7.48e-02
L10 N09 N10 3.60e-10
R10 N09 N10 3.35e-02
C11 N10 N11 6.41e-06
L11 N10 N11 8.29e-11
R11 N10 N11 8.29e-03
C12 N11 N12 4.10e-06
L12 N11 N12 5.91e-11
R12 N11 N12 1.05e-02
C13 N12 N13 1.58e-11
L13 N12 N13 7.52e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 1.83e-12
L14 N13 Port2 2.35e-10
R14 N13 Port2 1.02e+02
.ENDS GRJ31MR71C225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRJ31MR71C225ME11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71C225ME11 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.43e-10
R03 N02 N03 1.86e-02
C04 N03 N04 2.36e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.30e+00
C06 N05 N06 3.14e-04
R06 N05 N06 2.86e-01
C07 N06 N07 2.32e-04
R07 N06 N07 5.76e-02
C08 N07 N08 2.07e-04
R08 N07 N08 8.18e-03
L09 N08 N09 5.71e-11
R09 N08 N09 7.48e-02
L10 N09 N10 3.60e-10
R10 N09 N10 3.35e-02
C11 N10 N11 6.41e-06
L11 N10 N11 8.29e-11
R11 N10 N11 8.29e-03
C12 N11 N12 4.10e-06
L12 N11 N12 5.91e-11
R12 N11 N12 1.05e-02
C13 N12 N13 1.58e-11
L13 N12 N13 7.52e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 1.83e-12
L14 N13 Port2 2.35e-10
R14 N13 Port2 1.02e+02
.ENDS GRJ31MR71C225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRJ31MR71E225KE11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71E225KE11 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.43e-10
R03 N02 N03 1.86e-02
C04 N03 N04 2.36e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.30e+00
C06 N05 N06 3.14e-04
R06 N05 N06 2.86e-01
C07 N06 N07 2.32e-04
R07 N06 N07 5.76e-02
C08 N07 N08 2.07e-04
R08 N07 N08 8.18e-03
L09 N08 N09 5.71e-11
R09 N08 N09 7.48e-02
L10 N09 N10 3.60e-10
R10 N09 N10 3.35e-02
C11 N10 N11 6.41e-06
L11 N10 N11 8.29e-11
R11 N10 N11 8.29e-03
C12 N11 N12 4.10e-06
L12 N11 N12 5.91e-11
R12 N11 N12 1.05e-02
C13 N12 N13 1.58e-11
L13 N12 N13 7.52e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 1.83e-12
L14 N13 Port2 2.35e-10
R14 N13 Port2 1.02e+02
.ENDS GRJ31MR71E225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRJ31MR71E225ME11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71E225ME11 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.43e-10
R03 N02 N03 1.86e-02
C04 N03 N04 2.36e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.30e+00
C06 N05 N06 3.14e-04
R06 N05 N06 2.86e-01
C07 N06 N07 2.32e-04
R07 N06 N07 5.76e-02
C08 N07 N08 2.07e-04
R08 N07 N08 8.18e-03
L09 N08 N09 5.71e-11
R09 N08 N09 7.48e-02
L10 N09 N10 3.60e-10
R10 N09 N10 3.35e-02
C11 N10 N11 6.41e-06
L11 N10 N11 8.29e-11
R11 N10 N11 8.29e-03
C12 N11 N12 4.10e-06
L12 N11 N12 5.91e-11
R12 N11 N12 1.05e-02
C13 N12 N13 1.58e-11
L13 N12 N13 7.52e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 1.83e-12
L14 N13 Port2 2.35e-10
R14 N13 Port2 1.02e+02
.ENDS GRJ31MR71E225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H104KE01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GRJ31MR71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H104ME01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H104ME01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GRJ31MR71H104ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31MR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H105KE01 Port1 Port2
C01 Port1 N01 9.69e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 7.20e-11
R03 N02 N03 3.11e-02
C04 N03 N04 7.86e-05
R04 N03 N04 2.43e+01
C05 N04 N05 2.35e-04
R05 N04 N05 2.29e+00
C06 N05 N06 1.15e-04
R06 N05 N06 5.65e-01
C07 N06 N07 1.15e-04
R07 N06 N07 5.89e-02
C08 N07 N08 9.69e-05
R08 N07 N08 1.67e-02
L09 N08 N09 3.87e-11
R09 N08 N09 7.92e-02
L10 N09 N10 2.94e-10
R10 N09 N10 4.83e-02
C11 N10 N11 3.14e-06
L11 N10 N11 6.46e-11
R11 N10 N11 1.19e-02
C12 N11 N12 1.45e-06
L12 N11 N12 5.52e-11
R12 N11 N12 1.43e-02
C13 N12 N13 8.71e-12
L13 N12 N13 1.06e-10
R13 N12 N13 8.01e+00
C14 N13 Port2 8.56e-13
L14 N13 Port2 3.49e-10
R14 N13 Port2 1.34e+02
.ENDS GRJ31MR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31MR71H105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H105ME01 Port1 Port2
C01 Port1 N01 9.69e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 7.20e-11
R03 N02 N03 3.11e-02
C04 N03 N04 7.86e-05
R04 N03 N04 2.43e+01
C05 N04 N05 2.35e-04
R05 N04 N05 2.29e+00
C06 N05 N06 1.15e-04
R06 N05 N06 5.65e-01
C07 N06 N07 1.15e-04
R07 N06 N07 5.89e-02
C08 N07 N08 9.69e-05
R08 N07 N08 1.67e-02
L09 N08 N09 3.87e-11
R09 N08 N09 7.92e-02
L10 N09 N10 2.94e-10
R10 N09 N10 4.83e-02
C11 N10 N11 3.14e-06
L11 N10 N11 6.46e-11
R11 N10 N11 1.19e-02
C12 N11 N12 1.45e-06
L12 N11 N12 5.52e-11
R12 N11 N12 1.43e-02
C13 N12 N13 8.71e-12
L13 N12 N13 1.06e-10
R13 N12 N13 8.01e+00
C14 N13 Port2 8.56e-13
L14 N13 Port2 3.49e-10
R14 N13 Port2 1.34e+02
.ENDS GRJ31MR71H105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H224KE01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GRJ31MR71H224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H224ME01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GRJ31MR71H224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H474KE01 Port1 Port2
C01 Port1 N01 4.42e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 4.95e-11
R03 N02 N03 3.94e-02
C04 N03 N04 2.97e-05
R04 N03 N04 7.23e-02
C05 N04 N05 6.38e-05
R05 N04 N05 2.58e-03
L06 N05 N06 3.06e-11
R06 N05 N06 7.71e-02
L07 N06 N07 2.60e-10
R07 N06 N07 6.20e-02
C08 N07 N08 1.41e-06
L08 N07 N08 6.08e-11
R08 N07 N08 2.06e-02
C09 N08 N09 8.32e-07
L09 N08 N09 4.17e-11
R09 N08 N09 2.18e-02
C10 N09 N10 9.54e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.12e+01
C11 N10 Port2 1.43e-12
L11 N10 Port2 3.30e-10
R11 N10 Port2 1.45e+02
.ENDS GRJ31MR71H474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H474ME01 Port1 Port2
C01 Port1 N01 4.42e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 4.95e-11
R03 N02 N03 3.94e-02
C04 N03 N04 2.97e-05
R04 N03 N04 7.23e-02
C05 N04 N05 6.38e-05
R05 N04 N05 2.58e-03
L06 N05 N06 3.06e-11
R06 N05 N06 7.71e-02
L07 N06 N07 2.60e-10
R07 N06 N07 6.20e-02
C08 N07 N08 1.41e-06
L08 N07 N08 6.08e-11
R08 N07 N08 2.06e-02
C09 N08 N09 8.32e-07
L09 N08 N09 4.17e-11
R09 N08 N09 2.18e-02
C10 N09 N10 9.54e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.12e+01
C11 N10 Port2 1.43e-12
L11 N10 Port2 3.30e-10
R11 N10 Port2 1.45e+02
.ENDS GRJ31MR71H474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GRJ31MR72A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR72A224KE01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GRJ31MR72A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GRJ31MR72A224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR72A224ME01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GRJ31MR72A224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ32DC72A475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DC72A475KE11 Port1 Port2
C01 Port1 N01 4.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.37e-11
R03 N02 N03 3.45e-03
C04 N03 N04 5.12e-04
R04 N03 N04 4.87e+00
C05 N04 N05 4.73e-04
R05 N04 N05 5.59e-01
C06 N05 N06 3.88e-04
R06 N05 N06 1.07e-01
C07 N06 N07 3.31e-04
R07 N06 N07 1.06e-02
C08 N07 N08 2.79e-04
R08 N07 N08 7.95e-04
L09 N08 N09 1.03e-11
R09 N08 N09 4.42e-02
L10 N09 N10 4.47e-11
R10 N09 N10 3.61e-02
L11 N10 N11 3.77e-10
R11 N10 N11 2.44e-02
C12 N11 N12 1.02e-05
L12 N11 N12 1.06e-10
R12 N11 N12 1.27e-02
C13 N12 N13 6.47e-06
L13 N12 N13 6.72e-11
R13 N12 N13 9.93e-03
C14 N13 N14 3.24e-11
L14 N13 N14 5.15e-11
R14 N13 N14 4.06e+00
C15 N14 Port2 1.49e-12
L15 N14 Port2 2.65e-10
R15 N14 Port2 1.19e+02
.ENDS GRJ32DC72A475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ32DC72A475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DC72A475ME11 Port1 Port2
C01 Port1 N01 4.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.37e-11
R03 N02 N03 3.45e-03
C04 N03 N04 5.12e-04
R04 N03 N04 4.87e+00
C05 N04 N05 4.73e-04
R05 N04 N05 5.59e-01
C06 N05 N06 3.88e-04
R06 N05 N06 1.07e-01
C07 N06 N07 3.31e-04
R07 N06 N07 1.06e-02
C08 N07 N08 2.79e-04
R08 N07 N08 7.95e-04
L09 N08 N09 1.03e-11
R09 N08 N09 4.42e-02
L10 N09 N10 4.47e-11
R10 N09 N10 3.61e-02
L11 N10 N11 3.77e-10
R11 N10 N11 2.44e-02
C12 N11 N12 1.02e-05
L12 N11 N12 1.06e-10
R12 N11 N12 1.27e-02
C13 N12 N13 6.47e-06
L13 N12 N13 6.72e-11
R13 N12 N13 9.93e-03
C14 N13 N14 3.24e-11
L14 N13 N14 5.15e-11
R14 N13 N14 4.06e+00
C15 N14 Port2 1.49e-12
L15 N14 Port2 2.65e-10
R15 N14 Port2 1.19e+02
.ENDS GRJ32DC72A475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GRJ32DR72A225KE11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72A225KE11 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.64e-11
R03 N02 N03 8.32e-03
C04 N03 N04 3.05e-04
R04 N03 N04 3.43e+00
C05 N04 N05 3.42e-04
R05 N04 N05 3.39e-01
C06 N05 N06 3.28e-04
R06 N05 N06 5.08e-02
C07 N06 N07 3.15e-04
R07 N06 N07 1.13e-02
C08 N07 N08 2.66e-04
R08 N07 N08 1.73e-03
L09 N08 N09 3.40e-11
R09 N08 N09 5.09e-02
L10 N09 N10 2.94e-10
R10 N09 N10 3.38e-02
C11 N10 N11 5.09e-06
L11 N10 N11 9.08e-11
R11 N10 N11 2.04e-02
C12 N11 N12 2.30e-06
L12 N11 N12 6.51e-11
R12 N11 N12 1.57e-02
C13 N12 N13 2.11e-11
L13 N12 N13 8.26e-11
R13 N12 N13 7.98e+00
C14 N13 Port2 2.18e-12
L14 N13 Port2 2.43e-10
R14 N13 Port2 6.55e+01
.ENDS GRJ32DR72A225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GRJ32DR72A225ME11
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72A225ME11 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.64e-11
R03 N02 N03 8.32e-03
C04 N03 N04 3.05e-04
R04 N03 N04 3.43e+00
C05 N04 N05 3.42e-04
R05 N04 N05 3.39e-01
C06 N05 N06 3.28e-04
R06 N05 N06 5.08e-02
C07 N06 N07 3.15e-04
R07 N06 N07 1.13e-02
C08 N07 N08 2.66e-04
R08 N07 N08 1.73e-03
L09 N08 N09 3.40e-11
R09 N08 N09 5.09e-02
L10 N09 N10 2.94e-10
R10 N09 N10 3.38e-02
C11 N10 N11 5.09e-06
L11 N10 N11 9.08e-11
R11 N10 N11 2.04e-02
C12 N11 N12 2.30e-06
L12 N11 N12 6.51e-11
R12 N11 N12 1.57e-02
C13 N12 N13 2.11e-11
L13 N12 N13 8.26e-11
R13 N12 N13 7.98e+00
C14 N13 Port2 2.18e-12
L14 N13 Port2 2.43e-10
R14 N13 Port2 6.55e+01
.ENDS GRJ32DR72A225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-01[uF]/250[V]
* Murata P/N :GRJ32DR72E104KWJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72E104KWJ1 Port1 Port2
C01 Port1 N01 1.01e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 2.81e-10
R03 N02 N03 1.99e-02
C04 N03 N04 8.32e-06
R04 N03 N04 1.91e-01
C05 N04 N05 1.51e-05
R05 N04 N05 2.10e-02
C06 N05 N06 1.29e-05
R06 N05 N06 9.81e-03
L07 N06 N07 2.10e-11
R07 N06 N07 1.12e-01
L08 N07 N08 1.39e-10
R08 N07 N08 7.42e-02
C09 N08 N09 4.10e-07
L09 N08 N09 3.65e-11
R09 N08 N09 3.76e-02
C10 N09 N10 8.96e-08
L10 N09 N10 5.52e-11
R10 N09 N10 3.93e-02
C11 N10 Port2 7.63e-12
L11 N10 Port2 2.70e-10
R11 N10 Port2 2.78e+01
.ENDS GRJ32DR72E104KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GRJ32DR72E224KWJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72E224KWJ1 Port1 Port2
C01 Port1 N01 2.21e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.49e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.67e-05
R04 N03 N04 9.50e-02
C05 N04 N05 2.59e-05
R05 N04 N05 9.72e-03
C06 N05 N06 8.99e-05
R06 N05 N06 1.77e-03
L07 N06 N07 3.11e-11
R07 N06 N07 1.78e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.60e-02
C09 N08 N09 5.31e-07
L09 N08 N09 7.07e-11
R09 N08 N09 4.92e-02
C10 N09 N10 2.60e-07
L10 N09 N10 5.24e-11
R10 N09 N10 4.49e-02
C11 N10 Port2 7.67e-12
L11 N10 Port2 1.86e-10
R11 N10 Port2 2.52e+01
.ENDS GRJ32DR72E224KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :GRJ32DR72J333KWJ1
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72J333KWJ1 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 2.93e-10
R03 N02 N03 2.89e-02
C04 N03 N04 2.14e-06
R04 N03 N04 7.43e-01
C05 N04 N05 3.03e-06
R05 N04 N05 6.18e-02
C06 N05 N06 2.70e-06
R06 N05 N06 2.05e-02
L07 N06 N07 9.53e-11
R07 N06 N07 1.22e-01
C08 N07 N08 8.39e-08
L08 N07 N08 5.38e-11
R08 N07 N08 1.03e-01
C09 N08 N09 3.05e-08
L09 N08 N09 5.13e-11
R09 N08 N09 1.18e-01
C10 N09 Port2 6.97e-12
L10 N09 Port2 2.82e-10
R10 N09 Port2 2.68e+01
.ENDS GRJ32DR72J333KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GRJ32DR72J473KWJ1
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72J473KWJ1 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 2.08e-10
R03 N02 N03 2.23e-02
C04 N03 N04 3.44e-06
R04 N03 N04 4.63e-01
C05 N04 N05 6.85e-06
R05 N04 N05 4.63e-02
C06 N05 N06 2.73e-06
R06 N05 N06 2.67e-02
L07 N06 N07 1.35e-10
R07 N06 N07 1.73e-01
C08 N07 N08 1.12e-07
L08 N07 N08 7.03e-11
R08 N07 N08 1.12e-01
C09 N08 N09 3.87e-08
L09 N08 N09 7.36e-11
R09 N08 N09 1.07e-01
C10 N09 Port2 5.99e-12
L10 N09 Port2 1.89e-10
R10 N09 Port2 1.66e+01
.ENDS GRJ32DR72J473KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-02[uF]/1000[V]
* Murata P/N :GRJ32DR73A153KWJ1
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR73A153KWJ1 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 2.50e-10
R03 N02 N03 4.00e-02
C04 N03 N04 9.35e-07
R04 N03 N04 1.70e+00
C05 N04 N05 1.48e-06
R05 N04 N05 2.14e-01
C06 N05 N06 1.29e-06
R06 N05 N06 6.18e-02
C07 N06 N07 3.90e-07
R07 N06 N07 2.76e-02
L08 N07 N08 1.26e-10
R08 N07 N08 3.37e-01
C09 N08 N09 4.08e-08
L09 N08 N09 4.01e-11
R09 N08 N09 1.01e-01
C10 N09 N10 1.32e-08
L10 N09 N10 4.10e-11
R10 N09 N10 1.16e-01
C11 N10 Port2 6.62e-12
L11 N10 Port2 3.41e-10
R11 N10 Port2 3.06e+01
.ENDS GRJ32DR73A153KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/1000[V]
* Murata P/N :GRJ32DR73A223KWJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR73A223KWJ1 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.85e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.31e-06
R04 N03 N04 1.21e+00
C05 N04 N05 1.85e-06
R05 N04 N05 8.58e-02
C06 N05 N06 3.15e-06
R06 N05 N06 2.91e-02
C07 N06 N07 2.50e-07
R07 N06 N07 2.53e-02
L08 N07 N08 1.85e-10
R08 N07 N08 1.80e-01
L09 N08 N09 2.55e-11
R09 N08 N09 1.39e-01
C10 N09 N10 4.52e-08
L10 N09 N10 7.24e-11
R10 N09 N10 1.59e-01
C11 N10 N11 2.98e-08
L11 N10 N11 3.98e-11
R11 N10 N11 1.30e-01
C12 N11 Port2 4.12e-12
L12 N11 Port2 2.75e-10
R12 N11 Port2 3.49e+01
.ENDS GRJ32DR73A223KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRJ32EC71E226KE11
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32EC71E226KE11 Port1 Port2
C01 Port1 N01 2.07e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 8.06e-11
R03 N02 N03 5.23e-03
C04 N03 N04 2.75e-03
R04 N03 N04 1.85e+00
C05 N04 N05 3.66e-03
R05 N04 N05 1.37e-01
C06 N05 N06 3.22e-03
R06 N05 N06 1.48e-02
C07 N06 N07 1.10e-02
R07 N06 N07 1.20e-02
C08 N07 N08 3.66e-03
R08 N07 N08 1.70e-03
L09 N08 N09 2.48e-11
R09 N08 N09 4.57e-02
L10 N09 N10 5.80e-11
R10 N09 N10 1.34e-02
L11 N10 N11 5.88e-10
R11 N10 N11 1.32e-02
C12 N11 N12 4.88e-05
L12 N11 N12 1.40e-10
R12 N11 N12 5.13e-03
C13 N12 N13 4.79e-05
L13 N12 N13 5.75e-11
R13 N12 N13 3.14e-03
C14 N13 N14 4.19e-11
L14 N13 N14 3.10e-11
R14 N13 N14 2.24e+00
C15 N14 Port2 1.77e-12
L15 N14 Port2 1.56e-10
R15 N14 Port2 4.75e+01
.ENDS GRJ32EC71E226KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRJ32EC71H106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32EC71H106KE11 Port1 Port2
C01 Port1 N01 9.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.75e-11
R03 N02 N03 6.36e-03
C04 N03 N04 2.11e-03
R04 N03 N04 1.30e+00
C05 N04 N05 1.82e-03
R05 N04 N05 2.05e-01
C06 N05 N06 1.36e-03
R06 N05 N06 3.51e-02
C07 N06 N07 1.86e-03
R07 N06 N07 2.44e-03
L08 N07 N08 1.37e-11
R08 N07 N08 6.00e-02
L09 N08 N09 7.76e-11
R09 N08 N09 3.76e-02
L10 N09 N10 5.46e-10
R10 N09 N10 1.90e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.54e-03
C12 N11 N12 2.05e-05
L12 N11 N12 6.70e-11
R12 N11 N12 6.31e-03
C13 N12 N13 3.36e-11
L13 N12 N13 4.44e-11
R13 N12 N13 2.71e+00
C14 N13 Port2 2.07e-12
L14 N13 Port2 1.91e-10
R14 N13 Port2 1.08e+02
.ENDS GRJ32EC71H106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRJ32EC71H106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32EC71H106ME11 Port1 Port2
C01 Port1 N01 9.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.75e-11
R03 N02 N03 6.36e-03
C04 N03 N04 2.11e-03
R04 N03 N04 1.30e+00
C05 N04 N05 1.82e-03
R05 N04 N05 2.05e-01
C06 N05 N06 1.36e-03
R06 N05 N06 3.51e-02
C07 N06 N07 1.86e-03
R07 N06 N07 2.44e-03
L08 N07 N08 1.37e-11
R08 N07 N08 6.00e-02
L09 N08 N09 7.76e-11
R09 N08 N09 3.76e-02
L10 N09 N10 5.46e-10
R10 N09 N10 1.90e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.54e-03
C12 N11 N12 2.05e-05
L12 N11 N12 6.70e-11
R12 N11 N12 6.31e-03
C13 N12 N13 3.36e-11
L13 N12 N13 4.44e-11
R13 N12 N13 2.71e+00
C14 N13 Port2 2.07e-12
L14 N13 Port2 1.91e-10
R14 N13 Port2 1.08e+02
.ENDS GRJ32EC71H106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRJ32ER70J476KE11
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER70J476KE11 Port1 Port2
C01 Port1 N01 3.44e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 7.49e-11
R03 N02 N03 3.07e-03
C04 N03 N04 8.65e-04
R04 N03 N04 6.13e+00
C05 N04 N05 1.13e-03
R05 N04 N05 3.92e-01
C06 N05 N06 1.22e-03
R06 N05 N06 4.75e-02
C07 N06 N07 8.85e-04
R07 N06 N07 1.03e-02
C08 N07 N08 6.40e-04
R08 N07 N08 9.74e-04
L09 N08 N09 1.17e-11
R09 N08 N09 2.72e-02
L10 N09 N10 8.77e-11
R10 N09 N10 2.68e-02
L11 N10 N11 5.85e-10
R11 N10 N11 1.09e-02
C12 N11 N12 7.35e-05
L12 N11 N12 1.58e-10
R12 N11 N12 3.61e-03
C13 N12 N13 6.25e-05
L13 N12 N13 8.23e-11
R13 N12 N13 3.41e-03
C14 N13 N14 3.95e-11
L14 N13 N14 6.92e-11
R14 N13 N14 4.45e+00
C15 N14 Port2 1.92e-12
L15 N14 Port2 2.89e-10
R15 N14 Port2 6.06e+01
.ENDS GRJ32ER70J476KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRJ32ER70J476ME11
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER70J476ME11 Port1 Port2
C01 Port1 N01 3.44e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 7.49e-11
R03 N02 N03 3.07e-03
C04 N03 N04 8.65e-04
R04 N03 N04 6.13e+00
C05 N04 N05 1.13e-03
R05 N04 N05 3.92e-01
C06 N05 N06 1.22e-03
R06 N05 N06 4.75e-02
C07 N06 N07 8.85e-04
R07 N06 N07 1.03e-02
C08 N07 N08 6.40e-04
R08 N07 N08 9.74e-04
L09 N08 N09 1.17e-11
R09 N08 N09 2.72e-02
L10 N09 N10 8.77e-11
R10 N09 N10 2.68e-02
L11 N10 N11 5.85e-10
R11 N10 N11 1.09e-02
C12 N11 N12 7.35e-05
L12 N11 N12 1.58e-10
R12 N11 N12 3.61e-03
C13 N12 N13 6.25e-05
L13 N12 N13 8.23e-11
R13 N12 N13 3.41e-03
C14 N13 N14 3.95e-11
L14 N13 N14 6.92e-11
R14 N13 N14 4.45e+00
C15 N14 Port2 1.92e-12
L15 N14 Port2 2.89e-10
R15 N14 Port2 6.06e+01
.ENDS GRJ32ER70J476ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A226KE11
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A226KE11 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.15e-11
R03 N02 N03 5.15e-03
C04 N03 N04 4.79e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.94e-04
R05 N04 N05 1.16e+00
C06 N05 N06 4.48e-04
R06 N05 N06 1.20e-01
C07 N06 N07 5.23e-04
R07 N06 N07 9.95e-03
C08 N07 N08 4.39e-04
R08 N07 N08 4.55e-03
L09 N08 N09 6.43e-11
R09 N08 N09 4.02e-02
L10 N09 N10 5.67e-10
R10 N09 N10 1.40e-02
C11 N10 N11 5.83e-05
L11 N10 N11 8.44e-11
R11 N10 N11 5.31e-03
C12 N11 N12 3.65e-05
L12 N11 N12 6.07e-11
R12 N11 N12 3.69e-03
C13 N12 N13 5.16e-11
L13 N12 N13 5.20e-11
R13 N12 N13 2.82e+00
C14 N13 N14 1.50e-11
L14 N13 N14 6.76e-11
R14 N13 N14 3.94e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 1.11e+02
.ENDS GRJ32ER71A226KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A226ME11
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A226ME11 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.15e-11
R03 N02 N03 5.15e-03
C04 N03 N04 4.79e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.94e-04
R05 N04 N05 1.16e+00
C06 N05 N06 4.48e-04
R06 N05 N06 1.20e-01
C07 N06 N07 5.23e-04
R07 N06 N07 9.95e-03
C08 N07 N08 4.39e-04
R08 N07 N08 4.55e-03
L09 N08 N09 6.43e-11
R09 N08 N09 4.02e-02
L10 N09 N10 5.67e-10
R10 N09 N10 1.40e-02
C11 N10 N11 5.83e-05
L11 N10 N11 8.44e-11
R11 N10 N11 5.31e-03
C12 N11 N12 3.65e-05
L12 N11 N12 6.07e-11
R12 N11 N12 3.69e-03
C13 N12 N13 5.16e-11
L13 N12 N13 5.20e-11
R13 N12 N13 2.82e+00
C14 N13 N14 1.50e-11
L14 N13 N14 6.76e-11
R14 N13 N14 3.94e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 1.11e+02
.ENDS GRJ32ER71A226ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A476KE11
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A476KE11 Port1 Port2
C01 Port1 N01 3.34e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.25e-11
R03 N02 N03 3.84e-03
C04 N03 N04 6.81e-04
R04 N03 N04 1.56e+01
C05 N04 N05 1.35e-03
R05 N04 N05 1.12e+00
C06 N05 N06 1.49e-03
R06 N05 N06 1.96e-01
C07 N06 N07 1.09e-03
R07 N06 N07 4.25e-02
C08 N07 N08 7.31e-04
R08 N07 N08 6.37e-03
L09 N08 N09 1.19e-11
R09 N08 N09 2.91e-02
L10 N09 N10 9.30e-11
R10 N09 N10 2.57e-02
L11 N10 N11 5.70e-10
R11 N10 N11 1.04e-02
C12 N11 N12 9.46e-05
L12 N11 N12 1.17e-10
R12 N11 N12 2.89e-03
C13 N12 N13 8.32e-05
L13 N12 N13 5.99e-11
R13 N12 N13 2.43e-03
C14 N13 N14 5.42e-11
L14 N13 N14 5.73e-11
R14 N13 N14 4.44e+00
C15 N14 N15 1.41e-11
L15 N14 N15 7.20e-11
R15 N14 N15 8.84e+00
C16 N15 Port2 1.78e-12
L16 N15 Port2 2.90e-10
R16 N15 Port2 7.09e+01
.ENDS GRJ32ER71A476KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A476ME11
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A476ME11 Port1 Port2
C01 Port1 N01 3.34e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.25e-11
R03 N02 N03 3.84e-03
C04 N03 N04 6.81e-04
R04 N03 N04 1.56e+01
C05 N04 N05 1.35e-03
R05 N04 N05 1.12e+00
C06 N05 N06 1.49e-03
R06 N05 N06 1.96e-01
C07 N06 N07 1.09e-03
R07 N06 N07 4.25e-02
C08 N07 N08 7.31e-04
R08 N07 N08 6.37e-03
L09 N08 N09 1.19e-11
R09 N08 N09 2.91e-02
L10 N09 N10 9.30e-11
R10 N09 N10 2.57e-02
L11 N10 N11 5.70e-10
R11 N10 N11 1.04e-02
C12 N11 N12 9.46e-05
L12 N11 N12 1.17e-10
R12 N11 N12 2.89e-03
C13 N12 N13 8.32e-05
L13 N12 N13 5.99e-11
R13 N12 N13 2.43e-03
C14 N13 N14 5.42e-11
L14 N13 N14 5.73e-11
R14 N13 N14 4.44e+00
C15 N14 N15 1.41e-11
L15 N14 N15 7.20e-11
R15 N14 N15 8.84e+00
C16 N15 Port2 1.78e-12
L16 N15 Port2 2.90e-10
R16 N15 Port2 7.09e+01
.ENDS GRJ32ER71A476ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRJ32ER71C226KE11
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71C226KE11 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.15e-11
R03 N02 N03 5.15e-03
C04 N03 N04 4.79e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.94e-04
R05 N04 N05 1.16e+00
C06 N05 N06 4.48e-04
R06 N05 N06 1.20e-01
C07 N06 N07 5.23e-04
R07 N06 N07 9.95e-03
C08 N07 N08 4.39e-04
R08 N07 N08 4.55e-03
L09 N08 N09 6.43e-11
R09 N08 N09 4.02e-02
L10 N09 N10 5.67e-10
R10 N09 N10 1.40e-02
C11 N10 N11 5.83e-05
L11 N10 N11 8.44e-11
R11 N10 N11 5.31e-03
C12 N11 N12 3.65e-05
L12 N11 N12 6.07e-11
R12 N11 N12 3.69e-03
C13 N12 N13 5.16e-11
L13 N12 N13 5.20e-11
R13 N12 N13 2.82e+00
C14 N13 N14 1.50e-11
L14 N13 N14 6.76e-11
R14 N13 N14 3.94e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 1.11e+02
.ENDS GRJ32ER71C226KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRJ32ER71C226ME11
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71C226ME11 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.15e-11
R03 N02 N03 5.15e-03
C04 N03 N04 4.79e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.94e-04
R05 N04 N05 1.16e+00
C06 N05 N06 4.48e-04
R06 N05 N06 1.20e-01
C07 N06 N07 5.23e-04
R07 N06 N07 9.95e-03
C08 N07 N08 4.39e-04
R08 N07 N08 4.55e-03
L09 N08 N09 6.43e-11
R09 N08 N09 4.02e-02
L10 N09 N10 5.67e-10
R10 N09 N10 1.40e-02
C11 N10 N11 5.83e-05
L11 N10 N11 8.44e-11
R11 N10 N11 5.31e-03
C12 N11 N12 3.65e-05
L12 N11 N12 6.07e-11
R12 N11 N12 3.69e-03
C13 N12 N13 5.16e-11
L13 N12 N13 5.20e-11
R13 N12 N13 2.82e+00
C14 N13 N14 1.50e-11
L14 N13 N14 6.76e-11
R14 N13 N14 3.94e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 1.11e+02
.ENDS GRJ32ER71C226ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ32ER71E106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71E106KE11 Port1 Port2
C01 Port1 N01 9.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.87e-11
R03 N02 N03 3.25e-03
C04 N03 N04 1.22e-03
R04 N03 N04 1.79e+00
C05 N04 N05 1.35e-03
R05 N04 N05 1.83e-01
C06 N05 N06 1.11e-03
R06 N05 N06 3.13e-02
C07 N06 N07 8.78e-04
R07 N06 N07 3.13e-03
L08 N07 N08 1.61e-11
R08 N07 N08 4.44e-02
L09 N08 N09 5.40e-11
R09 N08 N09 3.00e-02
L10 N09 N10 5.98e-10
R10 N09 N10 2.26e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.24e-10
R11 N10 N11 9.33e-03
C12 N11 N12 2.01e-05
L12 N11 N12 6.07e-11
R12 N11 N12 6.27e-03
C13 N12 N13 1.71e-11
L13 N12 N13 5.55e-11
R13 N12 N13 4.44e+00
C14 N13 Port2 2.86e-12
L14 N13 Port2 1.31e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ32ER71E106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ32ER71E106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71E106ME11 Port1 Port2
C01 Port1 N01 9.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.87e-11
R03 N02 N03 3.25e-03
C04 N03 N04 1.22e-03
R04 N03 N04 1.79e+00
C05 N04 N05 1.35e-03
R05 N04 N05 1.83e-01
C06 N05 N06 1.11e-03
R06 N05 N06 3.13e-02
C07 N06 N07 8.78e-04
R07 N06 N07 3.13e-03
L08 N07 N08 1.61e-11
R08 N07 N08 4.44e-02
L09 N08 N09 5.40e-11
R09 N08 N09 3.00e-02
L10 N09 N10 5.98e-10
R10 N09 N10 2.26e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.24e-10
R11 N10 N11 9.33e-03
C12 N11 N12 2.01e-05
L12 N11 N12 6.07e-11
R12 N11 N12 6.27e-03
C13 N12 N13 1.71e-11
L13 N12 N13 5.55e-11
R13 N12 N13 4.44e+00
C14 N13 Port2 2.86e-12
L14 N13 Port2 1.31e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ32ER71E106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRJ32ER71H106KE11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71H106KE11 Port1 Port2
C01 Port1 N01 9.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.75e-11
R03 N02 N03 6.36e-03
C04 N03 N04 2.11e-03
R04 N03 N04 1.30e+00
C05 N04 N05 1.82e-03
R05 N04 N05 2.05e-01
C06 N05 N06 1.36e-03
R06 N05 N06 3.51e-02
C07 N06 N07 1.86e-03
R07 N06 N07 2.44e-03
L08 N07 N08 1.37e-11
R08 N07 N08 6.00e-02
L09 N08 N09 7.76e-11
R09 N08 N09 3.76e-02
L10 N09 N10 5.46e-10
R10 N09 N10 1.90e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.54e-03
C12 N11 N12 2.05e-05
L12 N11 N12 6.70e-11
R12 N11 N12 6.31e-03
C13 N12 N13 3.36e-11
L13 N12 N13 4.44e-11
R13 N12 N13 2.71e+00
C14 N13 Port2 2.07e-12
L14 N13 Port2 1.91e-10
R14 N13 Port2 1.08e+02
.ENDS GRJ32ER71H106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRJ32ER71H106ME11
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71H106ME11 Port1 Port2
C01 Port1 N01 9.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.75e-11
R03 N02 N03 6.36e-03
C04 N03 N04 2.11e-03
R04 N03 N04 1.30e+00
C05 N04 N05 1.82e-03
R05 N04 N05 2.05e-01
C06 N05 N06 1.36e-03
R06 N05 N06 3.51e-02
C07 N06 N07 1.86e-03
R07 N06 N07 2.44e-03
L08 N07 N08 1.37e-11
R08 N07 N08 6.00e-02
L09 N08 N09 7.76e-11
R09 N08 N09 3.76e-02
L10 N09 N10 5.46e-10
R10 N09 N10 1.90e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.54e-03
C12 N11 N12 2.05e-05
L12 N11 N12 6.70e-11
R12 N11 N12 6.31e-03
C13 N12 N13 3.36e-11
L13 N12 N13 4.44e-11
R13 N12 N13 2.71e+00
C14 N13 Port2 2.07e-12
L14 N13 Port2 1.91e-10
R14 N13 Port2 1.08e+02
.ENDS GRJ32ER71H106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ32ER71H475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71H475KE11 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.88e-11
R03 N02 N03 3.85e-03
C04 N03 N04 4.48e-04
R04 N03 N04 3.92e+00
C05 N04 N05 5.72e-04
R05 N04 N05 3.20e-01
C06 N05 N06 5.05e-04
R06 N05 N06 4.41e-02
C07 N06 N07 3.76e-04
R07 N06 N07 7.45e-03
L08 N07 N08 4.33e-11
R08 N07 N08 3.47e-02
L09 N08 N09 3.82e-10
R09 N08 N09 2.55e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.10e-10
R10 N09 N10 1.39e-02
C11 N10 N11 7.01e-06
L11 N10 N11 6.83e-11
R11 N10 N11 9.25e-03
C12 N11 N12 2.14e-11
L12 N11 N12 8.01e-11
R12 N11 N12 4.66e+00
C13 N12 Port2 2.82e-12
L13 N12 Port2 1.77e-10
R13 N12 Port2 7.33e+01
.ENDS GRJ32ER71H475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ32ER71H475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71H475ME11 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.88e-11
R03 N02 N03 3.85e-03
C04 N03 N04 4.48e-04
R04 N03 N04 3.92e+00
C05 N04 N05 5.72e-04
R05 N04 N05 3.20e-01
C06 N05 N06 5.05e-04
R06 N05 N06 4.41e-02
C07 N06 N07 3.76e-04
R07 N06 N07 7.45e-03
L08 N07 N08 4.33e-11
R08 N07 N08 3.47e-02
L09 N08 N09 3.82e-10
R09 N08 N09 2.55e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.10e-10
R10 N09 N10 1.39e-02
C11 N10 N11 7.01e-06
L11 N10 N11 6.83e-11
R11 N10 N11 9.25e-03
C12 N11 N12 2.14e-11
L12 N11 N12 8.01e-11
R12 N11 N12 4.66e+00
C13 N12 Port2 2.82e-12
L13 N12 Port2 1.77e-10
R13 N12 Port2 7.33e+01
.ENDS GRJ32ER71H475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/80[V]
* Murata P/N :GRJ32ER71K475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71K475KE11 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 5.02e-11
R03 N02 N03 6.63e-03
C04 N03 N04 4.86e-04
R04 N03 N04 3.78e+00
C05 N04 N05 4.91e-04
R05 N04 N05 2.63e-01
C06 N05 N06 4.74e-04
R06 N05 N06 2.71e-02
C07 N06 N07 3.86e-04
R07 N06 N07 3.45e-03
L08 N07 N08 4.92e-11
R08 N07 N08 4.93e-02
L09 N08 N09 4.20e-10
R09 N08 N09 2.29e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.12e-10
R10 N09 N10 1.40e-02
C11 N10 N11 8.92e-06
L11 N10 N11 5.41e-11
R11 N10 N11 9.24e-03
C12 N11 N12 1.82e-11
L12 N11 N12 7.47e-11
R12 N11 N12 6.00e+00
C13 N12 Port2 1.95e-12
L13 N12 Port2 2.22e-10
R13 N12 Port2 9.98e+01
.ENDS GRJ32ER71K475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/80[V]
* Murata P/N :GRJ32ER71K475ME11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71K475ME11 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 5.02e-11
R03 N02 N03 6.63e-03
C04 N03 N04 4.86e-04
R04 N03 N04 3.78e+00
C05 N04 N05 4.91e-04
R05 N04 N05 2.63e-01
C06 N05 N06 4.74e-04
R06 N05 N06 2.71e-02
C07 N06 N07 3.86e-04
R07 N06 N07 3.45e-03
L08 N07 N08 4.92e-11
R08 N07 N08 4.93e-02
L09 N08 N09 4.20e-10
R09 N08 N09 2.29e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.12e-10
R10 N09 N10 1.40e-02
C11 N10 N11 8.92e-06
L11 N10 N11 5.41e-11
R11 N10 N11 9.24e-03
C12 N11 N12 1.82e-11
L12 N11 N12 7.47e-11
R12 N11 N12 6.00e+00
C13 N12 Port2 1.95e-12
L13 N12 Port2 2.22e-10
R13 N12 Port2 9.98e+01
.ENDS GRJ32ER71K475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-01[uF]/250[V]
* Murata P/N :GRJ32QR72E154KWJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR72E154KWJ1 Port1 Port2
C01 Port1 N01 1.48e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.39e-10
R03 N02 N03 1.48e-02
C04 N03 N04 1.37e-05
R04 N03 N04 1.16e-01
C05 N04 N05 1.98e-05
R05 N04 N05 2.54e-02
C06 N05 N06 1.65e-05
R06 N05 N06 6.09e-03
L07 N06 N07 3.83e-11
R07 N06 N07 2.05e-01
L08 N07 N08 1.60e-10
R08 N07 N08 7.96e-02
C09 N08 N09 5.34e-07
L09 N08 N09 3.52e-11
R09 N08 N09 2.75e-02
C10 N09 N10 1.54e-07
L10 N09 N10 4.44e-11
R10 N09 N10 3.39e-02
C11 N10 Port2 8.27e-12
L11 N10 Port2 1.50e-10
R11 N10 Port2 2.69e+01
.ENDS GRJ32QR72E154KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GRJ32QR72E683KWJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR72E683KWJ1 Port1 Port2
C01 Port1 N01 6.39e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 2.49e-10
R03 N02 N03 2.86e-02
C04 N03 N04 4.73e-06
R04 N03 N04 3.37e-01
C05 N04 N05 4.95e-06
R05 N04 N05 2.56e-02
C06 N05 N06 1.64e-05
R06 N05 N06 2.44e-02
L07 N06 N07 6.29e-11
R07 N06 N07 1.06e-01
L08 N07 N08 9.31e-12
R08 N07 N08 5.33e-02
C09 N08 N09 3.16e-07
L09 N08 N09 2.16e-11
R09 N08 N09 2.61e-02
C10 N09 N10 2.40e-08
L10 N09 N10 7.14e-11
R10 N09 N10 5.46e-02
C11 N10 Port2 5.37e-12
L11 N10 Port2 2.78e-10
R11 N10 Port2 2.86e+01
.ENDS GRJ32QR72E683KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GRJ32QR72J223KWJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR72J223KWJ1 Port1 Port2
C01 Port1 N01 2.13e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.89e-10
R03 N02 N03 3.62e-02
C04 N03 N04 1.40e-06
R04 N03 N04 1.14e+00
C05 N04 N05 1.93e-06
R05 N04 N05 1.31e-01
C06 N05 N06 1.72e-06
R06 N05 N06 3.52e-02
C07 N06 N07 1.27e-06
R07 N06 N07 7.88e-03
L08 N07 N08 5.82e-11
R08 N07 N08 3.11e-01
L09 N08 N09 6.38e-11
R09 N08 N09 1.15e-01
C10 N09 N10 6.81e-08
L10 N09 N10 2.83e-11
R10 N09 N10 7.66e-02
C11 N10 N11 1.63e-08
L11 N10 N11 3.97e-11
R11 N10 N11 1.01e-01
C12 N11 Port2 5.05e-12
L12 N11 Port2 2.70e-10
R12 N11 Port2 3.67e+01
.ENDS GRJ32QR72J223KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-02[uF]/1000[V]
* Murata P/N :GRJ32QR73A103KWJ1
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR73A103KWJ1 Port1 Port2
C01 Port1 N01 9.62e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 6.38e-02
C04 N03 N04 4.97e-07
R04 N03 N04 3.20e+00
C05 N04 N05 8.84e-07
R05 N04 N05 1.80e-01
C06 N05 N06 7.88e-07
R06 N05 N06 7.17e-02
C07 N06 N07 3.29e-07
R07 N06 N07 2.16e-02
L08 N07 N08 9.63e-11
R08 N07 N08 7.60e-01
C09 N08 N09 2.72e-08
L09 N08 N09 2.75e-11
R09 N08 N09 7.98e-02
C10 N09 N10 3.94e-09
L10 N09 N10 5.00e-11
R10 N09 N10 1.42e-01
C11 N10 Port2 6.24e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 3.48e+01
.ENDS GRJ32QR73A103KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-03[uF]/1000[V]
* Murata P/N :GRJ32QR73A682KWJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR73A682KWJ1 Port1 Port2
C01 Port1 N01 6.63e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.69e-10
R03 N02 N03 7.82e-02
C04 N03 N04 3.08e-07
R04 N03 N04 5.17e+00
C05 N04 N05 5.73e-07
R05 N04 N05 2.78e-01
C06 N05 N06 9.29e-07
R06 N05 N06 8.58e-02
C07 N06 N07 2.68e-07
R07 N06 N07 5.67e-02
C08 N07 N08 3.87e-07
R08 N07 N08 6.51e-03
L09 N08 N09 8.50e-11
R09 N08 N09 9.06e-01
C10 N09 N10 2.35e-08
L10 N09 N10 1.46e-11
R10 N09 N10 6.26e-02
C11 N10 N11 5.14e-09
L11 N10 N11 1.92e-11
R11 N10 N11 1.22e-01
C12 N11 Port2 7.09e-12
L12 N11 Port2 3.19e-10
R12 N11 Port2 3.36e+01
.ENDS GRJ32QR73A682KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E224KWJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E224KWJ1 Port1 Port2
C01 Port1 N01 2.22e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.23e-10
R03 N02 N03 1.47e-02
C04 N03 N04 2.00e-05
R04 N03 N04 7.96e-02
C05 N04 N05 2.96e-05
R05 N04 N05 1.35e-02
C06 N05 N06 5.51e-05
R06 N05 N06 2.89e-03
L07 N06 N07 1.78e-11
R07 N06 N07 1.34e-01
L08 N07 N08 1.70e-10
R08 N07 N08 7.72e-02
C09 N08 N09 5.74e-07
L09 N08 N09 6.84e-11
R09 N08 N09 3.45e-02
C10 N09 N10 1.82e-07
L10 N09 N10 6.84e-11
R10 N09 N10 3.45e-02
C11 N10 Port2 7.74e-12
L11 N10 Port2 2.92e-10
R11 N10 Port2 3.30e+01
.ENDS GRJ43DR72E224KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E334KWJ1
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E334KWJ1 Port1 Port2
C01 Port1 N01 3.26e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 3.30e-10
R03 N02 N03 1.24e-02
C04 N03 N04 3.43e-05
R04 N03 N04 4.64e-02
C05 N04 N05 5.19e-05
R05 N04 N05 9.70e-03
C06 N05 N06 8.23e-05
R06 N05 N06 1.93e-03
L07 N06 N07 1.50e-11
R07 N06 N07 1.05e-01
L08 N07 N08 1.53e-10
R08 N07 N08 8.18e-02
C09 N08 N09 8.70e-07
L09 N08 N09 5.95e-11
R09 N08 N09 2.08e-02
C10 N09 N10 2.14e-07
L10 N09 N10 8.03e-11
R10 N09 N10 3.07e-02
C11 N10 Port2 6.75e-12
L11 N10 Port2 3.35e-10
R11 N10 Port2 3.87e+01
.ENDS GRJ43DR72E334KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E474KWJ1
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E474KWJ1 Port1 Port2
C01 Port1 N01 4.69e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 2.50e-10
R03 N02 N03 8.74e-03
C04 N03 N04 4.88e-05
R04 N03 N04 3.26e-02
C05 N04 N05 1.04e-04
R05 N04 N05 6.07e-03
C06 N05 N06 6.01e-05
R06 N05 N06 4.20e-03
L07 N06 N07 1.47e-11
R07 N06 N07 6.69e-02
L08 N07 N08 1.98e-10
R08 N07 N08 6.53e-02
C09 N08 N09 8.61e-07
L09 N08 N09 9.98e-11
R09 N08 N09 3.03e-02
C10 N09 N10 4.03e-07
L10 N09 N10 7.74e-11
R10 N09 N10 2.77e-02
C11 N10 Port2 5.69e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 3.48e+01
.ENDS GRJ43DR72E474KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GRJ43DR72J104KWJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72J104KWJ1 Port1 Port2
C01 Port1 N01 9.88e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 3.07e-10
R03 N02 N03 1.41e-02
C04 N03 N04 7.18e-06
R04 N03 N04 2.22e-01
C05 N04 N05 7.69e-06
R05 N04 N05 2.49e-02
C06 N05 N06 8.24e-06
R06 N05 N06 1.64e-03
L07 N06 N07 1.58e-10
R07 N06 N07 1.14e-01
L08 N07 N08 1.48e-11
R08 N07 N08 7.88e-02
C09 N08 N09 1.82e-07
L09 N08 N09 9.89e-11
R09 N08 N09 9.73e-02
C10 N09 N10 8.49e-08
L10 N09 N10 8.04e-11
R10 N09 N10 8.28e-02
C11 N10 Port2 7.57e-12
L11 N10 Port2 2.16e-10
R11 N10 Port2 3.37e+01
.ENDS GRJ43DR72J104KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-02[uF]/1000[V]
* Murata P/N :GRJ43DR73A333KWJ1
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR73A333KWJ1 Port1 Port2
C01 Port1 N01 3.27e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 2.18e-10
R03 N02 N03 2.77e-02
C04 N03 N04 2.80e-06
R04 N03 N04 5.69e-01
C05 N04 N05 4.97e-06
R05 N04 N05 8.04e-02
C06 N05 N06 2.80e-06
R06 N05 N06 4.42e-02
C07 N06 N07 9.48e-07
R07 N06 N07 1.06e-02
L08 N07 N08 1.62e-10
R08 N07 N08 2.67e-01
C09 N08 N09 8.11e-08
L09 N08 N09 5.31e-11
R09 N08 N09 8.09e-02
C10 N09 N10 2.75e-08
L10 N09 N10 4.96e-11
R10 N09 N10 8.47e-02
C11 N10 Port2 5.36e-12
L11 N10 Port2 4.63e-10
R11 N10 Port2 4.77e+01
.ENDS GRJ43DR73A333KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/1000[V]
* Murata P/N :GRJ43DR73A473KWJ1
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR73A473KWJ1 Port1 Port2
C01 Port1 N01 4.98e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 2.24e-10
R03 N02 N03 2.20e-02
C04 N03 N04 3.78e-06
R04 N03 N04 4.21e-01
C05 N04 N05 9.95e-06
R05 N04 N05 3.05e-02
C06 N05 N06 3.78e-06
R06 N05 N06 2.66e-02
C07 N06 N07 4.24e-06
R07 N06 N07 2.37e-03
L08 N07 N08 1.53e-10
R08 N07 N08 1.96e-01
L09 N08 N09 1.93e-11
R09 N08 N09 1.63e-01
C10 N09 N10 1.02e-07
L10 N09 N10 8.42e-11
R10 N09 N10 1.09e-01
C11 N10 N11 4.16e-08
L11 N10 N11 7.17e-11
R11 N10 N11 1.04e-01
C12 N11 Port2 5.87e-12
L12 N11 Port2 2.79e-10
R12 N11 Port2 4.55e+01
.ENDS GRJ43DR73A473KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.50e-01[uF]/250[V]
* Murata P/N :GRJ43QR72E154KWJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43QR72E154KWJ1 Port1 Port2
C01 Port1 N01 1.50e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.77e-10
R03 N02 N03 2.14e-02
C04 N03 N04 1.41e-05
R04 N03 N04 1.13e-01
C05 N04 N05 2.04e-05
R05 N04 N05 1.96e-02
C06 N05 N06 2.24e-05
R06 N05 N06 6.64e-03
L07 N06 N07 3.54e-11
R07 N06 N07 1.50e-01
L08 N07 N08 1.29e-10
R08 N07 N08 1.09e-01
C09 N08 N09 3.91e-07
L09 N08 N09 4.59e-11
R09 N08 N09 2.16e-02
C10 N09 N10 6.64e-08
L10 N09 N10 7.64e-11
R10 N09 N10 3.36e-02
C11 N10 Port2 6.80e-12
L11 N10 Port2 2.76e-10
R11 N10 Port2 2.54e+01
.ENDS GRJ43QR72E154KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/6.80e-02[uF]/630[V]
* Murata P/N :GRJ43QR72J683KWJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43QR72J683KWJ1 Port1 Port2
C01 Port1 N01 6.72e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 3.45e-10
R03 N02 N03 1.88e-02
C04 N03 N04 5.41e-06
R04 N03 N04 2.94e-01
C05 N04 N05 6.36e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.30e-06
R06 N05 N06 1.14e-02
L07 N06 N07 2.00e-11
R07 N06 N07 1.69e-01
L08 N07 N08 1.26e-10
R08 N07 N08 1.20e-01
C09 N08 N09 1.35e-07
L09 N08 N09 6.65e-11
R09 N08 N09 8.24e-02
C10 N09 N10 4.91e-08
L10 N09 N10 6.35e-11
R10 N09 N10 9.03e-02
C11 N10 Port2 1.38e-11
L11 N10 Port2 1.56e-10
R11 N10 Port2 2.12e+01
.ENDS GRJ43QR72J683KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :GRJ55DR72E105KWJ1
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72E105KWJ1 Port1 Port2
C01 Port1 N01 1.07e-06
R01 Port1 N01 1.00e+08
L02 N01 N02 1.33e-10
R03 N02 N03 6.64e-03
C04 N03 N04 1.00e-05
R04 N03 N04 5.30e+02
C05 N04 N05 1.32e-04
R05 N04 N05 4.02e-01
C06 N05 N06 1.12e-04
R06 N05 N06 5.06e-02
C07 N06 N07 7.95e-05
R07 N06 N07 6.67e-03
L08 N07 N08 2.27e-11
R08 N07 N08 1.16e-01
L09 N08 N09 1.53e-10
R09 N08 N09 5.67e-02
C10 N09 N10 1.69e-06
L10 N09 N10 9.73e-11
R10 N09 N10 1.90e-02
C11 N10 N11 3.97e-07
L11 N10 N11 1.14e-10
R11 N10 N11 2.14e-02
C12 N11 Port2 6.30e-12
L12 N11 Port2 3.30e-10
R12 N11 Port2 7.40e+01
.ENDS GRJ55DR72E105KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GRJ55DR72E334KWJ1
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72E334KWJ1 Port1 Port2
C01 Port1 N01 3.32e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.38e-02
C04 N03 N04 3.24e-05
R04 N03 N04 4.91e-02
C05 N04 N05 6.17e-05
R05 N04 N05 8.15e-03
C06 N05 N06 3.89e-05
R06 N05 N06 3.25e-03
L07 N06 N07 6.84e-12
R07 N06 N07 6.96e-02
L08 N07 N08 1.43e-10
R08 N07 N08 5.92e-02
C09 N08 N09 6.47e-07
L09 N08 N09 5.80e-11
R09 N08 N09 1.89e-02
C10 N09 N10 3.10e-07
L10 N09 N10 3.32e-11
R10 N09 N10 1.49e-02
C11 N10 Port2 6.47e-12
L11 N10 Port2 5.05e-10
R11 N10 Port2 4.97e+01
.ENDS GRJ55DR72E334KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :GRJ55DR72E474KWJ1
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72E474KWJ1 Port1 Port2
C01 Port1 N01 4.61e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 1.92e-10
R03 N02 N03 8.42e-03
C04 N03 N04 4.30e-05
R04 N03 N04 3.70e-02
C05 N04 N05 5.93e-05
R05 N04 N05 8.48e-03
C06 N05 N06 8.58e-05
R06 N05 N06 1.17e-03
L07 N06 N07 2.85e-11
R07 N06 N07 1.39e-01
L08 N07 N08 1.19e-10
R08 N07 N08 7.11e-02
C09 N08 N09 9.30e-07
L09 N08 N09 7.01e-11
R09 N08 N09 3.30e-02
C10 N09 N10 1.85e-07
L10 N09 N10 1.06e-10
R10 N09 N10 3.79e-02
C11 N10 Port2 8.10e-12
L11 N10 Port2 3.06e-10
R11 N10 Port2 6.15e+01
.ENDS GRJ55DR72E474KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-01[uF]/250[V]
* Murata P/N :GRJ55DR72E684KWJ1
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72E684KWJ1 Port1 Port2
C01 Port1 N01 6.68e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 2.42e-10
R03 N02 N03 8.51e-03
C04 N03 N04 6.36e-05
R04 N03 N04 2.50e-02
C05 N04 N05 2.01e-04
R05 N04 N05 3.15e-03
C06 N05 N06 1.18e-04
R06 N05 N06 1.69e-03
L07 N06 N07 3.60e-11
R07 N06 N07 1.92e-01
L08 N07 N08 1.57e-10
R08 N07 N08 5.06e-02
C09 N08 N09 1.17e-06
L09 N08 N09 7.03e-11
R09 N08 N09 1.90e-02
C10 N09 N10 4.54e-07
L10 N09 N10 5.21e-11
R10 N09 N10 1.70e-02
C11 N10 Port2 9.07e-12
L11 N10 Port2 3.29e-10
R11 N10 Port2 6.30e+01
.ENDS GRJ55DR72E684KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :GRJ55DR72J154KWJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72J154KWJ1 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 1.11e-10
R03 N02 N03 1.32e-02
C04 N03 N04 1.08e-05
R04 N03 N04 1.48e-01
C05 N04 N05 2.47e-05
R05 N04 N05 1.17e-02
C06 N05 N06 1.52e-05
R06 N05 N06 9.75e-03
L07 N06 N07 1.13e-10
R07 N06 N07 1.04e-01
C08 N07 N08 2.66e-07
L08 N07 N08 6.76e-11
R08 N07 N08 5.66e-02
C09 N08 N09 8.80e-08
L09 N08 N09 6.16e-11
R09 N08 N09 5.28e-02
C10 N09 Port2 6.38e-12
L10 N09 Port2 5.13e-10
R10 N09 Port2 4.93e+01
.ENDS GRJ55DR72J154KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :GRJ55DR72J224KWJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72J224KWJ1 Port1 Port2
C01 Port1 N01 2.29e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.32e-11
R03 N02 N03 8.26e-03
C04 N03 N04 2.00e-05
R04 N03 N04 7.97e-02
C05 N04 N05 2.14e-05
R05 N04 N05 1.45e-02
C06 N05 N06 1.48e-05
R06 N05 N06 1.42e-03
L07 N06 N07 1.20e-11
R07 N06 N07 1.02e-01
L08 N07 N08 1.41e-10
R08 N07 N08 9.06e-02
C09 N08 N09 3.42e-07
L09 N08 N09 1.15e-10
R09 N08 N09 7.99e-02
C10 N09 N10 1.27e-07
L10 N09 N10 1.02e-10
R10 N09 N10 6.80e-02
C11 N10 Port2 4.41e-12
L11 N10 Port2 3.89e-10
R11 N10 Port2 9.61e+01
.ENDS GRJ55DR72J224KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-01[uF]/1000[V]
* Murata P/N :GRJ55DR73A104KWJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR73A104KWJ1 Port1 Port2
C01 Port1 N01 1.00e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 7.63e-11
R03 N02 N03 1.35e-02
C04 N03 N04 8.44e-06
R04 N03 N04 1.88e-01
C05 N04 N05 2.33e-05
R05 N04 N05 1.37e-02
C06 N05 N06 9.47e-06
R06 N05 N06 1.30e-02
C07 N06 N07 7.02e-06
R07 N06 N07 2.72e-03
L08 N07 N08 1.72e-10
R08 N07 N08 1.92e-01
C09 N08 N09 1.69e-07
L09 N08 N09 8.45e-11
R09 N08 N09 8.91e-02
C10 N09 N10 6.41e-08
L10 N09 N10 6.72e-11
R10 N09 N10 7.24e-02
C11 N10 Port2 5.46e-12
L11 N10 Port2 4.14e-10
R11 N10 Port2 6.03e+01
.ENDS GRJ55DR73A104KWJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-02[uF]/1000[V]
* Murata P/N :GRJ55DR73A683KWJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR73A683KWJ1 Port1 Port2
C01 Port1 N01 6.77e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 1.70e-10
R03 N02 N03 1.98e-02
C04 N03 N04 5.18e-06
R04 N03 N04 3.07e-01
C05 N04 N05 6.37e-06
R05 N04 N05 2.33e-02
C06 N05 N06 1.64e-05
R06 N05 N06 1.85e-02
C07 N06 N07 3.58e-06
R07 N06 N07 4.44e-03
L08 N07 N08 8.64e-12
R08 N07 N08 1.84e-01
L09 N08 N09 6.71e-11
R09 N08 N09 9.86e-02
C10 N09 N10 1.33e-07
L10 N09 N10 5.13e-11
R10 N09 N10 5.79e-02
C11 N10 N11 3.75e-08
L11 N10 N11 5.01e-11
R11 N10 N11 5.79e-02
C12 N11 Port2 6.99e-12
L12 N11 Port2 5.13e-10
R12 N11 Port2 5.16e+01
.ENDS GRJ55DR73A683KWJ1
