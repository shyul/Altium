*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GGM1555C1H100FA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H100FA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.67e-10
R03 N02 N03 2.11e-01
L04 N03 N04 7.40e-12
R04 N03 N04 1.16e-01
C05 N04 N05 4.13e-11
L05 N04 N05 2.14e-11
R05 N04 N05 5.92e+00
C06 N05 Port2 7.91e-12
L06 N05 Port2 3.52e-11
R06 N05 Port2 4.81e+00
.ENDS GGM1555C1H100FA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GGM1555C1H100GA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H100GA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.67e-10
R03 N02 N03 2.11e-01
L04 N03 N04 7.40e-12
R04 N03 N04 1.16e-01
C05 N04 N05 4.13e-11
L05 N04 N05 2.14e-11
R05 N04 N05 5.92e+00
C06 N05 Port2 7.91e-12
L06 N05 Port2 3.52e-11
R06 N05 Port2 4.81e+00
.ENDS GGM1555C1H100GA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GGM1555C1H100JA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H100JA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.67e-10
R03 N02 N03 2.11e-01
L04 N03 N04 7.40e-12
R04 N03 N04 1.16e-01
C05 N04 N05 4.13e-11
L05 N04 N05 2.14e-11
R05 N04 N05 5.92e+00
C06 N05 Port2 7.91e-12
L06 N05 Port2 3.52e-11
R06 N05 Port2 4.81e+00
.ENDS GGM1555C1H100JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GGM1555C1H100RA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H100RA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.67e-10
R03 N02 N03 2.11e-01
L04 N03 N04 7.40e-12
R04 N03 N04 1.16e-01
C05 N04 N05 4.13e-11
L05 N04 N05 2.14e-11
R05 N04 N05 5.92e+00
C06 N05 Port2 7.91e-12
L06 N05 Port2 3.52e-11
R06 N05 Port2 4.81e+00
.ENDS GGM1555C1H100RA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GGM1555C1H101JA16
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H101JA16 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 7.87e-02
L04 N03 N04 1.32e-11
R04 N03 N04 6.83e-02
L05 N04 N05 1.76e-11
R05 N04 N05 2.48e-02
C06 N05 N06 1.08e-09
L06 N05 N06 6.64e-12
R06 N05 N06 4.45e-01
C07 N06 N07 1.58e-10
L07 N06 N07 1.89e-11
R07 N06 N07 1.24e+00
C08 N07 N08 2.89e-11
L08 N07 N08 2.30e-11
R08 N07 N08 1.17e+00
C09 N08 Port2 8.66e-12
L09 N08 Port2 2.98e-11
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H101JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GGM1555C1H120JA16
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H120JA16 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.25e-10
R03 N02 N03 1.08e-01
L04 N03 N04 1.16e-11
R04 N03 N04 2.11e-01
L05 N04 N05 4.18e-11
R05 N04 N05 1.18e-01
C06 N05 N06 9.34e-11
L06 N05 N06 1.14e-11
R06 N05 N06 2.46e+00
C07 N06 N07 1.44e-11
L07 N06 N07 2.43e-11
R07 N06 N07 3.13e+00
C08 N07 Port2 4.41e-12
L08 N07 Port2 6.00e-11
R08 N07 Port2 5.00e+03
.ENDS GGM1555C1H120JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GGM1555C1H121JA16
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H121JA16 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.20e-01
C04 N03 N04 2.74e-12
L04 N03 N04 1.03e-10
C05 N04 N05 2.68e-12
L05 N04 N05 7.26e-11
R05 N04 N05 4.39e+00
C06 N05 N06 2.15e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.16e+00
C07 N06 Port2 8.89e-10
L07 N06 Port2 9.86e-12
R07 N06 Port2 5.69e-01
.ENDS GGM1555C1H121JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GGM1555C1H150JA16
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H150JA16 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.37e-10
R03 N02 N03 1.06e-01
L04 N03 N04 2.01e-11
R04 N03 N04 4.00e-01
L05 N04 N05 3.51e-11
R05 N04 N05 1.05e-01
C06 N05 N06 1.06e-10
L06 N05 N06 1.01e-11
R06 N05 N06 1.61e+00
C07 N06 N07 2.87e-11
L07 N06 N07 1.18e-11
R07 N06 N07 2.13e+00
C08 N07 Port2 2.32e-12
L08 N07 Port2 8.88e-11
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H150JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GGM1555C1H151JA16
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H151JA16 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.49e-10
R03 N02 N03 8.71e-02
L04 N03 N04 1.15e-11
R04 N03 N04 4.61e-02
C05 N04 N05 1.47e-09
L05 N04 N05 7.15e-12
R05 N04 N05 2.75e-01
C06 N05 N06 2.51e-10
L06 N05 N06 1.73e-11
R06 N05 N06 8.55e-01
C07 N06 N07 6.99e-12
L07 N06 N07 4.64e-11
R07 N06 N07 1.71e+00
C08 N07 Port2 1.46e-12
L08 N07 Port2 1.51e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H151JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GGM1555C1H180JA16
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H180JA16 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.22e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.46e-11
R04 N03 N04 8.40e-02
L05 N04 N05 1.92e-11
R05 N04 N05 5.10e-02
C06 N05 N06 2.88e-10
L06 N05 N06 4.89e-12
R06 N05 N06 8.71e-01
C07 N06 N07 1.19e-11
L07 N06 N07 3.68e-11
R07 N06 N07 6.64e+00
C08 N07 Port2 3.62e-12
L08 N07 Port2 7.78e-11
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H180JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GGM1555C1H181JA16
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H181JA16 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.15e-10
R03 N02 N03 1.00e-01
L04 N03 N04 1.74e-11
R04 N03 N04 5.48e-01
L05 N04 N05 1.17e-10
R05 N04 N05 1.33e+01
C06 N05 N06 3.37e-12
L06 N05 N06 8.36e-11
C07 N06 N07 2.98e-10
L07 N06 N07 2.02e-11
R07 N06 N07 9.99e-01
C08 N07 Port2 1.78e-09
L08 N07 Port2 7.81e-12
R08 N07 Port2 4.30e-01
.ENDS GGM1555C1H181JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H1R0CA16
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H1R0CA16 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.09e-10
R03 N02 N03 4.92e-01
L04 N03 N04 3.76e-11
R04 N03 N04 2.70e-01
C05 N04 Port2 4.97e-11
L05 N04 Port2 6.09e-12
R05 N04 Port2 1.15e+00
.ENDS GGM1555C1H1R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GGM1555C1H1R2CA16
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H1R2CA16 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.96e-10
R03 N02 N03 4.11e-01
L04 N03 N04 4.15e-11
R04 N03 N04 2.84e-01
C05 N04 Port2 2.54e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 2.63e+00
.ENDS GGM1555C1H1R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GGM1555C1H1R5CA16
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H1R5CA16 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.66e-10
R03 N02 N03 3.89e-01
L04 N03 N04 2.46e-11
R04 N03 N04 2.19e-01
C05 N04 Port2 2.72e-11
L05 N04 Port2 1.14e-11
R05 N04 Port2 1.72e+00
.ENDS GGM1555C1H1R5CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GGM1555C1H1R8CA16
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H1R8CA16 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.44e-10
R03 N02 N03 3.50e-01
L04 N03 N04 1.74e-11
R04 N03 N04 3.76e-01
C05 N04 Port2 9.65e-11
L05 N04 Port2 3.62e-12
R05 N04 Port2 6.05e-01
.ENDS GGM1555C1H1R8CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GGM1555C1H220JA16
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H220JA16 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.70e-10
R03 N02 N03 1.01e-01
L04 N03 N04 2.01e-11
R04 N03 N04 1.48e-01
L05 N04 N05 2.75e-11
R05 N04 N05 3.67e-02
C06 N05 N06 1.33e-10
L06 N05 N06 1.24e-11
R06 N05 N06 1.89e+00
C07 N06 N07 1.44e-11
L07 N06 N07 3.19e-11
R07 N06 N07 4.74e+00
C08 N07 Port2 1.91e-12
L08 N07 Port2 1.38e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H220JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GGM1555C1H221JA16
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H221JA16 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.06e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.84e-11
R04 N03 N04 1.04e+00
C05 N04 N05 2.62e-09
L05 N04 N05 5.20e-12
R05 N04 N05 1.34e-01
C06 N05 N06 3.41e-10
L06 N05 N06 1.62e-11
R06 N05 N06 5.62e-01
C07 N06 N07 6.81e-11
L07 N06 N07 5.33e-12
R07 N06 N07 1.14e+00
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.30e-10
R08 N07 Port2 8.25e+08
.ENDS GGM1555C1H221JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GGM1555C1H270JA16
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H270JA16 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.43e-10
R03 N02 N03 9.66e-02
L04 N03 N04 1.06e-11
R04 N03 N04 1.33e-01
L05 N04 N05 3.79e-11
R05 N04 N05 8.53e-02
C06 N05 N06 1.53e-10
L06 N05 N06 1.31e-11
R06 N05 N06 1.48e+00
C07 N06 N07 4.92e-11
L07 N06 N07 1.38e-11
R07 N06 N07 1.54e+00
C08 N07 N08 3.86e-11
L08 N07 N08 9.54e-12
R08 N07 N08 2.03e+00
C09 N08 Port2 3.18e-12
L09 N08 Port2 7.58e-11
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H270JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GGM1555C1H271JA16
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H271JA16 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.23e-10
R03 N02 N03 1.00e-01
L04 N03 N04 6.58e-11
R04 N03 N04 2.48e+00
C05 N04 N05 2.13e-12
L05 N04 N05 1.32e-10
C06 N05 N06 6.72e-12
L06 N05 N06 4.19e-11
C07 N06 N07 1.44e-11
L07 N06 N07 2.44e-11
R07 N06 N07 7.56e+00
C08 N07 N08 4.29e-10
L08 N07 N08 1.82e-11
R08 N07 N08 5.62e-01
C09 N08 Port2 3.52e-09
L09 N08 Port2 5.17e-12
R09 N08 Port2 1.31e-01
.ENDS GGM1555C1H271JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H2R0CA16
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H2R0CA16 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.35e-10
R03 N02 N03 3.18e-01
L04 N03 N04 1.16e-11
R04 N03 N04 3.33e-01
C05 N04 Port2 2.62e-10
L05 N04 Port2 1.73e-12
R05 N04 Port2 2.37e-01
.ENDS GGM1555C1H2R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GGM1555C1H2R2CA16
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H2R2CA16 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.33e-10
R03 N02 N03 3.16e-01
C04 N03 Port2 2.91e-11
L04 N03 Port2 1.01e-11
R04 N03 Port2 6.66e-01
.ENDS GGM1555C1H2R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GGM1555C1H2R7CA16
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H2R7CA16 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-10
R03 N02 N03 2.85e-01
C04 N03 Port2 4.96e-11
L04 N03 Port2 9.20e-12
R04 N03 Port2 6.20e-01
.ENDS GGM1555C1H2R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GGM1555C1H330JA16
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H330JA16 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 8.05e-02
L04 N03 N04 1.24e-11
R04 N03 N04 1.42e-01
L05 N04 N05 3.92e-11
R05 N04 N05 8.58e-02
C06 N05 N06 1.81e-10
L06 N05 N06 1.36e-11
R06 N05 N06 1.18e+00
C07 N06 N07 7.62e-11
L07 N06 N07 1.08e-11
R07 N06 N07 1.34e+00
C08 N07 N08 5.35e-11
L08 N07 N08 7.82e-12
R08 N07 N08 1.22e+00
C09 N08 Port2 2.95e-12
L09 N08 Port2 7.19e-11
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H330JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GGM1555C1H331JA16
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H331JA16 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.98e-10
R03 N02 N03 7.51e-02
L04 N03 N04 6.24e-11
R04 N03 N04 9.54e-01
C05 N04 N05 4.13e-09
L05 N04 N05 5.92e-12
R05 N04 N05 1.89e-01
C06 N05 N06 7.02e-10
L06 N05 N06 1.50e-11
R06 N05 N06 4.64e-01
C07 N06 N07 6.03e-11
L07 N06 N07 5.81e-12
R07 N06 N07 7.78e-01
C08 N07 Port2 2.33e-12
L08 N07 Port2 1.04e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H331JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GGM1555C1H390JA16
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H390JA16 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 7.55e-02
L04 N03 N04 1.06e-11
R04 N03 N04 2.64e-01
L05 N04 N05 3.73e-11
R05 N04 N05 1.03e-01
C06 N05 N06 2.76e-10
L06 N05 N06 1.14e-11
R06 N05 N06 1.40e+00
C07 N06 N07 1.16e-10
L07 N06 N07 9.28e-12
R07 N06 N07 1.30e+00
C08 N07 N08 1.78e-11
L08 N07 N08 2.60e-11
R08 N07 N08 2.90e+00
C09 N08 Port2 1.65e-12
L09 N08 Port2 1.33e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H390JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GGM1555C1H391JA16
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H391JA16 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.58e-10
R03 N02 N03 7.50e-02
L04 N03 N04 4.37e-11
R04 N03 N04 9.15e-01
C05 N04 N05 2.35e-12
L05 N04 N05 1.20e-10
C06 N05 N06 1.15e-11
L06 N05 N06 2.97e-11
R06 N05 N06 4.87e+00
C07 N06 N07 9.05e-10
L07 N06 N07 4.83e-12
R07 N06 N07 1.95e-01
C08 N07 N08 6.96e-10
L08 N07 N08 1.97e-11
R08 N07 N08 5.90e-01
C09 N08 Port2 3.22e-09
L09 N08 Port2 9.50e-12
R09 N08 Port2 2.46e-01
.ENDS GGM1555C1H391JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H3R0CA16
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H3R0CA16 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 2.74e-01
C04 N03 Port2 4.86e-11
L04 N03 Port2 9.17e-12
R04 N03 Port2 5.55e-01
.ENDS GGM1555C1H3R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GGM1555C1H3R3CA16
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H3R3CA16 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.72e-01
L04 N03 N04 8.89e-12
R04 N03 N04 2.97e-01
C05 N04 Port2 1.22e-11
L05 N04 Port2 2.23e-11
R05 N04 Port2 5.99e+00
.ENDS GGM1555C1H3R3CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GGM1555C1H3R9CA16
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H3R9CA16 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 2.54e-01
L04 N03 N04 6.43e-12
R04 N03 N04 1.26e-01
C05 N04 Port2 5.05e-12
L05 N04 Port2 6.39e-11
R05 N04 Port2 2.68e+01
.ENDS GGM1555C1H3R9CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GGM1555C1H470JA16
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H470JA16 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-10
R03 N02 N03 7.44e-02
L04 N03 N04 3.86e-11
R04 N03 N04 8.55e-02
L05 N04 N05 2.48e-12
R05 N04 N05 5.61e-02
C06 N05 N06 4.56e-10
L06 N05 N06 7.45e-12
R06 N05 N06 7.46e-01
C07 N06 N07 6.40e-11
L07 N06 N07 2.18e-11
R07 N06 N07 2.38e+00
C08 N07 N08 1.34e-11
L08 N07 N08 3.05e-11
R08 N07 N08 3.04e+00
C09 N08 Port2 1.14e-12
L09 N08 Port2 1.82e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H470JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GGM1555C1H471JA16
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H471JA16 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 5.29e-02
L04 N03 N04 7.93e-11
R04 N03 N04 6.77e-01
C05 N04 N05 6.72e-09
L05 N04 N05 5.61e-12
R05 N04 N05 2.07e-01
C06 N05 N06 1.85e-09
L06 N05 N06 9.35e-12
R06 N05 N06 4.02e-01
C07 N06 N07 7.69e-11
L07 N06 N07 4.58e-12
R07 N06 N07 1.64e+00
C08 N07 Port2 1.50e-12
L08 N07 Port2 1.26e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1555C1H471JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H4R0CA16
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H4R0CA16 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.31e-10
R03 N02 N03 2.50e-01
L04 N03 N04 1.62e-10
R04 N03 N04 2.41e+02
L05 N04 N05 2.01e-11
R05 N04 N05 2.27e+00
C06 N05 Port2 1.08e-11
L06 N05 Port2 2.92e-11
R06 N05 Port2 1.28e+01
.ENDS GGM1555C1H4R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GGM1555C1H4R3CA16
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H4R3CA16 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.91e-10
R03 N02 N03 2.48e-01
L04 N03 N04 1.05e-11
R04 N03 N04 2.97e-01
C05 N04 Port2 1.13e-11
L05 N04 Port2 3.27e-11
R05 N04 Port2 1.29e+01
.ENDS GGM1555C1H4R3CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GGM1555C1H4R7CA16
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H4R7CA16 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 2.47e-01
L04 N03 N04 8.42e-12
R04 N03 N04 2.57e-01
C05 N04 Port2 9.29e-12
L05 N04 Port2 4.25e-11
R05 N04 Port2 1.51e+01
.ENDS GGM1555C1H4R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GGM1555C1H560JA16
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H560JA16 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 6.86e-02
L04 N03 N04 3.71e-11
R04 N03 N04 7.87e-02
L05 N04 N05 2.89e-12
R05 N04 N05 2.56e-02
C06 N05 N06 3.54e-10
L06 N05 N06 1.13e-11
R06 N05 N06 1.01e+00
C07 N06 N07 8.94e-11
L07 N06 N07 1.91e-11
R07 N06 N07 2.05e+00
C08 N07 N08 2.96e-11
L08 N07 N08 1.82e-11
R08 N07 N08 1.43e+00
C09 N08 Port2 7.57e-12
L09 N08 Port2 2.73e-11
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H560JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H5R0CA16
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H5R0CA16 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.99e-10
R03 N02 N03 2.39e-01
L04 N03 N04 1.36e-11
R04 N03 N04 3.84e-01
C05 N04 Port2 1.68e-11
L05 N04 Port2 2.55e-11
R05 N04 Port2 9.87e+00
.ENDS GGM1555C1H5R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GGM1555C1H5R6DA16
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H5R6DA16 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.93e-10
R03 N02 N03 2.32e-01
L04 N03 N04 1.67e-11
R04 N03 N04 6.42e-01
C05 N04 Port2 2.00e-11
L05 N04 Port2 2.42e-11
R05 N04 Port2 8.73e+00
.ENDS GGM1555C1H5R6DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GGM1555C1H680JA16
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H680JA16 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.27e-01
L04 N03 N04 8.27e-12
R04 N03 N04 9.27e-02
L05 N04 N05 2.94e-11
R05 N04 N05 6.90e-02
C06 N05 N06 6.75e-10
L06 N05 N06 5.85e-12
R06 N05 N06 3.14e-01
C07 N06 N07 7.64e-11
L07 N06 N07 2.04e-11
R07 N06 N07 1.38e+00
C08 N07 N08 2.68e-11
L08 N07 N08 1.52e-11
R08 N07 N08 1.25e+00
C09 N08 Port2 2.46e-12
L09 N08 Port2 8.79e-11
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H680JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H6R0DA16
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H6R0DA16 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.70e-10
R03 N02 N03 2.30e-01
L04 N03 N04 1.09e-11
R04 N03 N04 2.18e-01
C05 N04 N05 1.36e-11
L05 N04 N05 3.72e-11
R05 N04 N05 1.21e+01
C06 N05 Port2 1.55e-11
L06 N05 Port2 2.06e-11
R06 N05 Port2 2.25e+01
.ENDS GGM1555C1H6R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GGM1555C1H6R8DA16
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H6R8DA16 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.77e-10
R03 N02 N03 2.27e-01
L04 N03 N04 1.16e-11
R04 N03 N04 3.01e-01
C05 N04 N05 1.75e-11
L05 N04 N05 3.22e-11
R05 N04 N05 9.92e+00
C06 N05 Port2 1.40e-11
L06 N05 Port2 2.34e-11
R06 N05 Port2 9.27e+00
.ENDS GGM1555C1H6R8DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H7R0DA16
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H7R0DA16 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.78e-10
R03 N02 N03 2.23e-01
L04 N03 N04 1.27e-11
R04 N03 N04 3.06e-01
C05 N04 N05 1.93e-11
L05 N04 N05 3.08e-11
R05 N04 N05 9.54e+00
C06 N05 Port2 1.53e-11
L06 N05 Port2 1.98e-11
R06 N05 Port2 8.81e+00
.ENDS GGM1555C1H7R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GGM1555C1H820JA16
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H820JA16 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.11e-12
R03 N02 N03 8.78e-02
L04 N03 N04 3.61e-11
R04 N03 N04 7.31e-02
L05 N04 N05 3.87e-12
R05 N04 N05 5.36e-02
C06 N05 N06 8.53e-10
L06 N05 N06 6.17e-12
R06 N05 N06 4.17e-01
C07 N06 N07 1.09e-10
L07 N06 N07 1.93e-11
R07 N06 N07 1.55e+00
C08 N07 N08 1.53e-11
L08 N07 N08 3.32e-11
R08 N07 N08 2.56e+00
C09 N08 Port2 6.04e-13
L09 N08 Port2 2.98e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1555C1H820JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H8R0DA16
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H8R0DA16 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.75e-10
R03 N02 N03 2.23e-01
L04 N03 N04 1.01e-11
R04 N03 N04 1.47e-01
C05 N04 N05 2.72e-11
L05 N04 N05 2.58e-11
R05 N04 N05 7.24e+00
C06 N05 Port2 8.24e-12
L06 N05 Port2 3.33e-11
R06 N05 Port2 7.52e+00
.ENDS GGM1555C1H8R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GGM1555C1H8R2DA16
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H8R2DA16 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.94e-10
R03 N02 N03 2.19e-01
L04 N03 N04 1.58e-11
R04 N03 N04 3.85e-01
C05 N04 N05 2.90e-11
L05 N04 N05 2.41e-11
R05 N04 N05 6.91e+00
C06 N05 Port2 2.82e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 2.36e+00
.ENDS GGM1555C1H8R2DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GGM1555C1H9R0DA16
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1H9R0DA16 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.16e-01
L04 N03 N04 1.51e-11
R04 N03 N04 2.85e-01
C05 N04 N05 3.09e-11
L05 N04 N05 2.52e-11
R05 N04 N05 7.12e+00
C06 N05 Port2 1.63e-11
L06 N05 Port2 1.94e-11
R06 N05 Port2 4.01e+00
.ENDS GGM1555C1H9R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GGM1555C1HR50BA16
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1HR50BA16 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 4.03e-10
R03 N02 N03 5.95e-01
L04 N03 Port2 3.52e-11
R04 N03 Port2 4.96e-01
.ENDS GGM1555C1HR50BA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GGM1555C1HR50WA16
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1555C1HR50WA16 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 4.03e-10
R03 N02 N03 5.95e-01
L04 N03 Port2 3.52e-11
R04 N03 Port2 4.96e-01
.ENDS GGM1555C1HR50WA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GGM1885C1H100JA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H100JA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.47e-11
R03 N02 N03 2.40e-01
L04 N03 N04 3.32e-11
R04 N03 N04 2.57e-01
C05 N04 N05 1.97e-11
L05 N04 N05 3.08e-11
R05 N04 N05 6.43e+00
C06 N05 N06 2.83e-12
L06 N05 N06 1.17e-10
R06 N05 N06 1.51e+01
C07 N06 Port2 7.50e-13
L07 N06 Port2 3.47e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C1H100JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GGM1885C1H101JA16
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H101JA16 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.15e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.71e-11
R04 N03 N04 8.03e-02
C05 N04 N05 1.14e-09
L05 N04 N05 7.24e-12
R05 N04 N05 2.77e-01
C06 N05 N06 1.01e-10
L06 N05 N06 2.88e-11
R06 N05 N06 1.50e+00
C07 N06 N07 1.61e-12
L07 N06 N07 1.77e-10
R07 N06 N07 4.25e+01
C08 N07 Port2 7.25e-13
L08 N07 Port2 3.51e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H101JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GGM1885C1H102JA16
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H102JA16 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.05e-10
R03 N02 N03 1.97e-02
L04 N03 N04 6.73e-11
R04 N03 N04 5.39e-01
L05 N04 N05 7.18e-11
R05 N04 N05 1.80e-02
C06 N05 N06 5.83e-09
L06 N05 N06 2.40e-11
R06 N05 N06 5.42e-01
C07 N06 N07 2.45e-09
L07 N06 N07 2.16e-11
R07 N06 N07 5.68e-01
C08 N07 N08 1.40e-09
L08 N07 N08 1.29e-11
R08 N07 N08 2.60e-01
C09 N08 N09 2.09e-11
L09 N08 N09 1.67e-11
R09 N08 N09 4.40e+00
C10 N09 Port2 1.12e-12
L10 N09 Port2 2.07e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C1H102JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GGM1885C1H120JA16
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H120JA16 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.18e-11
R03 N02 N03 1.60e-01
L04 N03 N04 1.37e-11
R04 N03 N04 2.02e-01
L05 N04 N05 6.45e-11
R05 N04 N05 1.77e-01
C06 N05 N06 3.40e-12
L06 N05 N06 9.84e-11
R06 N05 N06 1.51e+01
C07 N06 Port2 7.41e-13
L07 N06 Port2 3.55e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C1H120JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GGM1885C1H121JA16
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H121JA16 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.24e-12
R03 N02 N03 9.14e-02
L04 N03 N04 7.98e-11
R04 N03 N04 4.51e+00
L05 N04 N05 2.33e-11
R05 N04 N05 9.33e-02
C06 N05 N06 1.82e-09
L06 N05 N06 6.05e-12
R06 N05 N06 2.91e-01
C07 N06 N07 1.59e-10
L07 N06 N07 2.47e-11
R07 N06 N07 1.37e+00
C08 N07 Port2 1.01e-12
L08 N07 Port2 4.99e-10
R08 N07 Port2 3.53e+02
.ENDS GGM1885C1H121JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GGM1885C1H122JA16
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H122JA16 Port1 Port2
C01 Port1 N01 1.18e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 9.17e-11
R03 N02 N03 1.20e-02
L04 N03 N04 5.39e-11
R04 N03 N04 4.53e-01
L05 N04 N05 8.88e-11
R05 N04 N05 2.07e-02
L06 N05 N06 1.19e-11
R06 N05 N06 1.38e-02
C07 N06 N07 1.77e-08
L07 N06 N07 7.31e-12
R07 N06 N07 1.71e-01
C08 N07 N08 1.65e-09
L08 N07 N08 3.31e-11
R08 N07 N08 6.01e-01
C09 N08 Port2 1.01e-12
L09 N08 Port2 3.58e-10
R09 N08 Port2 4.99e+02
.ENDS GGM1885C1H122JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GGM1885C1H150JA16
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H150JA16 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.98e-11
R03 N02 N03 2.10e-01
L04 N03 N04 1.85e-11
R04 N03 N04 2.55e-01
C05 N04 N05 2.10e-12
L05 N04 N05 1.53e-10
R05 N04 N05 3.16e+01
C06 N05 Port2 8.69e-13
L06 N05 Port2 3.06e-10
R06 N05 Port2 1.00e+05
.ENDS GGM1885C1H150JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GGM1885C1H151JA16
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H151JA16 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.42e-11
R03 N02 N03 8.50e-02
L04 N03 N04 8.61e-11
R04 N03 N04 1.87e+00
C05 N04 N05 1.88e-09
L05 N04 N05 8.09e-12
R05 N04 N05 3.87e-01
C06 N05 N06 2.93e-10
L06 N05 N06 2.00e-11
R06 N05 N06 1.08e+00
C07 N06 N07 6.83e-12
L07 N06 N07 5.01e-11
R07 N06 N07 1.18e+01
C08 N07 Port2 6.74e-13
L08 N07 Port2 3.68e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H151JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GGM1885C1H152JA16
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H152JA16 Port1 Port2
C01 Port1 N01 1.47e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.69e-11
R03 N02 N03 1.50e-02
L04 N03 N04 5.04e-11
R04 N03 N04 3.80e-01
L05 N04 N05 1.23e-10
R05 N04 N05 2.76e-02
C06 N05 N06 1.07e-08
L06 N05 N06 1.59e-11
R06 N05 N06 2.42e-01
C07 N06 N07 1.84e-09
L07 N06 N07 4.15e-11
R07 N06 N07 5.96e-01
C08 N07 N08 2.63e-09
L08 N07 N08 9.52e-12
R08 N07 N08 1.88e-01
C09 N08 N09 7.18e-13
L09 N08 N09 3.26e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 2.37e-12
L10 N09 Port2 6.81e-11
R10 N09 Port2 6.44e+00
.ENDS GGM1885C1H152JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GGM1885C1H180JA16
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H180JA16 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.29e-01
L04 N03 N04 5.42e-11
R04 N03 N04 2.94e-01
C05 N04 N05 4.22e-11
L05 N04 N05 4.43e-11
R05 N04 N05 5.07e+00
C06 N05 Port2 7.39e-13
L06 N05 Port2 4.74e-10
R06 N05 Port2 2.95e+02
.ENDS GGM1885C1H180JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GGM1885C1H181JA16
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H181JA16 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 9.57e-11
R04 N03 N04 3.61e+00
C05 N04 N05 9.41e-13
L05 N04 N05 4.12e-10
R05 N04 N05 5.59e+02
C06 N05 N06 3.10e-10
L06 N05 N06 2.55e-11
R06 N05 N06 1.21e+00
C07 N06 Port2 1.37e-09
L07 N06 Port2 1.40e-11
R07 N06 Port2 5.55e-01
.ENDS GGM1885C1H181JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GGM1885C1H182JA16
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H182JA16 Port1 Port2
C01 Port1 N01 1.81e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 2.05e-02
L04 N03 N04 5.19e-11
R04 N03 N04 2.29e-02
C05 N04 N05 1.64e-08
L05 N04 N05 1.29e-11
R05 N04 N05 1.80e-01
C06 N05 N06 3.02e-09
L06 N05 N06 2.50e-11
R06 N05 N06 3.70e-01
C07 N06 N07 8.34e-10
L07 N06 N07 2.40e-11
R07 N06 N07 2.24e-01
C08 N07 N08 8.66e-12
L08 N07 N08 4.55e-11
R08 N07 N08 8.81e-01
C09 N08 Port2 9.61e-13
L09 N08 Port2 2.31e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C1H182JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H1R0CA16
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H1R0CA16 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-10
R03 N02 N03 5.74e-01
C04 N03 Port2 7.58e-12
L04 N03 Port2 3.42e-11
R04 N03 Port2 1.55e+01
.ENDS GGM1885C1H1R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GGM1885C1H1R2CA16
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H1R2CA16 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.08e-10
R03 N02 N03 4.83e-01
L04 N03 N04 4.86e-12
R04 N03 N04 2.22e-01
C05 N04 Port2 8.30e-12
L05 N04 Port2 3.15e-11
R05 N04 Port2 1.28e+01
.ENDS GGM1885C1H1R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GGM1885C1H1R5CA16
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H1R5CA16 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.36e-10
R03 N02 N03 4.42e-01
C04 N03 Port2 4.28e-12
L04 N03 Port2 5.75e-11
R04 N03 Port2 2.51e+01
.ENDS GGM1885C1H1R5CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GGM1885C1H1R8CA16
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H1R8CA16 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.97e-10
R03 N02 N03 4.17e-01
L04 N03 N04 1.98e-12
R04 N03 N04 6.54e-02
C05 N04 Port2 3.21e-12
L05 N04 Port2 8.80e-11
R05 N04 Port2 6.90e+01
.ENDS GGM1885C1H1R8CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GGM1885C1H220JA16
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H220JA16 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.27e-12
R03 N02 N03 1.50e-01
L04 N03 N04 2.29e-11
R04 N03 N04 1.57e-01
C05 N04 N05 2.90e-10
L05 N04 N05 8.91e-12
R05 N04 N05 1.05e+00
C06 N05 N06 1.26e-12
L06 N05 N06 2.54e-10
R06 N05 N06 6.69e+01
C07 N06 Port2 1.01e-12
L07 N06 Port2 2.46e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C1H220JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GGM1885C1H221JA16
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H221JA16 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 9.46e-02
L04 N03 N04 5.00e-11
R04 N03 N04 8.98e-01
L05 N04 N05 1.16e-11
R05 N04 N05 3.50e-02
C06 N05 N06 3.19e-09
L06 N05 N06 6.00e-12
R06 N05 N06 2.04e-01
C07 N06 N07 2.98e-10
L07 N06 N07 2.41e-11
R07 N06 N07 8.75e-01
C08 N07 N08 4.98e-12
L08 N07 N08 5.35e-11
R08 N07 N08 6.35e+00
C09 N08 Port2 7.56e-13
L09 N08 Port2 3.29e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C1H221JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GGM1885C1H222JA16
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H222JA16 Port1 Port2
C01 Port1 N01 2.23e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 1.55e-02
L04 N03 N04 5.14e-11
R04 N03 N04 7.13e-01
L05 N04 N05 6.80e-11
R05 N04 N05 1.43e-02
C06 N05 N06 1.14e-08
L06 N05 N06 2.50e-11
R06 N05 N06 2.67e-01
C07 N06 N07 4.72e-09
L07 N06 N07 2.23e-11
R07 N06 N07 3.43e-01
C08 N07 N08 1.26e-09
L08 N07 N08 2.41e-11
R08 N07 N08 2.09e-01
C09 N08 N09 1.10e-10
L09 N08 N09 2.64e-12
R09 N08 N09 3.79e-01
C10 N09 Port2 1.49e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C1H222JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GGM1885C1H270JA16
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H270JA16 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.80e-12
R03 N02 N03 1.02e-01
L04 N03 N04 2.80e-11
R04 N03 N04 9.99e-02
C05 N04 N05 8.50e-10
L05 N04 N05 3.89e-12
R05 N04 N05 4.30e-01
C06 N05 N06 4.88e-11
L06 N05 N06 2.17e-11
R06 N05 N06 3.15e+00
C07 N06 N07 5.09e-12
L07 N06 N07 6.65e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 7.44e-13
L08 N07 Port2 4.11e-10
R08 N07 Port2 1.51e+02
.ENDS GGM1885C1H270JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GGM1885C1H271JA16
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H271JA16 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 9.00e-02
L04 N03 N04 7.38e-11
R04 N03 N04 1.86e+00
C05 N04 N05 1.01e-12
L05 N04 N05 4.79e-10
R05 N04 N05 7.14e+02
C06 N05 N06 3.98e-10
L06 N05 N06 2.75e-11
R06 N05 N06 7.98e-01
C07 N06 Port2 1.72e-09
L07 N06 Port2 1.63e-11
R07 N06 Port2 3.30e-01
.ENDS GGM1885C1H271JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GGM1885C1H272JA16
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H272JA16 Port1 Port2
C01 Port1 N01 2.71e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.41e-10
R03 N02 N03 1.04e-02
L04 N03 N04 7.56e-11
R04 N03 N04 3.63e-01
L05 N04 N05 7.62e-11
R05 N04 N05 1.78e-02
C06 N05 N06 2.11e-08
L06 N05 N06 1.58e-11
R06 N05 N06 2.37e-01
C07 N06 N07 5.67e-09
L07 N06 N07 2.66e-11
R07 N06 N07 3.92e-01
C08 N07 N08 5.26e-09
L08 N07 N08 9.28e-12
R08 N07 N08 1.13e-01
C09 N08 Port2 6.00e-12
L09 N08 Port2 5.17e-11
R09 N08 Port2 3.46e+01
.ENDS GGM1885C1H272JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H2R0CA16
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H2R0CA16 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.42e-10
R03 N02 N03 3.64e-01
C04 N03 Port2 2.21e-12
L04 N03 Port2 1.33e-10
R04 N03 Port2 1.02e+02
.ENDS GGM1885C1H2R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GGM1885C1H2R2CA16
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H2R2CA16 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.54e-10
R03 N02 N03 3.40e-01
C04 N03 Port2 2.12e-12
L04 N03 Port2 1.35e-10
R04 N03 Port2 8.65e+01
.ENDS GGM1885C1H2R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GGM1885C1H2R4CA16
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H2R4CA16 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.40e-10
R03 N02 N03 3.22e-01
L04 N03 N04 3.99e-12
R04 N03 N04 1.29e-01
C05 N04 Port2 4.01e-12
L05 N04 Port2 7.75e-11
R05 N04 Port2 3.69e+01
.ENDS GGM1885C1H2R4CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GGM1885C1H2R7CA16
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H2R7CA16 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.14e-10
R03 N02 N03 3.08e-01
L04 N03 N04 3.05e-12
R04 N03 N04 1.03e-01
C05 N04 Port2 3.84e-12
L05 N04 Port2 7.85e-11
R05 N04 Port2 3.49e+01
.ENDS GGM1885C1H2R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GGM1885C1H330JA16
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H330JA16 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.64e-11
R03 N02 N03 1.30e-01
L04 N03 N04 1.36e-11
R04 N03 N04 1.05e-01
C05 N04 N05 3.70e-10
L05 N04 N05 1.03e-11
R05 N04 N05 9.32e-01
C06 N05 N06 7.83e-11
L06 N05 N06 1.49e-11
R06 N05 N06 2.34e+00
C07 N06 N07 3.96e-12
L07 N06 N07 7.95e-11
R07 N06 N07 7.59e+00
C08 N07 Port2 7.10e-13
L08 N07 Port2 3.27e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H330JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GGM1885C1H331JA16
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H331JA16 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 7.68e-02
L04 N03 N04 1.49e-11
R04 N03 N04 3.22e-01
C05 N04 N05 2.76e-09
L05 N04 N05 1.31e-11
R05 N04 N05 3.72e-01
C06 N05 N06 4.29e-10
L06 N05 N06 3.33e-11
R06 N05 N06 9.57e-01
C07 N06 N07 1.51e-10
L07 N06 N07 2.20e-11
R07 N06 N07 4.79e-01
C08 N07 N08 4.83e-10
L08 N07 N08 2.06e-12
R08 N07 N08 4.85e-01
C09 N08 N09 2.99e-12
L09 N08 N09 1.07e-10
R09 N08 N09 3.37e+01
C10 N09 Port2 8.93e-13
L10 N09 Port2 2.78e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C1H331JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GGM1885C1H332JA16
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H332JA16 Port1 Port2
C01 Port1 N01 3.31e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 5.56e-12
R03 N02 N03 1.44e-02
L04 N03 N04 6.68e-11
R04 N03 N04 3.80e-01
L05 N04 N05 4.26e-11
R05 N04 N05 1.03e-02
C06 N05 N06 2.49e-08
L06 N05 N06 1.62e-11
R06 N05 N06 2.44e-01
C07 N06 N07 5.06e-09
L07 N06 N07 3.86e-11
R07 N06 N07 4.21e-01
C08 N07 N08 3.78e-09
L08 N07 N08 1.70e-11
R08 N07 N08 1.15e-01
C09 N08 N09 3.45e-11
L09 N08 N09 8.69e-12
R09 N08 N09 9.69e-01
C10 N09 Port2 7.72e-13
L10 N09 Port2 3.15e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C1H332JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GGM1885C1H390JA16
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H390JA16 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.01e-01
L04 N03 N04 2.63e-11
R04 N03 N04 7.26e-02
C05 N04 N05 3.45e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.56e+00
C06 N05 N06 6.24e-11
L06 N05 N06 2.11e-11
R06 N05 N06 2.71e+00
C07 N06 N07 2.35e-12
L07 N06 N07 1.36e-10
R07 N06 N07 1.47e+01
C08 N07 Port2 8.60e-13
L08 N07 Port2 3.47e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H390JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GGM1885C1H391JA16
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H391JA16 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 8.17e-11
R04 N03 N04 4.26e+00
C05 N04 N05 7.55e-13
L05 N04 N05 3.30e-10
C06 N05 N06 2.59e-11
L06 N05 N06 1.49e-11
R06 N05 N06 4.19e+00
C07 N06 N07 4.43e-10
L07 N06 N07 1.22e-11
R07 N06 N07 4.49e-01
C08 N07 N08 5.28e-10
L08 N07 N08 3.33e-11
R08 N07 N08 8.74e-01
C09 N08 Port2 2.54e-09
L09 N08 Port2 2.07e-11
R09 N08 Port2 6.74e-01
.ENDS GGM1885C1H391JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GGM1885C1H392JA16
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H392JA16 Port1 Port2
C01 Port1 N01 3.84e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 7.60e-03
L04 N03 N04 1.02e-10
R04 N03 N04 3.69e-01
L05 N04 N05 5.34e-11
R05 N04 N05 1.33e-02
L06 N05 N06 1.38e-10
R06 N05 N06 5.29e-03
C07 N06 N07 2.13e-08
L07 N06 N07 2.39e-11
R07 N06 N07 3.03e-01
C08 N07 N08 8.43e-09
L08 N07 N08 2.82e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 1.70e-11
L09 N08 Port2 2.15e-11
R09 N08 Port2 5.93e+00
.ENDS GGM1885C1H392JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H3R0CA16
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H3R0CA16 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.18e-10
R03 N02 N03 2.90e-01
C04 N03 Port2 1.25e-12
L04 N03 Port2 2.54e-10
R04 N03 Port2 2.37e+02
.ENDS GGM1885C1H3R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GGM1885C1H3R3CA16
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H3R3CA16 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.45e-10
R03 N02 N03 2.64e-01
L04 N03 N04 1.79e-12
R04 N03 N04 3.66e-02
C05 N04 Port2 1.80e-12
L05 N04 Port2 2.12e-10
R05 N04 Port2 1.79e+02
.ENDS GGM1885C1H3R3CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GGM1885C1H3R6CA16
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H3R6CA16 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.12e-10
R03 N02 N03 2.57e-01
L04 N03 N04 1.08e-11
R04 N03 N04 3.62e-01
C05 N04 Port2 5.98e-12
L05 N04 Port2 6.70e-11
R05 N04 Port2 3.53e+01
.ENDS GGM1885C1H3R6CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GGM1885C1H3R9CA16
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H3R9CA16 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.22e-10
R03 N02 N03 2.53e-01
L04 N03 N04 5.22e-12
R04 N03 N04 1.62e-01
C05 N04 N05 5.17e-12
L05 N04 N05 8.20e-11
R05 N04 N05 4.45e+01
C06 N05 Port2 4.06e-12
L06 N05 Port2 7.69e-11
R06 N05 Port2 7.32e+01
.ENDS GGM1885C1H3R9CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GGM1885C1H470JA16
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H470JA16 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.02e-01
L04 N03 N04 9.02e-12
R04 N03 N04 7.35e-02
C05 N04 N05 3.17e-10
L05 N04 N05 1.92e-11
R05 N04 N05 1.63e+00
C06 N05 N06 8.31e-11
L06 N05 N06 2.18e-11
R06 N05 N06 2.16e+00
C07 N06 N07 3.68e-12
L07 N06 N07 8.20e-11
R07 N06 N07 9.21e+00
C08 N07 Port2 1.22e-12
L08 N07 Port2 2.04e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H470JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GGM1885C1H471JA16
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H471JA16 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.90e-11
R03 N02 N03 6.33e-02
L04 N03 N04 3.93e-11
R04 N03 N04 1.04e+00
C05 N04 N05 3.06e-09
L05 N04 N05 2.00e-11
R05 N04 N05 6.16e-01
C06 N05 N06 7.33e-10
L06 N05 N06 2.84e-11
R06 N05 N06 7.32e-01
C07 N06 N07 4.64e-10
L07 N06 N07 1.27e-11
R07 N06 N07 4.03e-01
C08 N07 N08 7.61e-12
L08 N07 N08 3.95e-11
R08 N07 N08 8.00e+00
C09 N08 Port2 8.13e-13
L09 N08 Port2 2.85e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C1H471JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H4R0CA16
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H4R0CA16 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.25e-10
R03 N02 N03 2.50e-01
L04 N03 N04 7.40e-12
R04 N03 N04 2.30e-01
C05 N04 N05 5.98e-12
L05 N04 N05 7.25e-11
R05 N04 N05 3.99e+01
C06 N05 Port2 3.97e-12
L06 N05 Port2 7.57e-11
R06 N05 Port2 6.85e+01
.ENDS GGM1885C1H4R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GGM1885C1H4R7CA16
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H4R7CA16 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.00e-10
R03 N02 N03 2.45e-01
L04 N03 N04 1.15e-11
R04 N03 N04 3.78e-01
C05 N04 N05 1.69e-11
L05 N04 N05 3.21e-11
R05 N04 N05 1.75e+01
C06 N05 Port2 6.84e-12
L06 N05 Port2 4.55e-11
R06 N05 Port2 2.55e+01
.ENDS GGM1885C1H4R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GGM1885C1H560JA16
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H560JA16 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.43e-11
R03 N02 N03 9.36e-02
L04 N03 N04 3.95e-11
R04 N03 N04 1.81e+00
L05 N04 N05 4.96e-11
R05 N04 N05 1.67e-01
C06 N05 N06 5.34e-10
L06 N05 N06 1.15e-11
R06 N05 N06 7.29e-01
C07 N06 Port2 6.94e-13
L07 N06 Port2 5.05e-10
R07 N06 Port2 2.40e+02
.ENDS GGM1885C1H560JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GGM1885C1H561JA16
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H561JA16 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.03e-11
R04 N03 N04 1.30e+00
C05 N04 N05 9.40e-13
L05 N04 N05 2.64e-10
C06 N05 N06 1.92e-11
L06 N05 N06 1.82e-11
R06 N05 N06 4.34e+00
C07 N06 N07 5.16e-10
L07 N06 N07 1.60e-11
R07 N06 N07 3.36e-01
C08 N07 N08 9.36e-10
L08 N07 N08 2.94e-11
R08 N07 N08 8.03e-01
C09 N08 Port2 2.84e-09
L09 N08 Port2 2.66e-11
R09 N08 Port2 6.77e-01
.ENDS GGM1885C1H561JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H5R0CA16
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H5R0CA16 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.48e-10
R03 N02 N03 2.45e-01
L04 N03 N04 4.00e-12
R04 N03 N04 5.70e-02
C05 N04 N05 1.31e-11
L05 N04 N05 4.40e-11
R05 N04 N05 2.47e+01
C06 N05 Port2 4.36e-12
L06 N05 Port2 7.93e-11
R06 N05 Port2 3.92e+01
.ENDS GGM1885C1H5R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GGM1885C1H5R6DA16
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H5R6DA16 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 2.41e-01
C04 N03 N04 1.79e-11
L04 N03 N04 3.54e-11
R04 N03 N04 1.89e+01
C05 N04 Port2 2.62e-12
L05 N04 Port2 1.26e-10
R05 N04 Port2 5.89e+01
.ENDS GGM1885C1H5R6DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GGM1885C1H680JA16
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H680JA16 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.67e-12
R03 N02 N03 1.40e-01
L04 N03 N04 7.84e-11
R04 N03 N04 2.96e+00
L05 N04 N05 7.78e-13
R05 N04 N05 4.79e-03
C06 N05 N06 8.28e-10
L06 N05 N06 9.34e-12
R06 N05 N06 5.69e-01
C07 N06 N07 2.34e-12
L07 N06 N07 1.36e-10
R07 N06 N07 6.09e+01
C08 N07 Port2 7.45e-13
L08 N07 Port2 3.41e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C1H680JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GGM1885C1H681JA16
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H681JA16 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.94e-10
R03 N02 N03 6.00e-02
L04 N03 N04 4.78e-11
R04 N03 N04 6.28e+00
L05 N04 N05 4.96e-11
R05 N04 N05 7.39e-01
C06 N05 N06 4.86e-09
L06 N05 N06 1.87e-11
R06 N05 N06 3.84e-01
C07 N06 N07 1.03e-09
L07 N06 N07 3.01e-11
R07 N06 N07 5.69e-01
C08 N07 N08 1.38e-09
L08 N07 N08 6.98e-12
R08 N07 N08 2.33e-01
C09 N08 N09 5.10e-10
L09 N08 N09 2.02e-12
R09 N08 N09 8.65e-01
C10 N09 Port2 1.68e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C1H681JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H6R0DA16
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H6R0DA16 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.76e-10
R03 N02 N03 2.34e-01
L04 N03 N04 5.49e-12
R04 N03 N04 8.11e-02
C05 N04 N05 2.22e-11
L05 N04 N05 2.53e-11
R05 N04 N05 1.04e+01
C06 N05 Port2 3.08e-12
L06 N05 Port2 1.09e-10
R06 N05 Port2 5.77e+01
.ENDS GGM1885C1H6R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GGM1885C1H6R8DA16
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H6R8DA16 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.08e-10
R03 N02 N03 2.13e-01
C04 N03 N04 3.57e-11
L04 N03 N04 1.98e-11
R04 N03 N04 9.94e+00
C05 N04 Port2 2.01e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 7.25e+01
.ENDS GGM1885C1H6R8DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H7R0DA16
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H7R0DA16 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 2.10e-01
C04 N03 N04 2.58e-11
L04 N03 N04 2.87e-11
R04 N03 N04 1.37e+01
C05 N04 Port2 1.62e-12
L05 N04 Port2 2.07e-10
R05 N04 Port2 1.30e+02
.ENDS GGM1885C1H7R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GGM1885C1H820JA16
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H820JA16 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.11e-11
R03 N02 N03 8.60e-02
L04 N03 N04 3.59e-11
R04 N03 N04 1.01e-01
C05 N04 N05 6.43e-10
L05 N04 N05 1.50e-11
R05 N04 N05 7.19e-01
C06 N05 N06 1.83e-10
L06 N05 N06 1.42e-11
R06 N05 N06 8.48e-01
C07 N06 N07 8.69e-13
L07 N06 N07 3.24e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 1.10e-12
L08 N07 Port2 2.01e-10
R08 N07 Port2 2.39e+01
.ENDS GGM1885C1H820JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GGM1885C1H821JA16
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H821JA16 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 4.50e-11
R03 N02 N03 3.30e-02
L04 N03 N04 9.08e-11
R04 N03 N04 7.13e-01
C05 N04 N05 5.00e-13
L05 N04 N05 3.30e-10
C06 N05 N06 3.11e-11
L06 N05 N06 1.27e-11
R06 N05 N06 1.53e+00
C07 N06 N07 2.27e-09
L07 N06 N07 6.25e-12
R07 N06 N07 1.75e-01
C08 N07 N08 1.65e-09
L08 N07 N08 2.53e-11
R08 N07 N08 5.72e-01
C09 N08 Port2 6.39e-09
L09 N08 Port2 1.76e-11
R09 N08 Port2 4.85e-01
.ENDS GGM1885C1H821JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H8R0DA16
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H8R0DA16 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.19e-10
R03 N02 N03 2.14e-01
C04 N03 N04 3.15e-11
L04 N03 N04 2.80e-11
R04 N03 N04 1.30e+01
C05 N04 Port2 3.54e-12
L05 N04 Port2 1.11e-10
R05 N04 Port2 3.90e+01
.ENDS GGM1885C1H8R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GGM1885C1H8R2DA16
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H8R2DA16 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 2.12e-01
L04 N03 N04 2.49e-12
R04 N03 N04 5.25e-02
C05 N04 N05 3.29e-11
L05 N04 N05 2.72e-11
R05 N04 N05 1.18e+01
C06 N05 Port2 4.12e-12
L06 N05 Port2 9.84e-11
R06 N05 Port2 3.70e+01
.ENDS GGM1885C1H8R2DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GGM1885C1H9R0DA16
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1H9R0DA16 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.92e-10
R03 N02 N03 1.97e-01
L04 N03 N04 1.70e-12
R04 N03 N04 3.72e-02
C05 N04 N05 4.09e-11
L05 N04 N05 2.51e-11
R05 N04 N05 1.09e+01
C06 N05 N06 5.42e-12
L06 N05 N06 8.52e-11
R06 N05 N06 2.97e+01
C07 N06 Port2 5.99e-12
L07 N06 Port2 5.39e-11
R07 N06 Port2 6.98e+01
.ENDS GGM1885C1H9R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GGM1885C1HR50BA16
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C1HR50BA16 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 5.25e-10
R03 N02 N03 8.21e-01
L04 N03 Port2 1.37e-11
R04 N03 Port2 7.34e-01
.ENDS GGM1885C1HR50BA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GGM1885C2A100JA16
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A100JA16 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.31e-10
R03 N02 N03 1.79e-01
L04 N03 N04 3.69e-11
R04 N03 N04 3.67e-01
L05 N04 N05 1.85e-11
R05 N04 N05 7.60e-02
C06 N05 N06 1.24e-11
L06 N05 N06 4.62e-11
R06 N05 N06 9.89e+00
C07 N06 N07 2.91e-12
L07 N06 N07 1.14e-10
R07 N06 N07 2.68e+01
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.47e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A100JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GGM1885C2A101JA16
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A101JA16 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.09e-11
R03 N02 N03 8.99e-02
L04 N03 N04 4.29e-11
R04 N03 N04 1.57e-01
C05 N04 N05 1.03e-10
L05 N04 N05 2.90e-11
R05 N04 N05 1.37e+00
C06 N05 N06 3.48e-12
L06 N05 N06 9.43e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 5.94e-13
L07 N06 Port2 4.38e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A101JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GGM1885C2A102JA16
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A102JA16 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.11e-10
R03 N02 N03 2.19e-02
L04 N03 N04 4.69e-11
R04 N03 N04 4.85e-01
L05 N04 N05 5.09e-11
R05 N04 N05 1.63e-02
C06 N05 N06 4.28e-09
L06 N05 N06 3.32e-11
R06 N05 N06 5.56e-01
C07 N06 N07 1.79e-09
L07 N06 N07 3.08e-11
R07 N06 N07 6.20e-01
C08 N07 N08 8.50e-09
L08 N07 N08 3.79e-12
R08 N07 N08 1.30e-01
C09 N08 N09 9.54e-10
L09 N08 N09 1.81e-11
R09 N08 N09 3.47e-01
C10 N09 N10 4.40e-12
L10 N09 N10 6.64e-11
R10 N09 N10 1.00e+05
C11 N10 Port2 5.32e-12
L11 N10 Port2 4.71e-11
R11 N10 Port2 3.34e+00
.ENDS GGM1885C2A102JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GGM1885C2A120JA16
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A120JA16 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.18e-11
R03 N02 N03 1.60e-01
L04 N03 N04 1.37e-11
R04 N03 N04 2.02e-01
L05 N04 N05 6.45e-11
R05 N04 N05 1.77e-01
C06 N05 N06 3.40e-12
L06 N05 N06 9.84e-11
R06 N05 N06 1.51e+01
C07 N06 Port2 7.41e-13
L07 N06 Port2 3.55e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A120JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GGM1885C2A121JA16
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A121JA16 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.24e-12
R03 N02 N03 9.14e-02
L04 N03 N04 7.98e-11
R04 N03 N04 4.51e+00
L05 N04 N05 2.33e-11
R05 N04 N05 9.33e-02
C06 N05 N06 1.82e-09
L06 N05 N06 6.05e-12
R06 N05 N06 2.91e-01
C07 N06 N07 1.59e-10
L07 N06 N07 2.47e-11
R07 N06 N07 1.37e+00
C08 N07 Port2 1.01e-12
L08 N07 Port2 4.99e-10
R08 N07 Port2 3.53e+02
.ENDS GGM1885C2A121JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GGM1885C2A122JA16
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A122JA16 Port1 Port2
C01 Port1 N01 1.18e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 9.17e-11
R03 N02 N03 1.20e-02
L04 N03 N04 5.39e-11
R04 N03 N04 4.53e-01
L05 N04 N05 8.88e-11
R05 N04 N05 2.07e-02
L06 N05 N06 1.19e-11
R06 N05 N06 1.38e-02
C07 N06 N07 1.77e-08
L07 N06 N07 7.31e-12
R07 N06 N07 1.71e-01
C08 N07 N08 1.65e-09
L08 N07 N08 3.31e-11
R08 N07 N08 6.01e-01
C09 N08 Port2 1.01e-12
L09 N08 Port2 3.58e-10
R09 N08 Port2 4.99e+02
.ENDS GGM1885C2A122JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GGM1885C2A150JA16
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A150JA16 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.78e-11
R03 N02 N03 1.45e-01
L04 N03 N04 1.72e-11
R04 N03 N04 1.83e-01
L05 N04 N05 2.25e-11
R05 N04 N05 7.30e-02
C06 N05 N06 1.93e-12
L06 N05 N06 1.66e-10
R06 N05 N06 3.59e+01
C07 N06 Port2 8.04e-13
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A150JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GGM1885C2A151JA16
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A151JA16 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.58e-12
R03 N02 N03 8.50e-02
L04 N03 N04 8.47e-11
R04 N03 N04 1.87e+00
C05 N04 N05 1.49e-09
L05 N04 N05 9.98e-12
R05 N04 N05 3.96e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.94e-11
R06 N05 N06 1.04e+00
C07 N06 N07 5.99e-12
L07 N06 N07 5.75e-11
R07 N06 N07 1.65e+01
C08 N07 Port2 6.25e-13
L08 N07 Port2 3.97e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A151JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GGM1885C2A152JA16
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A152JA16 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.65e-10
R03 N02 N03 1.70e-02
L04 N03 N04 5.16e-11
R04 N03 N04 5.07e-01
L05 N04 N05 1.13e-10
R05 N04 N05 2.92e-02
C06 N05 N06 9.04e-09
L06 N05 N06 2.01e-11
R06 N05 N06 2.38e-01
C07 N06 N07 2.77e-09
L07 N06 N07 3.03e-11
R07 N06 N07 4.23e-01
C08 N07 N08 1.14e-09
L08 N07 N08 2.10e-11
R08 N07 N08 1.74e-01
C09 N08 N09 1.83e-11
L09 N08 N09 2.03e-11
R09 N08 N09 1.03e+00
C10 N09 Port2 1.20e-12
L10 N09 Port2 2.27e-10
R10 N09 Port2 1.00e+05
.ENDS GGM1885C2A152JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GGM1885C2A180JA16
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A180JA16 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.29e-01
L04 N03 N04 5.42e-11
R04 N03 N04 2.94e-01
C05 N04 N05 4.22e-11
L05 N04 N05 4.43e-11
R05 N04 N05 5.07e+00
C06 N05 Port2 7.39e-13
L06 N05 Port2 4.74e-10
R06 N05 Port2 2.95e+02
.ENDS GGM1885C2A180JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GGM1885C2A181JA16
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A181JA16 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 9.57e-11
R04 N03 N04 3.61e+00
C05 N04 N05 9.41e-13
L05 N04 N05 4.12e-10
R05 N04 N05 5.59e+02
C06 N05 N06 3.10e-10
L06 N05 N06 2.55e-11
R06 N05 N06 1.21e+00
C07 N06 Port2 1.37e-09
L07 N06 Port2 1.40e-11
R07 N06 Port2 5.55e-01
.ENDS GGM1885C2A181JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A1R0CA16
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A1R0CA16 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.29e-10
R03 N02 N03 3.62e-01
L04 N03 N04 4.22e-11
R04 N03 N04 2.27e-01
C05 N04 N05 2.44e-11
L05 N04 N05 1.31e-11
R05 N04 N05 1.00e+05
C06 N05 Port2 2.61e-11
L06 N05 Port2 1.01e-11
R06 N05 Port2 1.58e+00
.ENDS GGM1885C2A1R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GGM1885C2A1R2CA16
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A1R2CA16 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.08e-10
R03 N02 N03 4.83e-01
L04 N03 N04 4.86e-12
R04 N03 N04 2.22e-01
C05 N04 Port2 8.30e-12
L05 N04 Port2 3.15e-11
R05 N04 Port2 1.28e+01
.ENDS GGM1885C2A1R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GGM1885C2A1R5CA16
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A1R5CA16 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.36e-10
R03 N02 N03 4.42e-01
C04 N03 Port2 4.28e-12
L04 N03 Port2 5.75e-11
R04 N03 Port2 2.51e+01
.ENDS GGM1885C2A1R5CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GGM1885C2A1R8CA16
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A1R8CA16 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.97e-10
R03 N02 N03 4.17e-01
L04 N03 N04 1.98e-12
R04 N03 N04 6.54e-02
C05 N04 Port2 3.21e-12
L05 N04 Port2 8.80e-11
R05 N04 Port2 6.90e+01
.ENDS GGM1885C2A1R8CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GGM1885C2A220JA16
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A220JA16 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.37e-11
R03 N02 N03 1.12e-01
L04 N03 N04 3.13e-11
R04 N03 N04 1.03e-01
C05 N04 N05 3.33e-10
L05 N04 N05 7.74e-12
R05 N04 N05 9.78e-01
C06 N05 N06 1.28e-12
L06 N05 N06 2.48e-10
R06 N05 N06 6.86e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A220JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GGM1885C2A221JA16
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A221JA16 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 9.00e-02
L04 N03 N04 6.40e-11
R04 N03 N04 1.28e+00
C05 N04 N05 2.17e-09
L05 N04 N05 8.83e-12
R05 N04 N05 2.20e-01
C06 N05 N06 3.09e-10
L06 N05 N06 2.29e-11
R06 N05 N06 8.04e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.61e-12
R07 N06 N07 5.79e-01
C08 N07 N08 3.00e-12
L08 N07 N08 1.19e-10
R08 N07 N08 5.44e+01
C09 N08 Port2 7.69e-13
L09 N08 Port2 3.62e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C2A221JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GGM1885C2A270JA16
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A270JA16 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.80e-12
R03 N02 N03 1.02e-01
L04 N03 N04 2.80e-11
R04 N03 N04 9.99e-02
C05 N04 N05 8.50e-10
L05 N04 N05 3.89e-12
R05 N04 N05 4.30e-01
C06 N05 N06 4.88e-11
L06 N05 N06 2.17e-11
R06 N05 N06 3.15e+00
C07 N06 N07 5.09e-12
L07 N06 N07 6.65e-11
R07 N06 N07 1.01e+02
C08 N07 Port2 7.44e-13
L08 N07 Port2 4.11e-10
R08 N07 Port2 1.51e+02
.ENDS GGM1885C2A270JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GGM1885C2A271JA16
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A271JA16 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 9.00e-02
L04 N03 N04 7.38e-11
R04 N03 N04 1.86e+00
C05 N04 N05 1.01e-12
L05 N04 N05 4.79e-10
R05 N04 N05 7.14e+02
C06 N05 N06 3.98e-10
L06 N05 N06 2.75e-11
R06 N05 N06 7.98e-01
C07 N06 Port2 1.72e-09
L07 N06 Port2 1.63e-11
R07 N06 Port2 3.30e-01
.ENDS GGM1885C2A271JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A2R0CA16
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A2R0CA16 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.27e-10
R03 N02 N03 2.45e-01
L04 N03 N04 3.13e-11
R04 N03 N04 2.81e-01
C05 N04 N05 1.86e-11
L05 N04 N05 1.52e-11
R05 N04 N05 1.49e+00
C06 N05 Port2 2.34e-12
L06 N05 Port2 1.06e-10
R06 N05 Port2 1.00e+05
.ENDS GGM1885C2A2R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GGM1885C2A2R2CA16
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A2R2CA16 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.54e-10
R03 N02 N03 3.40e-01
C04 N03 Port2 2.12e-12
L04 N03 Port2 1.35e-10
R04 N03 Port2 8.65e+01
.ENDS GGM1885C2A2R2CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GGM1885C2A2R4CA16
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A2R4CA16 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.40e-10
R03 N02 N03 3.22e-01
L04 N03 N04 3.99e-12
R04 N03 N04 1.29e-01
C05 N04 Port2 4.01e-12
L05 N04 Port2 7.75e-11
R05 N04 Port2 3.69e+01
.ENDS GGM1885C2A2R4CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GGM1885C2A2R7CA16
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A2R7CA16 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.14e-10
R03 N02 N03 3.08e-01
L04 N03 N04 3.05e-12
R04 N03 N04 1.03e-01
C05 N04 Port2 3.84e-12
L05 N04 Port2 7.85e-11
R05 N04 Port2 3.49e+01
.ENDS GGM1885C2A2R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GGM1885C2A330JA16
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A330JA16 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.50e-11
R03 N02 N03 1.06e-01
L04 N03 N04 3.17e-11
R04 N03 N04 1.75e-01
C05 N04 N05 9.91e-10
L05 N04 N05 3.59e-12
R05 N04 N05 3.10e-01
C06 N05 N06 5.48e-11
L06 N05 N06 2.02e-11
R06 N05 N06 2.56e+00
C07 N06 N07 5.15e-12
L07 N06 N07 7.08e-11
R07 N06 N07 1.20e+01
C08 N07 Port2 6.14e-13
L08 N07 Port2 3.86e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A330JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GGM1885C2A331JA16
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A331JA16 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-10
R03 N02 N03 7.49e-02
L04 N03 N04 3.21e-11
R04 N03 N04 8.25e-01
C05 N04 N05 5.50e-10
L05 N04 N05 2.59e-11
R05 N04 N05 7.96e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.17e-11
R06 N05 N06 3.72e-01
C07 N06 N07 2.09e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.21e+00
C08 N07 Port2 6.97e-13
L08 N07 Port2 3.40e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A331JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GGM1885C2A390JA16
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A390JA16 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.01e-01
L04 N03 N04 2.63e-11
R04 N03 N04 7.26e-02
C05 N04 N05 3.45e-10
L05 N04 N05 1.39e-11
R05 N04 N05 1.56e+00
C06 N05 N06 6.24e-11
L06 N05 N06 2.11e-11
R06 N05 N06 2.71e+00
C07 N06 N07 2.35e-12
L07 N06 N07 1.36e-10
R07 N06 N07 1.47e+01
C08 N07 Port2 8.60e-13
L08 N07 Port2 3.47e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A390JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GGM1885C2A391JA16
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A391JA16 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 5.00e-02
L04 N03 N04 9.07e-11
R04 N03 N04 1.22e+00
C05 N04 N05 6.15e-13
L05 N04 N05 3.81e-10
C06 N05 N06 4.22e-11
L06 N05 N06 9.62e-12
R06 N05 N06 1.97e+00
C07 N06 N07 2.26e-09
L07 N06 N07 2.35e-12
R07 N06 N07 1.41e-01
C08 N07 N08 8.59e-10
L08 N07 N08 2.05e-11
R08 N07 N08 6.21e-01
C09 N08 Port2 2.58e-09
L09 N08 Port2 2.03e-11
R09 N08 Port2 6.63e-01
.ENDS GGM1885C2A391JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A3R0CA16
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A3R0CA16 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.40e-10
R03 N02 N03 1.70e-01
L04 N03 N04 1.65e-11
R04 N03 N04 3.18e-01
L05 N04 N05 3.15e-11
R05 N04 N05 1.41e-01
C06 N05 N06 1.08e-11
L06 N05 N06 2.79e-11
R06 N05 N06 5.51e+00
C07 N06 Port2 6.58e-12
L07 N06 Port2 4.50e-11
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A3R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GGM1885C2A3R3CA16
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A3R3CA16 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.45e-10
R03 N02 N03 2.64e-01
L04 N03 N04 1.79e-12
R04 N03 N04 3.66e-02
C05 N04 Port2 1.80e-12
L05 N04 Port2 2.12e-10
R05 N04 Port2 1.79e+02
.ENDS GGM1885C2A3R3CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GGM1885C2A3R6CA16
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A3R6CA16 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.12e-10
R03 N02 N03 2.57e-01
L04 N03 N04 1.08e-11
R04 N03 N04 3.62e-01
C05 N04 Port2 5.98e-12
L05 N04 Port2 6.70e-11
R05 N04 Port2 3.53e+01
.ENDS GGM1885C2A3R6CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GGM1885C2A3R9CA16
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A3R9CA16 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.22e-10
R03 N02 N03 2.53e-01
L04 N03 N04 5.22e-12
R04 N03 N04 1.62e-01
C05 N04 N05 5.17e-12
L05 N04 N05 8.20e-11
R05 N04 N05 4.45e+01
C06 N05 Port2 4.06e-12
L06 N05 Port2 7.69e-11
R06 N05 Port2 7.32e+01
.ENDS GGM1885C2A3R9CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GGM1885C2A470JA16
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A470JA16 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.30e-11
R03 N02 N03 9.36e-02
L04 N03 N04 1.81e-11
R04 N03 N04 5.64e-02
C05 N04 N05 3.41e-10
L05 N04 N05 1.76e-11
R05 N04 N05 1.46e+00
C06 N05 N06 8.02e-11
L06 N05 N06 2.24e-11
R06 N05 N06 2.28e+00
C07 N06 N07 3.40e-12
L07 N06 N07 8.37e-11
R07 N06 N07 8.18e+00
C08 N07 Port2 8.47e-13
L08 N07 Port2 2.74e-10
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A470JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GGM1885C2A471JA16
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A471JA16 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.05e-10
R03 N02 N03 5.73e-02
L04 N03 N04 2.47e-11
R04 N03 N04 5.08e-01
C05 N04 N05 2.92e-09
L05 N04 N05 2.15e-11
R05 N04 N05 6.77e-01
C06 N05 N06 8.44e-10
L06 N05 N06 2.40e-11
R06 N05 N06 7.31e-01
C07 N06 N07 3.52e-10
L07 N06 N07 1.75e-11
R07 N06 N07 4.36e-01
C08 N07 N08 3.96e-12
L08 N07 N08 6.72e-11
R08 N07 N08 7.97e+00
C09 N08 Port2 1.06e-12
L09 N08 Port2 2.33e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C2A471JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A4R0CA16
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A4R0CA16 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.09e-10
R03 N02 N03 1.54e-01
L04 N03 N04 2.07e-11
R04 N03 N04 5.72e-01
L05 N04 N05 2.04e-11
R05 N04 N05 1.20e-01
C06 N05 N06 1.50e-11
L06 N05 N06 2.86e-11
R06 N05 N06 1.37e+01
C07 N06 Port2 4.25e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A4R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GGM1885C2A4R7CA16
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A4R7CA16 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.00e-10
R03 N02 N03 2.45e-01
L04 N03 N04 1.15e-11
R04 N03 N04 3.78e-01
C05 N04 N05 1.69e-11
L05 N04 N05 3.21e-11
R05 N04 N05 1.75e+01
C06 N05 Port2 6.84e-12
L06 N05 Port2 4.55e-11
R06 N05 Port2 2.55e+01
.ENDS GGM1885C2A4R7CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GGM1885C2A560JA16
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A560JA16 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.43e-11
R03 N02 N03 9.36e-02
L04 N03 N04 3.95e-11
R04 N03 N04 1.81e+00
L05 N04 N05 4.96e-11
R05 N04 N05 1.67e-01
C06 N05 N06 5.34e-10
L06 N05 N06 1.15e-11
R06 N05 N06 7.29e-01
C07 N06 Port2 6.94e-13
L07 N06 Port2 5.05e-10
R07 N06 Port2 2.40e+02
.ENDS GGM1885C2A560JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GGM1885C2A561JA16
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A561JA16 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 6.03e-11
R04 N03 N04 1.30e+00
C05 N04 N05 9.40e-13
L05 N04 N05 2.64e-10
C06 N05 N06 1.92e-11
L06 N05 N06 1.82e-11
R06 N05 N06 4.34e+00
C07 N06 N07 5.16e-10
L07 N06 N07 1.60e-11
R07 N06 N07 3.36e-01
C08 N07 N08 9.36e-10
L08 N07 N08 2.94e-11
R08 N07 N08 8.03e-01
C09 N08 Port2 2.84e-09
L09 N08 Port2 2.66e-11
R09 N08 Port2 6.77e-01
.ENDS GGM1885C2A561JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A5R0CA16
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A5R0CA16 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.45e-10
R03 N02 N03 1.42e-01
L04 N03 N04 2.85e-11
R04 N03 N04 1.94e-01
C05 N04 N05 1.78e-11
L05 N04 N05 3.23e-11
R05 N04 N05 1.55e+01
C06 N05 N06 6.36e-12
L06 N05 N06 4.90e-11
R06 N05 N06 2.07e+01
C07 N06 Port2 4.62e-12
L07 N06 Port2 6.34e-11
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A5R0CA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GGM1885C2A5R6DA16
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A5R6DA16 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 2.41e-01
C04 N03 N04 1.79e-11
L04 N03 N04 3.54e-11
R04 N03 N04 1.89e+01
C05 N04 Port2 2.62e-12
L05 N04 Port2 1.26e-10
R05 N04 Port2 5.89e+01
.ENDS GGM1885C2A5R6DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GGM1885C2A680JA16
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A680JA16 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.56e-11
R03 N02 N03 9.03e-02
L04 N03 N04 3.55e-11
R04 N03 N04 1.14e-01
C05 N04 N05 3.35e-09
L05 N04 N05 2.17e-12
R05 N04 N05 1.10e-01
C06 N05 N06 8.09e-11
L06 N05 N06 2.26e-11
R06 N05 N06 1.06e+00
C07 N06 N07 2.02e-12
L07 N06 N07 1.62e-10
R07 N06 N07 5.69e+01
C08 N07 Port2 6.90e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 3.16e+07
.ENDS GGM1885C2A680JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GGM1885C2A681JA16
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A681JA16 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.66e-11
R03 N02 N03 5.45e-02
L04 N03 N04 3.14e-11
R04 N03 N04 1.32e+00
L05 N04 N05 6.44e-11
R05 N04 N05 4.02e-01
C06 N05 N06 6.92e-09
L06 N05 N06 1.31e-11
R06 N05 N06 3.50e-01
C07 N06 N07 1.89e-09
L07 N06 N07 1.69e-11
R07 N06 N07 4.75e-01
C08 N07 N08 2.85e-11
L08 N07 N08 1.17e-11
R08 N07 N08 5.70e+00
C09 N08 Port2 7.27e-13
L09 N08 Port2 3.19e-10
R09 N08 Port2 1.00e+05
.ENDS GGM1885C2A681JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A6R0DA16
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A6R0DA16 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.60e-10
R03 N02 N03 1.38e-01
L04 N03 N04 1.72e-11
R04 N03 N04 4.49e-01
L05 N04 N05 4.02e-11
R05 N04 N05 1.53e-01
C06 N05 N06 1.20e-11
L06 N05 N06 2.48e-11
R06 N05 N06 3.45e+00
C07 N06 Port2 1.91e-12
L07 N06 Port2 1.32e-10
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A6R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GGM1885C2A6R8DA16
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A6R8DA16 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.08e-10
R03 N02 N03 2.13e-01
C04 N03 N04 3.57e-11
L04 N03 N04 1.98e-11
R04 N03 N04 9.94e+00
C05 N04 Port2 2.01e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 7.25e+01
.ENDS GGM1885C2A6R8DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A7R0DA16
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A7R0DA16 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.11e-10
R03 N02 N03 1.32e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.70e-01
L05 N04 N05 4.67e-11
R05 N04 N05 1.63e-01
C06 N05 N06 5.96e-12
L06 N05 N06 5.38e-11
R06 N05 N06 1.33e+01
C07 N06 Port2 1.16e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GGM1885C2A7R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GGM1885C2A820JA16
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A820JA16 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.11e-11
R03 N02 N03 8.60e-02
L04 N03 N04 3.59e-11
R04 N03 N04 1.01e-01
C05 N04 N05 6.43e-10
L05 N04 N05 1.50e-11
R05 N04 N05 7.19e-01
C06 N05 N06 1.83e-10
L06 N05 N06 1.42e-11
R06 N05 N06 8.48e-01
C07 N06 N07 8.69e-13
L07 N06 N07 3.24e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 1.10e-12
L08 N07 Port2 2.01e-10
R08 N07 Port2 2.39e+01
.ENDS GGM1885C2A820JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GGM1885C2A821JA16
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A821JA16 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 4.50e-11
R03 N02 N03 3.30e-02
L04 N03 N04 9.08e-11
R04 N03 N04 7.13e-01
C05 N04 N05 5.00e-13
L05 N04 N05 3.30e-10
C06 N05 N06 3.11e-11
L06 N05 N06 1.27e-11
R06 N05 N06 1.53e+00
C07 N06 N07 2.27e-09
L07 N06 N07 6.25e-12
R07 N06 N07 1.75e-01
C08 N07 N08 1.65e-09
L08 N07 N08 2.53e-11
R08 N07 N08 5.72e-01
C09 N08 Port2 6.39e-09
L09 N08 Port2 1.76e-11
R09 N08 Port2 4.85e-01
.ENDS GGM1885C2A821JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A8R0DA16
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A8R0DA16 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 1.29e-01
L04 N03 N04 2.81e-11
R04 N03 N04 1.21e-01
C05 N04 N05 3.15e-11
L05 N04 N05 2.88e-11
R05 N04 N05 1.20e+01
C06 N05 N06 6.27e-12
L06 N05 N06 6.72e-11
R06 N05 N06 2.51e+01
C07 N06 Port2 1.63e-11
L07 N06 Port2 1.96e-11
R07 N06 Port2 4.09e+01
.ENDS GGM1885C2A8R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GGM1885C2A8R2DA16
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A8R2DA16 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 2.12e-01
L04 N03 N04 2.49e-12
R04 N03 N04 5.25e-02
C05 N04 N05 3.29e-11
L05 N04 N05 2.72e-11
R05 N04 N05 1.18e+01
C06 N05 Port2 4.12e-12
L06 N05 Port2 9.84e-11
R06 N05 Port2 3.70e+01
.ENDS GGM1885C2A8R2DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GGM1885C2A9R0DA16
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2A9R0DA16 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.21e-10
R03 N02 N03 1.16e-01
L04 N03 N04 7.31e-12
R04 N03 N04 1.08e-01
L05 N04 N05 2.31e-11
R05 N04 N05 1.03e-01
C06 N05 N06 3.73e-11
L06 N05 N06 2.75e-11
R06 N05 N06 1.23e+01
C07 N06 N07 7.08e-12
L07 N06 N07 6.43e-11
R07 N06 N07 2.16e+01
C08 N07 Port2 5.13e-12
L08 N07 Port2 5.71e-11
R08 N07 Port2 1.00e+05
.ENDS GGM1885C2A9R0DA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-07[uF]/100[V]
* Murata P/N :GGM1885C2AR50BA16
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM1885C2AR50BA16 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 5.25e-10
R03 N02 N03 8.21e-01
L04 N03 Port2 1.37e-11
R04 N03 Port2 7.34e-01
.ENDS GGM1885C2AR50BA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GGM2165C2A101JA16
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A101JA16 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.38e-11
R03 N02 N03 1.10e-01
L04 N03 N04 1.44e-11
R04 N03 N04 3.14e-01
C05 N04 N05 5.91e-10
L05 N04 N05 9.55e-12
R05 N04 N05 7.15e-01
C06 N05 N06 7.24e-11
L06 N05 N06 2.37e-11
R06 N05 N06 1.71e+00
C07 N06 N07 2.65e-12
L07 N06 N07 7.17e-11
R07 N06 N07 9.05e+00
C08 N07 Port2 6.39e-13
L08 N07 Port2 2.96e-10
R08 N07 Port2 1.00e+05
.ENDS GGM2165C2A101JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GGM2165C2A102JA16
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A102JA16 Port1 Port2
C01 Port1 N01 9.81e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.16e-11
R03 N02 N03 2.28e-02
C04 N03 N04 1.24e-08
L04 N03 N04 8.80e-11
R04 N03 N04 2.65e-02
C05 N04 N05 3.72e-09
L05 N04 N05 1.32e-11
R05 N04 N05 1.37e-01
C06 N05 N06 5.49e-10
L06 N05 N06 2.53e-11
R06 N05 N06 3.34e-01
C07 N06 N07 4.72e-12
L07 N06 N07 5.28e-11
R07 N06 N07 8.20e-01
C08 N07 Port2 5.35e-13
L08 N07 Port2 4.19e-10
R08 N07 Port2 9.12e+04
.ENDS GGM2165C2A102JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GGM2165C2A121JA16
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A121JA16 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.52e-11
R03 N02 N03 1.00e-01
C04 N03 N04 3.90e-10
L04 N03 N04 1.82e-11
R04 N03 N04 1.13e+00
C05 N04 N05 9.56e-11
L05 N04 N05 2.43e-11
R05 N04 N05 1.99e+00
C06 N05 N06 1.37e-12
L06 N05 N06 2.29e-10
R06 N05 N06 8.93e+01
C07 N06 Port2 2.14e-12
L07 N06 Port2 1.05e-10
R07 N06 Port2 1.00e+05
.ENDS GGM2165C2A121JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GGM2165C2A122JA16
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A122JA16 Port1 Port2
C01 Port1 N01 1.17e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.05e-10
R03 N02 N03 2.00e-02
L04 N03 N04 7.29e-11
R04 N03 N04 3.43e-02
C05 N04 N05 5.94e-09
L05 N04 N05 1.11e-11
R05 N04 N05 1.64e-01
C06 N05 N06 7.50e-10
L06 N05 N06 2.51e-11
R06 N05 N06 3.71e-01
C07 N06 N07 1.06e-12
L07 N06 N07 2.14e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 3.91e-12
L08 N07 Port2 5.02e-11
R08 N07 Port2 1.13e+00
.ENDS GGM2165C2A122JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GGM2165C2A151JA16
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A151JA16 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.87e-10
R03 N02 N03 9.34e-02
C04 N03 N04 4.52e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.70e-01
C05 N04 N05 1.13e-10
L05 N04 N05 2.46e-11
R05 N04 N05 1.75e+00
C06 N05 N06 1.22e-11
L06 N05 N06 3.85e-11
R06 N05 N06 2.18e+00
C07 N06 Port2 1.09e-12
L07 N06 Port2 2.07e-10
R07 N06 Port2 1.00e+05
.ENDS GGM2165C2A151JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GGM2165C2A152JA16
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A152JA16 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.98e-11
R03 N02 N03 1.38e-02
L04 N03 N04 5.98e-11
R04 N03 N04 5.18e-01
L05 N04 N05 7.30e-11
R05 N04 N05 2.45e-02
C06 N05 N06 9.64e-09
L06 N05 N06 9.86e-12
R06 N05 N06 1.38e-01
C07 N06 N07 1.46e-09
L07 N06 N07 2.03e-11
R07 N06 N07 3.35e-01
C08 N07 N08 1.82e-12
L08 N07 N08 1.96e-10
R08 N07 N08 1.70e+02
C09 N08 Port2 1.48e-12
L09 N08 Port2 1.93e-10
R09 N08 Port2 1.00e+05
.ENDS GGM2165C2A152JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GGM2165C2A181JA16
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A181JA16 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.09e-10
R03 N02 N03 8.50e-02
L04 N03 N04 2.47e-11
R04 N03 N04 6.56e-01
C05 N04 N05 6.35e-10
L05 N04 N05 1.56e-11
R05 N04 N05 7.25e-01
C06 N05 N06 1.33e-10
L06 N05 N06 2.37e-11
R06 N05 N06 1.68e+00
C07 N06 N07 1.80e-12
L07 N06 N07 1.50e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 4.09e-12
L08 N07 Port2 6.06e-11
R08 N07 Port2 1.05e+01
.ENDS GGM2165C2A181JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GGM2165C2A182JA16
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A182JA16 Port1 Port2
C01 Port1 N01 1.77e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.03e-11
R03 N02 N03 1.30e-02
L04 N03 N04 5.23e-11
R04 N03 N04 5.55e-01
L05 N04 N05 6.93e-11
R05 N04 N05 2.67e-02
C06 N05 N06 1.12e-08
L06 N05 N06 1.15e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.43e-09
L07 N06 N07 2.94e-11
R07 N06 N07 3.95e-01
C08 N07 N08 2.13e-11
L08 N07 N08 1.75e-11
R08 N07 N08 4.12e+00
C09 N08 Port2 6.90e-13
L09 N08 Port2 3.82e-10
R09 N08 Port2 1.00e+05
.ENDS GGM2165C2A182JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GGM2165C2A221JA16
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A221JA16 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.79e-11
R03 N02 N03 7.72e-02
C04 N03 N04 5.84e-10
L04 N03 N04 2.45e-11
R04 N03 N04 8.99e-01
C05 N04 N05 1.71e-10
L05 N04 N05 2.79e-11
R05 N04 N05 1.59e+00
C06 N05 N06 3.45e-10
L06 N05 N06 5.95e-12
R06 N05 N06 3.77e-01
C07 N06 N07 7.62e-11
L07 N06 N07 1.40e-11
R07 N06 N07 1.10e+00
C08 N07 N08 2.81e-11
L08 N07 N08 1.64e-11
R08 N07 N08 2.02e+00
C09 N08 Port2 5.26e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GGM2165C2A221JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GGM2165C2A222JA16
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A222JA16 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GGM2165C2A222JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GGM2165C2A271JA16
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A271JA16 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 6.34e-11
R03 N02 N03 7.00e-02
L04 N03 N04 4.00e-11
R04 N03 N04 1.25e+00
C05 N04 N05 8.64e-10
L05 N04 N05 2.33e-11
R05 N04 N05 1.02e+00
C06 N05 N06 2.50e-10
L06 N05 N06 2.77e-11
R06 N05 N06 1.54e+00
C07 N06 N07 1.32e-09
L07 N06 N07 2.32e-12
R07 N06 N07 2.68e-01
C08 N07 N08 5.15e-10
L08 N07 N08 3.31e-12
R08 N07 N08 4.32e-01
C09 N08 N09 5.92e-12
L09 N08 N09 5.27e-11
R09 N08 N09 1.31e+01
C10 N09 Port2 1.08e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 1.00e+05
.ENDS GGM2165C2A271JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GGM2165C2A272JA16
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A272JA16 Port1 Port2
C01 Port1 N01 2.73e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 1.00e-02
L04 N03 N04 7.89e-11
R04 N03 N04 2.64e-01
L05 N04 N05 4.80e-11
R05 N04 N05 1.33e-02
C06 N05 N06 1.44e-08
L06 N05 N06 2.06e-11
R06 N05 N06 2.56e-01
C07 N06 N07 3.08e-09
L07 N06 N07 3.79e-11
R07 N06 N07 4.41e-01
C08 N07 N08 2.66e-12
L08 N07 N08 1.03e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 1.23e-11
L09 N08 Port2 2.22e-11
R09 N08 Port2 6.61e-01
.ENDS GGM2165C2A272JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GGM2165C2A331JA16
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A331JA16 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GGM2165C2A331JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GGM2165C2A332JA16
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A332JA16 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GGM2165C2A332JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GGM2165C2A391JA16
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A391JA16 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.53e-11
R03 N02 N03 6.50e-02
C04 N03 N04 1.15e-09
L04 N03 N04 1.48e-11
R04 N03 N04 2.87e-01
C05 N04 N05 2.31e-10
L05 N04 N05 2.21e-11
R05 N04 N05 7.21e-01
C06 N05 N06 7.85e-10
L06 N05 N06 3.62e-12
R06 N05 N06 2.91e-01
C07 N06 Port2 7.95e-13
L07 N06 Port2 4.31e-10
R07 N06 Port2 6.72e+02
.ENDS GGM2165C2A391JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GGM2165C2A471JA16
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A471JA16 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GGM2165C2A471JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GGM2165C2A561JA16
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A561JA16 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.59e-11
R03 N02 N03 5.00e-02
C04 N03 N04 1.76e-09
L04 N03 N04 1.89e-11
R04 N03 N04 3.51e-01
C05 N04 N05 3.10e-10
L05 N04 N05 3.30e-11
R05 N04 N05 7.10e-01
C06 N05 N06 2.64e-10
L06 N05 N06 1.08e-11
R06 N05 N06 5.58e-01
C07 N06 N07 3.64e-12
L07 N06 N07 8.60e-11
R07 N06 N07 2.77e+01
C08 N07 Port2 1.22e-12
L08 N07 Port2 2.54e-10
R08 N07 Port2 1.00e+05
.ENDS GGM2165C2A561JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GGM2165C2A681JA16
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A681JA16 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.19e-10
R03 N02 N03 4.50e-02
L04 N03 N04 6.53e-11
R04 N03 N04 1.49e+00
C05 N04 N05 2.07e-09
L05 N04 N05 2.24e-11
R05 N04 N05 4.17e-01
C06 N05 N06 5.37e-10
L06 N05 N06 2.75e-11
R06 N05 N06 6.67e-01
C07 N06 Port2 3.56e-12
L07 N06 Port2 7.25e-11
R07 N06 Port2 1.00e+05
.ENDS GGM2165C2A681JA16
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GGM2165C2A821JA16
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM2165C2A821JA16 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.18e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.66e-11
R04 N03 N04 5.78e-01
C05 N04 N05 3.23e-09
L05 N04 N05 1.81e-11
R05 N04 N05 3.50e-01
C06 N05 N06 6.16e-10
L06 N05 N06 3.41e-11
R06 N05 N06 6.96e-01
C07 N06 N07 6.72e-12
L07 N06 N07 4.56e-11
R07 N06 N07 1.17e+01
C08 N07 Port2 1.92e-12
L08 N07 Port2 1.31e-10
R08 N07 Port2 1.00e+05
.ENDS GGM2165C2A821JA16
