*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS10NG00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS10NG00 port1 port2
C1 port1 port2 4.61e-14
L2 port1 1 1.14e-8
R2 1 port2 5.30e-2
R3 port1 port2 5.45e+4
L4 port1 2 2.29e-7
R4 2 port2 32.2
L5 port1 3 6.72e-7
R5 3 port2 849
L6 port1 4 9.81e-7
R6 4 port2 7.02e+3
L7 port1 5 2.11e-6
C7 5 6 1.45e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.24e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS10NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS10NJ00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS10NJ00 port1 port2
C1 port1 port2 4.61e-14
L2 port1 1 1.14e-8
R2 1 port2 5.30e-2
R3 port1 port2 5.45e+4
L4 port1 2 2.29e-7
R4 2 port2 32.2
L5 port1 3 6.72e-7
R5 3 port2 849
L6 port1 4 9.81e-7
R6 4 port2 7.02e+3
L7 port1 5 2.11e-6
C7 5 6 1.45e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.24e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS10NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS12NG00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS12NG00 port1 port2
C1 port1 port2 4.61e-14
L2 port1 1 1.31e-8
R2 1 port2 1.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.90e-7
R4 2 port2 46.7
L5 port1 3 6.07e-7
R5 3 port2 914
L6 port1 4 1.07e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 1.23e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.44e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS12NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS12NJ00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS12NJ00 port1 port2
C1 port1 port2 4.61e-14
L2 port1 1 1.31e-8
R2 1 port2 1.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.90e-7
R4 2 port2 46.7
L5 port1 3 6.07e-7
R5 3 port2 914
L6 port1 4 1.07e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 1.23e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.44e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS12NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS15NG00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS15NG00 port1 port2
C1 port1 port2 7.47e-14
L2 port1 1 1.73e-8
R2 1 port2 1.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.57e-7
R4 2 port2 46.7
L5 port1 3 8.77e-7
R5 3 port2 914
L6 port1 4 1.23e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 6.29e-17
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.44e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS15NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS15NJ00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS15NJ00 port1 port2
C1 port1 port2 7.47e-14
L2 port1 1 1.73e-8
R2 1 port2 1.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.57e-7
R4 2 port2 46.7
L5 port1 3 8.77e-7
R5 3 port2 914
L6 port1 4 1.23e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 6.29e-17
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 4.44e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS18NG00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS18NG00 port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.90e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 4.50e-7
R4 2 port2 46.7
L5 port1 3 1.03e-6
R5 3 port2 914
L6 port1 4 1.41e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 2.13e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 8.46e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS18NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS18NJ00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS18NJ00 port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.90e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 4.50e-7
R4 2 port2 46.7
L5 port1 3 1.03e-6
R5 3 port2 914
L6 port1 4 1.41e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 2.13e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 8.46e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS18NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS22NG00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS22NG00 port1 port2
C1 port1 port2 8.77e-14
L2 port1 1 2.34e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 46.7
L5 port1 3 1.18e-6
R5 3 port2 914
L6 port1 4 1.90e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 1.77e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 6.57e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS22NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS22NJ00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS22NJ00 port1 port2
C1 port1 port2 8.77e-14
L2 port1 1 2.34e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 46.7
L5 port1 3 1.18e-6
R5 3 port2 914
L6 port1 4 1.90e-6
R6 4 port2 7.82e+3
L7 port1 5 2.11e-6
C7 5 6 1.77e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 6.57e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS22NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS24NG00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS24NG00 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.57e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 46.7
L5 port1 3 1.39e-6
R5 3 port2 914
L6 port1 4 1.90e-6
R6 4 port2 8.57e+3
L7 port1 5 2.11e-6
C7 5 6 1.81e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 6.88e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS24NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS24NJ00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS24NJ00 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.57e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 46.7
L5 port1 3 1.39e-6
R5 3 port2 914
L6 port1 4 1.90e-6
R6 4 port2 8.57e+3
L7 port1 5 2.11e-6
C7 5 6 1.81e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 6.88e-17
R8 8 port2 3.46e+3
.ENDS LQW2BAS24NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS27NG00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS27NG00 port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 2.75e-8
R2 1 port2 2.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 34.6
L5 port1 3 1.27e-6
R5 3 port2 914
L6 port1 4 2.08e-6
R6 4 port2 5.16e+3
L7 port1 5 2.11e-6
C7 5 6 3.00e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 1.20e-16
R8 8 port2 3.46e+3
.ENDS LQW2BAS27NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS27NJ00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS27NJ00 port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 2.75e-8
R2 1 port2 2.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 5.80e-7
R4 2 port2 34.6
L5 port1 3 1.27e-6
R5 3 port2 914
L6 port1 4 2.08e-6
R6 4 port2 5.16e+3
L7 port1 5 2.11e-6
C7 5 6 3.00e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 1.20e-16
R8 8 port2 3.46e+3
.ENDS LQW2BAS27NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS2N8J00
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS2N8J00 port1 port2
C1 port1 port2 3.34e-14
L2 port1 1 3.36e-9
R2 1 port2 2.20e-2
R3 port1 port2 5.45e+4
L4 port1 2 9.44e-9
R4 2 port2 1.35
L5 port1 3 8.49e-8
R5 3 port2 452
L6 port1 4 3.72e-6
R6 4 port2 7.34e+3
.ENDS LQW2BAS2N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS33NG00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS33NG00 port1 port2
C1 port1 port2 8.57e-14
L2 port1 1 3.46e-8
R2 1 port2 2.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.03e-6
R4 2 port2 34.6
L5 port1 3 1.39e-6
R5 3 port2 618
L6 port1 4 3.15e-6
R6 4 port2 1.05e+4
L7 port1 5 2.11e-6
C7 5 6 3.00e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 1.17e-16
R8 8 port2 3.46e+3
L9 port1 9 4.84e-8
C9 9 10 1.31e-15
R9 10 port2 552
.ENDS LQW2BAS33NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS33NJ00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS33NJ00 port1 port2
C1 port1 port2 8.57e-14
L2 port1 1 3.46e-8
R2 1 port2 2.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.03e-6
R4 2 port2 34.6
L5 port1 3 1.39e-6
R5 3 port2 618
L6 port1 4 3.15e-6
R6 4 port2 1.05e+4
L7 port1 5 2.11e-6
C7 5 6 3.00e-16
R7 6 port2 1.89e+3
L8 port1 7 1.59e-6
C8 7 8 1.17e-16
R8 8 port2 3.46e+3
L9 port1 9 4.84e-8
C9 9 10 1.31e-15
R9 10 port2 552
.ENDS LQW2BAS33NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS36NG00
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS36NG00 port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 3.79e-8
R2 1 port2 2.10e-1
R3 port1 port2 6.86e+4
L4 port1 2 1.03e-6
R4 2 port2 34.6
L5 port1 3 1.39e-6
R5 3 port2 618
L6 port1 4 3.15e-6
R6 4 port2 1.05e+4
L7 port1 5 7.66e-9
C7 5 6 3.95e-14
R7 6 port2 7.52
L8 port1 7 1.59e-6
C8 7 8 1.17e-16
R8 8 port2 3.46e+3
L9 port1 9 4.84e-8
C9 9 10 1.31e-15
R9 10 port2 552
.ENDS LQW2BAS36NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS36NJ00
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS36NJ00 port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 3.79e-8
R2 1 port2 2.10e-1
R3 port1 port2 6.86e+4
L4 port1 2 1.03e-6
R4 2 port2 34.6
L5 port1 3 1.39e-6
R5 3 port2 618
L6 port1 4 3.15e-6
R6 4 port2 1.05e+4
L7 port1 5 7.66e-9
C7 5 6 3.95e-14
R7 6 port2 7.52
L8 port1 7 1.59e-6
C8 7 8 1.17e-16
R8 8 port2 3.46e+3
L9 port1 9 4.84e-8
C9 9 10 1.31e-15
R9 10 port2 552
.ENDS LQW2BAS36NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS39NG00
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS39NG00 port1 port2
C1 port1 port2 5.53e-14
L2 port1 1 4.07e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.11e-6
R4 2 port2 204
L5 port1 3 4.35e-6
R5 3 port2 4.73e+3
L6 port1 4 4.34e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 4.79e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.75e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS39NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS39NJ00
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS39NJ00 port1 port2
C1 port1 port2 5.53e-14
L2 port1 1 4.07e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.11e-6
R4 2 port2 204
L5 port1 3 4.35e-6
R5 3 port2 4.73e+3
L6 port1 4 4.34e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 4.79e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.75e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS39NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS3N0J00
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS3N0J00 port1 port2
C1 port1 port2 3.34e-14
L2 port1 1 3.77e-9
R2 1 port2 4.70e-2
R3 port1 port2 5.45e+4
L4 port1 2 1.19e-8
R4 2 port2 1.35
L5 port1 3 1.76e-7
R5 3 port2 1.61e+3
L6 port1 4 9.07e-8
R6 4 port2 201
.ENDS LQW2BAS3N0J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS43NG00
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS43NG00 port1 port2
C1 port1 port2 7.12e-14
L2 port1 1 4.46e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.27e-6
R4 2 port2 204
L5 port1 3 5.48e-6
R5 3 port2 4.73e+3
L6 port1 4 4.87e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 5.13e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.75e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS43NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS43NJ00
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS43NJ00 port1 port2
C1 port1 port2 7.12e-14
L2 port1 1 4.46e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.27e-6
R4 2 port2 204
L5 port1 3 5.48e-6
R5 3 port2 4.73e+3
L6 port1 4 4.87e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 5.13e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.75e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS43NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS47NG00
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS47NG00 port1 port2
C1 port1 port2 8.56e-14
L2 port1 1 4.78e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.33e-6
R4 2 port2 204
L5 port1 3 5.87e-6
R5 3 port2 4.73e+3
L6 port1 4 4.87e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 5.13e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.52e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS47NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS47NJ00
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS47NJ00 port1 port2
C1 port1 port2 8.56e-14
L2 port1 1 4.78e-8
R2 1 port2 2.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.33e-6
R4 2 port2 204
L5 port1 3 5.87e-6
R5 3 port2 4.73e+3
L6 port1 4 4.87e-6
R6 4 port2 1.10e+4
L7 port1 5 2.08e-7
C7 5 6 5.13e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.66e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.52e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS47NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS56NG00
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS56NG00 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 5.62e-8
R2 1 port2 2.90e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.67e-6
R4 2 port2 204
L5 port1 3 6.29e-6
R5 3 port2 3.93e+3
L6 port1 4 5.72e-6
R6 4 port2 9.36e+3
L7 port1 5 2.08e-7
C7 5 6 6.46e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 1.43e-14
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 2.20e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS56NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS56NJ00
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS56NJ00 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 5.62e-8
R2 1 port2 2.90e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.67e-6
R4 2 port2 204
L5 port1 3 6.29e-6
R5 3 port2 3.93e+3
L6 port1 4 5.72e-6
R6 4 port2 9.36e+3
L7 port1 5 2.08e-7
C7 5 6 6.46e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 1.43e-14
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 2.20e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAS56NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS5N6J00
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS5N6J00 port1 port2
C1 port1 port2 4.11e-14
L2 port1 1 6.41e-9
R2 1 port2 2.40e-2
R3 port1 port2 5.45e+4
L4 port1 2 6.67e-8
R4 2 port2 9.61
L5 port1 3 3.63e-7
R5 3 port2 759
L6 port1 4 6.05e-7
R6 4 port2 6.68e+3
L7 port1 5 3.35e-6
C7 5 6 3.80e-17
R7 6 port2 6.38e+3
.ENDS LQW2BAS5N6J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS68NG00
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS68NG00 port1 port2
C1 port1 port2 3.65e-14
L2 port1 1 7.08e-8
R2 1 port2 3.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.10e-6
R4 2 port2 204
L5 port1 3 7.92e-6
R5 3 port2 3.93e+3
L6 port1 4 7.54e-6
R6 4 port2 9.80e+3
L7 port1 5 2.08e-7
C7 5 6 9.56e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 2.72e-14
R8 8 port2 176
L9 port1 9 8.96e-6
C9 9 10 1.84e-17
R9 10 port2 8.44e+3
L10 port1 11 8.51e-7
C10 11 12 9.83e-17
R10 12 port2 2.37e+3
.ENDS LQW2BAS68NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS68NJ00
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS68NJ00 port1 port2
C1 port1 port2 3.65e-14
L2 port1 1 7.08e-8
R2 1 port2 3.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.10e-6
R4 2 port2 204
L5 port1 3 7.92e-6
R5 3 port2 3.93e+3
L6 port1 4 7.54e-6
R6 4 port2 9.80e+3
L7 port1 5 2.08e-7
C7 5 6 9.56e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 2.72e-14
R8 8 port2 176
L9 port1 9 8.96e-6
C9 9 10 1.84e-17
R9 10 port2 8.44e+3
L10 port1 11 8.51e-7
C10 11 12 9.83e-17
R10 12 port2 2.37e+3
.ENDS LQW2BAS68NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS6N8J00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS6N8J00 port1 port2
C1 port1 port2 3.84e-14
L2 port1 1 7.36e-9
R2 1 port2 8.60e-2
R3 port1 port2 5.45e+4
L4 port1 2 8.68e-8
R4 2 port2 16.2
L5 port1 3 2.73e-7
R5 3 port2 812
L6 port1 4 7.22e-7
R6 4 port2 1.04e+4
L7 port1 5 3.35e-6
C7 5 6 3.80e-17
R7 6 port2 6.38e+3
.ENDS LQW2BAS6N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS7N5J00
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS7N5J00 port1 port2
C1 port1 port2 6.22e-14
L2 port1 1 8.85e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.45e+4
L4 port1 2 8.48e-8
R4 2 port2 10.7
L5 port1 3 3.14e-7
R5 3 port2 758
L6 port1 4 7.22e-7
R6 4 port2 1.04e+4
L7 port1 5 3.35e-6
C7 5 6 3.02e-17
R7 6 port2 6.38e+3
.ENDS LQW2BAS7N5J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS82NG00
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS82NG00 port1 port2
C1 port1 port2 7.28e-14
L2 port1 1 8.71e-8
R2 1 port2 3.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.41e-6
R4 2 port2 269
L5 port1 3 1.28e-5
R5 3 port2 3.93e+3
L6 port1 4 8.86e-6
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 1.69e-15
R7 6 port2 1.12e+3
L8 port1 7 1.27e-7
C8 7 8 6.10e-15
R8 8 port2 1.23e+3
L9 port1 9 8.96e-6
C9 9 10 2.37e-17
R9 10 port2 8.44e+3
L10 port1 11 8.51e-7
C10 11 12 1.03e-16
R10 12 port2 2.37e+3
.ENDS LQW2BAS82NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS82NJ00
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS82NJ00 port1 port2
C1 port1 port2 7.28e-14
L2 port1 1 8.71e-8
R2 1 port2 3.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.41e-6
R4 2 port2 269
L5 port1 3 1.28e-5
R5 3 port2 3.93e+3
L6 port1 4 8.86e-6
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 1.69e-15
R7 6 port2 1.12e+3
L8 port1 7 1.27e-7
C8 7 8 6.10e-15
R8 8 port2 1.23e+3
L9 port1 9 8.96e-6
C9 9 10 2.37e-17
R9 10 port2 8.44e+3
L10 port1 11 8.51e-7
C10 11 12 1.03e-16
R10 12 port2 2.37e+3
.ENDS LQW2BAS82NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS8N2G00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS8N2G00 port1 port2
C1 port1 port2 5.67e-14
L2 port1 1 8.45e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.57e-7
R4 2 port2 171
L5 port1 3 5.52e-7
R5 3 port2 1.90e+3
L6 port1 4 6.23e-7
R6 4 port2 8.18e+3
L7 port1 5 3.35e-6
C7 5 6 2.95e-17
R7 6 port2 6.38e+3
.ENDS LQW2BAS8N2G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS8N2J00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS8N2J00 port1 port2
C1 port1 port2 5.67e-14
L2 port1 1 8.45e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.57e-7
R4 2 port2 171
L5 port1 3 5.52e-7
R5 3 port2 1.90e+3
L6 port1 4 6.23e-7
R6 4 port2 8.18e+3
L7 port1 5 3.35e-6
C7 5 6 2.95e-17
R7 6 port2 6.38e+3
.ENDS LQW2BAS8N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS91NG00
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS91NG00 port1 port2
C1 port1 port2 6.49e-14
L2 port1 1 9.33e-8
R2 1 port2 4.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.10e-6
R4 2 port2 269
L5 port1 3 1.11e-5
R5 3 port2 5.06e+3
L6 port1 4 1.07e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 1.99e-15
R7 6 port2 1.12e+3
L8 port1 7 1.27e-7
C8 7 8 8.04e-15
R8 8 port2 1.23e+3
L9 port1 9 4.56e-6
C9 9 10 6.77e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.57e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BAS91NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAS91NJ00
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAS91NJ00 port1 port2
C1 port1 port2 6.49e-14
L2 port1 1 9.33e-8
R2 1 port2 4.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.10e-6
R4 2 port2 269
L5 port1 3 1.11e-5
R5 3 port2 5.06e+3
L6 port1 4 1.07e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 1.99e-15
R7 6 port2 1.12e+3
L8 port1 7 1.27e-7
C8 7 8 8.04e-15
R8 8 port2 1.23e+3
L9 port1 9 4.56e-6
C9 9 10 6.77e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.57e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BAS91NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR10G00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR10G00 port1 port2
C1 port1 port2 7.63e-14
L2 port1 1 1.07e-7
R2 1 port2 4.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.17e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.20e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 6.17e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.40e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.37e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR10G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR10J00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR10J00 port1 port2
C1 port1 port2 7.63e-14
L2 port1 1 1.07e-7
R2 1 port2 4.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.17e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.20e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 6.17e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.40e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.37e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR10J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR11G00
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR11G00 port1 port2
C1 port1 port2 8.96e-14
L2 port1 1 1.12e-7
R2 1 port2 4.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 6.17e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.40e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.37e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR11G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR11J00
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR11J00 port1 port2
C1 port1 port2 8.96e-14
L2 port1 1 1.12e-7
R2 1 port2 4.10e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 6.17e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.40e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.37e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR11J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR12G00
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR12G00 port1 port2
C1 port1 port2 8.36e-14
L2 port1 1 1.29e-7
R2 1 port2 4.60e-1
R3 port1 port2 5.58e+4
L4 port1 2 3.48e-6
R4 2 port2 269
L5 port1 3 1.31e-5
R5 3 port2 5.06e+3
L6 port1 4 1.51e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.40e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.26e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.08e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.68e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR12G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR12J00
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR12J00 port1 port2
C1 port1 port2 8.36e-14
L2 port1 1 1.29e-7
R2 1 port2 4.60e-1
R3 port1 port2 5.58e+4
L4 port1 2 3.48e-6
R4 2 port2 269
L5 port1 3 1.31e-5
R5 3 port2 5.06e+3
L6 port1 4 1.51e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.40e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.26e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.08e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.68e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BASR12J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR15G00
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR15G00 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 1.59e-7
R2 1 port2 5.00e-1
R3 port1 port2 5.58e+4
L4 port1 2 3.48e-6
R4 2 port2 229
L5 port1 3 1.54e-5
R5 3 port2 5.06e+3
L6 port1 4 1.62e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 3.16e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 8.44e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 9.33e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.11e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.04e-16
R11 14 port2 2.19e+3
.ENDS LQW2BASR15G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR15J00
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR15J00 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 1.59e-7
R2 1 port2 5.00e-1
R3 port1 port2 5.58e+4
L4 port1 2 3.48e-6
R4 2 port2 229
L5 port1 3 1.54e-5
R5 3 port2 5.06e+3
L6 port1 4 1.62e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 3.16e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 8.44e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 9.33e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.11e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.04e-16
R11 14 port2 2.19e+3
.ENDS LQW2BASR15J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR18G00
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR18G00 port1 port2
C1 port1 port2 9.17e-14
L2 port1 1 1.91e-7
R2 1 port2 5.80e-1
R3 port1 port2 5.58e+4
L4 port1 2 4.50e-6
R4 2 port2 314
L5 port1 3 1.15e-5
R5 3 port2 4.79e+3
L6 port1 4 5.74e-5
R6 4 port2 1.84e+4
L7 port1 5 1.52e-6
C7 5 6 3.71e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.09e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.26e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.91e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.47e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 6.71e-16
R12 16 port2 603
.ENDS LQW2BASR18G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR18J00
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR18J00 port1 port2
C1 port1 port2 9.17e-14
L2 port1 1 1.91e-7
R2 1 port2 5.80e-1
R3 port1 port2 5.58e+4
L4 port1 2 4.50e-6
R4 2 port2 314
L5 port1 3 1.15e-5
R5 3 port2 4.79e+3
L6 port1 4 5.74e-5
R6 4 port2 1.84e+4
L7 port1 5 1.52e-6
C7 5 6 3.71e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.09e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.26e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.91e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.47e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 6.71e-16
R12 16 port2 603
.ENDS LQW2BASR18J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR22G00
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR22G00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 2.35e-7
R2 1 port2 6.60e-1
R3 port1 port2 5.58e+4
L4 port1 2 5.54e-6
R4 2 port2 314
L5 port1 3 1.23e-5
R5 3 port2 4.79e+3
L6 port1 4 1.46e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 5.00e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.47e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.82e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 3.93e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.77e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 6.71e-16
R12 16 port2 603
.ENDS LQW2BASR22G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR22J00
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR22J00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 2.35e-7
R2 1 port2 6.60e-1
R3 port1 port2 5.58e+4
L4 port1 2 5.54e-6
R4 2 port2 314
L5 port1 3 1.23e-5
R5 3 port2 4.79e+3
L6 port1 4 1.46e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 5.00e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.47e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.82e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 3.93e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.77e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 6.71e-16
R12 16 port2 603
.ENDS LQW2BASR22J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR24G00
* Property : L = 240[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR24G00 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 2.52e-7
R2 1 port2 7.80e-1
R3 port1 port2 5.58e+4
L4 port1 2 5.80e-6
R4 2 port2 314
L5 port1 3 1.26e-5
R5 3 port2 4.79e+3
L6 port1 4 1.49e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 5.61e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.47e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.82e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 3.84e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.77e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 7.19e-16
R12 16 port2 603
.ENDS LQW2BASR24G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR24J00
* Property : L = 240[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR24J00 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 2.52e-7
R2 1 port2 7.80e-1
R3 port1 port2 5.58e+4
L4 port1 2 5.80e-6
R4 2 port2 314
L5 port1 3 1.26e-5
R5 3 port2 4.79e+3
L6 port1 4 1.49e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 5.61e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.47e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.82e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 3.84e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.77e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 7.19e-16
R12 16 port2 603
.ENDS LQW2BASR24J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR27G00
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR27G00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 2.89e-7
R2 1 port2 8.30e-1
R3 port1 port2 5.58e+4
L4 port1 2 6.97e-6
R4 2 port2 314
L5 port1 3 1.32e-5
R5 3 port2 4.79e+3
L6 port1 4 1.52e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 6.44e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.65e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.95e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 4.41e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.99e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 8.07e-16
R12 16 port2 603
.ENDS LQW2BASR27G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR27J00
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR27J00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 2.89e-7
R2 1 port2 8.30e-1
R3 port1 port2 5.58e+4
L4 port1 2 6.97e-6
R4 2 port2 314
L5 port1 3 1.32e-5
R5 3 port2 4.79e+3
L6 port1 4 1.52e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 6.44e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 1.65e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 1.95e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 4.41e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.99e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 8.07e-16
R12 16 port2 603
.ENDS LQW2BASR27J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR33G00
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR33G00 port1 port2
C1 port1 port2 8.56e-14
L2 port1 1 3.47e-7
R2 1 port2 1.19
R3 port1 port2 5.58e+4
L4 port1 2 9.62e-6
R4 2 port2 314
L5 port1 3 1.55e-5
R5 3 port2 4.79e+3
L6 port1 4 1.56e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 7.06e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 2.23e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 2.57e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 5.43e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 2.62e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 8.65e-16
R12 16 port2 603
.ENDS LQW2BASR33G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR33J00
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR33J00 port1 port2
C1 port1 port2 8.56e-14
L2 port1 1 3.47e-7
R2 1 port2 1.19
R3 port1 port2 5.58e+4
L4 port1 2 9.62e-6
R4 2 port2 314
L5 port1 3 1.55e-5
R5 3 port2 4.79e+3
L6 port1 4 1.56e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 7.06e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 2.23e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 2.57e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 5.43e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 2.62e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 8.65e-16
R12 16 port2 603
.ENDS LQW2BASR33J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR39J00
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR39J00 port1 port2
C1 port1 port2 7.29e-14
L2 port1 1 4.17e-7
R2 1 port2 1.32
R3 port1 port2 5.58e+4
L4 port1 2 1.18e-5
R4 2 port2 314
L5 port1 3 1.66e-5
R5 3 port2 4.79e+3
L6 port1 4 1.63e-4
R6 4 port2 2.88e+4
L7 port1 5 1.52e-6
C7 5 6 1.12e-14
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 2.68e-16
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 3.24e-16
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 7.16e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 3.53e-16
R11 14 port2 2.19e+3
L12 port1 15 1.67e-7
C12 15 16 1.04e-15
R12 16 port2 603
.ENDS LQW2BASR39J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR47J00
* Property : L = 470[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR47J00 port1 port2
C1 port1 port2 1.59e-13
L2 port1 1 5.13e-7
R2 1 port2 1.53
R3 port1 port2 5.58e+4
L4 port1 2 1.35e-5
R4 2 port2 314
L5 port1 3 1.86e-5
R5 3 port2 4.79e+3
L6 port1 4 1.52e-4
R6 4 port2 2.75e+4
L7 port1 5 1.52e-6
C7 5 6 1.78e-14
R7 6 port2 1.12e+3
L8 port1 7 3.72e-7
C8 7 8 8.53e-15
R8 8 port2 787
L9 port1 9 7.49e-8
C9 9 10 1.50e-14
R9 10 port2 649
L10 port1 11 2.90e-7
C10 11 12 1.55e-15
R10 12 port2 787
L11 port1 13 5.01e-8
C11 13 14 2.91e-15
R11 14 port2 323
L12 port1 15 1.59e-7
C12 15 16 4.80e-16
R12 16 port2 1.60e+3
.ENDS LQW2BASR47J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR56J00
* Property : L = 560[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR56J00 port1 port2
C1 port1 port2 1.74e-13
L2 port1 1 6.03e-7
R2 1 port2 1.58
R3 port1 port2 5.58e+4
L4 port1 2 1.38e-5
R4 2 port2 314
L5 port1 3 1.90e-5
R5 3 port2 4.79e+3
L6 port1 4 1.59e-4
R6 4 port2 2.75e+4
L7 port1 5 1.52e-6
C7 5 6 1.95e-14
R7 6 port2 1.12e+3
L8 port1 7 3.72e-7
C8 7 8 1.00e-14
R8 8 port2 787
L9 port1 9 7.49e-8
C9 9 10 1.85e-14
R9 10 port2 649
L10 port1 11 2.90e-7
C10 11 12 1.74e-15
R10 12 port2 787
L11 port1 13 5.01e-8
C11 13 14 3.50e-15
R11 14 port2 323
L12 port1 15 1.59e-7
C12 15 16 5.39e-16
R12 16 port2 1.60e+3
.ENDS LQW2BASR56J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR68J00
* Property : L = 680[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR68J00 port1 port2
C1 port1 port2 2.40e-13
L2 port1 1 7.42e-7
R2 1 port2 1.79
R3 port1 port2 5.58e+4
L4 port1 2 1.48e-5
R4 2 port2 314
L5 port1 3 2.04e-5
R5 3 port2 4.79e+3
L6 port1 4 1.63e-4
R6 4 port2 2.63e+4
L7 port1 5 2.80e-5
C7 5 6 2.43e-15
R7 6 port2 1.94e+3
L8 port1 7 1.90e-6
C8 7 8 3.66e-15
R8 8 port2 1.31e+3
L9 port1 9 1.67e-6
C9 9 10 1.97e-15
R9 10 port2 6.67e+3
L10 port1 11 3.25e-7
C10 11 12 1.95e-15
R10 12 port2 787
L11 port1 13 5.49e-8
C11 13 14 3.84e-15
R11 14 port2 323
L12 port1 15 1.74e-7
C12 15 16 5.91e-16
R12 16 port2 1.60e+3
.ENDS LQW2BASR68J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BASR82J00
* Property : L = 820[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BASR82J00 port1 port2
C1 port1 port2 3.47e-13
L2 port1 1 8.72e-7
R2 1 port2 1.92
R3 port1 port2 5.58e+4
L4 port1 2 1.86e-5
R4 2 port2 314
L5 port1 3 2.04e-5
R5 3 port2 4.79e+3
L6 port1 4 1.56e-4
R6 4 port2 2.63e+4
L7 port1 5 2.80e-5
C7 5 6 4.22e-15
R7 6 port2 1.94e+3
L8 port1 7 1.90e-6
C8 7 8 1.49e-15
R8 8 port2 1.31e+3
L9 port1 9 1.67e-6
C9 9 10 9.43e-16
R9 10 port2 6.67e+3
L10 port1 11 3.25e-7
C10 11 12 2.14e-15
R10 12 port2 787
L11 port1 13 5.49e-8
C11 13 14 4.62e-15
R11 14 port2 323
L12 port1 15 1.74e-7
C12 15 16 6.33e-16
R12 16 port2 1.60e+3
.ENDS LQW2BASR82J00
*----------------------------------------------------------------------
