*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GXT1555C1E100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1E100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GXT1555C1E101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GXT1555C1E102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GXT1555C1E102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GXT1555C1E120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1E120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/25[V]
* Murata P/N :GXT1555C1E121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1E121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GXT1555C1E150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1E150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/25[V]
* Murata P/N :GXT1555C1E151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GXT1555C1E151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GXT1555C1E180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXT1555C1E180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/25[V]
* Murata P/N :GXT1555C1E181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1E181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GXT1555C1E220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXT1555C1E220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GXT1555C1E221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GXT1555C1E221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GXT1555C1E270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/25[V]
* Murata P/N :GXT1555C1E271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1E271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/25[V]
* Murata P/N :GXT1555C1E330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/25[V]
* Murata P/N :GXT1555C1E331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GXT1555C1E331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/25[V]
* Murata P/N :GXT1555C1E390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/25[V]
* Murata P/N :GXT1555C1E391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/25[V]
* Murata P/N :GXT1555C1E470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GXT1555C1E471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/25[V]
* Murata P/N :GXT1555C1E560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GXT1555C1E561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/25[V]
* Murata P/N :GXT1555C1E680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1E680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GXT1555C1E681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GXT1555C1E681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/25[V]
* Murata P/N :GXT1555C1E820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXT1555C1E820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GXT1555C1E821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1E821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1E821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GXT1555C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GXT1555C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXT1555C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GXT1555C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GXT1555C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GXT1555C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GXT1555C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GXT1555C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GXT1555C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GXT1555C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXT1555C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GXT1555C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXT1555C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GXT1555C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXT1555C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GXT1555C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GXT1555C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GXT1555C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXT1555C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXT1555C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GXT1555C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXT1555C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GXT1555C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GXT1555C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXT1555C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXT1555C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GXT1555C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXT1555C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXT1555C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GXT1555C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXT1555C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXT1555C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GXT1555C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXT1555C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GXT1555C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXT1555C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GXT1555C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXT1555C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXT1555C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1555C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXT1555C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GXT1555C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXT1555C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GXT1555C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GXT1555C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GXT1555C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GXT1555C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1555C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GXT1555C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXT1555C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXT1555C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GXT1555C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXT1555C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GXT1555C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXT1555C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GXT1555C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GXT1555C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXT1555C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GXT1555C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXT1555C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GXT1555C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXT1555C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GXT1555C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1555C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXT1555C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXT1555C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GXT1555C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXT1555C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXT1555C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GXT1555C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1555C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXT1555C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GXT155C81A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81A105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GXT155C81A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GXT155C81A225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81A225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155C81A225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GXT155C81A225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81A225ME13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155C81A225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GXT155C81C105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81C105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GXT155C81C105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GXT155C81C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81C225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155C81C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GXT155C81C225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81C225ME13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155C81C225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GXT155C81C474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81C474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155C81C474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GXT155C81C474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81C474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155C81C474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GXT155C81E105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81E105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GXT155C81E105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GXT155C81E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81E224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155C81E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GXT155C81E224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81E224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155C81E224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GXT155C8YA224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C8YA224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155C8YA224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GXT155C8YA224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C8YA224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155C8YA224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GXT155R60J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R60J105KE01 Port1 Port2
C01 Port1 N01 8.36e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 1.04e-02
C04 N03 N04 2.59e-05
R04 N03 N04 2.15e+02
C05 N04 N05 3.92e-05
R05 N04 N05 1.09e+01
C06 N05 N06 4.33e-05
R06 N05 N06 9.62e-01
C07 N06 N07 3.90e-05
R07 N06 N07 1.06e-01
C08 N07 N08 2.26e-05
R08 N07 N08 1.85e-02
L09 N08 N09 3.29e-11
R09 N08 N09 2.81e-01
L10 N09 N10 2.43e-11
R10 N09 N10 6.14e-02
L11 N10 N11 1.22e-10
R11 N10 N11 3.10e-02
C12 N11 N12 8.98e-07
L12 N11 N12 5.27e-11
R12 N11 N12 8.91e-03
C13 N12 Port2 2.52e-12
L13 N12 Port2 7.01e-11
R13 N12 Port2 1.17e+01
.ENDS GXT155R60J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GXT155R61A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61A105KE01 Port1 Port2
C01 Port1 N01 7.82e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.56e-11
R03 N02 N03 1.42e-02
C04 N03 N04 4.37e-06
R04 N03 N04 1.71e+03
C05 N04 N05 3.28e-05
R05 N04 N05 1.46e+01
C06 N05 N06 3.38e-05
R06 N05 N06 1.33e+00
C07 N06 N07 3.14e-05
R07 N06 N07 1.48e-01
C08 N07 N08 2.09e-05
R08 N07 N08 2.27e-02
L09 N08 N09 3.38e-11
R09 N08 N09 1.41e-01
L10 N09 N10 1.10e-10
R10 N09 N10 4.24e-02
C11 N10 N11 5.33e-07
L11 N10 N11 8.71e-11
R11 N10 N11 1.33e-02
C12 N11 Port2 7.86e-13
L12 N11 Port2 1.63e-10
R12 N11 Port2 4.30e+01
.ENDS GXT155R61A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GXT155R61C105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61C105KE01 Port1 Port2
C01 Port1 N01 6.61e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 9.93e-11
R03 N02 N03 1.12e-02
C04 N03 N04 2.55e-06
R04 N03 N04 2.74e+03
C05 N04 N05 1.19e-05
R05 N04 N05 2.54e+01
C06 N05 N06 1.25e-05
R06 N05 N06 2.42e+00
C07 N06 N07 9.90e-06
R07 N06 N07 2.95e-01
C08 N07 N08 7.19e-06
R08 N07 N08 3.13e-02
L09 N08 N09 3.54e-11
R09 N08 N09 1.48e-01
L10 N09 N10 1.21e-10
R10 N09 N10 3.60e-02
C11 N10 N11 1.95e-06
L11 N10 N11 2.54e-11
R11 N10 N11 5.15e-03
C12 N11 N12 1.30e-06
L12 N11 N12 2.16e-11
R12 N11 N12 5.51e-03
C13 N12 Port2 1.40e-12
L13 N12 Port2 9.72e-11
R13 N12 Port2 1.85e+01
.ENDS GXT155R61C105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GXT155R61C224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61C224KE01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.05e-10
R03 N02 N03 1.84e-02
C04 N03 N04 1.07e-06
R04 N03 N04 2.75e+00
C05 N04 N05 3.54e-06
R05 N04 N05 7.95e-02
C06 N05 N06 2.09e-06
R06 N05 N06 2.48e-02
L07 N06 N07 1.75e-11
R07 N06 N07 1.02e-01
L08 N07 N08 9.10e-11
R08 N07 N08 7.76e-02
C09 N08 N09 6.65e-07
L09 N08 N09 1.70e-11
R09 N08 N09 7.72e-03
C10 N09 N10 2.19e-07
L10 N09 N10 2.85e-11
R10 N09 N10 1.47e-02
C11 N10 Port2 1.53e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 3.37e+01
.ENDS GXT155R61C224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GXT155R61C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61C225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155R61C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GXT155R61C474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61C474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R61C474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GXT155R61C474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61C474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R61C474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GXT155R61E105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GXT155R61E105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GXT155R61E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155R61E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GXT155R61E224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155R61E224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GXT155R61E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GXT155R61E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GXT155R61E474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R61E474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GXT155R61E474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R61E474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R61E474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GXT155R6YA105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA105KE13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GXT155R6YA105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GXT155R6YA105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GXT155R6YA105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GXT155R6YA224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155R6YA224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GXT155R6YA224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155R6YA224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GXT155R6YA474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R6YA474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GXT155R6YA474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R6YA474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R6YA474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GXT155R71A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71A224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GXT155R71A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-01[uF]/10[V]
* Murata P/N :GXT155R71A474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71A474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GXT155R71A474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GXT155R71C224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71C224KE01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.05e-10
R03 N02 N03 1.84e-02
C04 N03 N04 1.07e-06
R04 N03 N04 2.75e+00
C05 N04 N05 3.54e-06
R05 N04 N05 7.95e-02
C06 N05 N06 2.09e-06
R06 N05 N06 2.48e-02
L07 N06 N07 1.75e-11
R07 N06 N07 1.02e-01
L08 N07 N08 9.10e-11
R08 N07 N08 7.76e-02
C09 N08 N09 6.65e-07
L09 N08 N09 1.70e-11
R09 N08 N09 7.72e-03
C10 N09 N10 2.19e-07
L10 N09 N10 2.85e-11
R10 N09 N10 1.47e-02
C11 N10 Port2 1.53e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 3.37e+01
.ENDS GXT155R71C224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GXT155R71C473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71C473KE01 Port1 Port2
C01 Port1 N01 4.57e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 2.33e-02
C04 N03 N04 3.83e-06
R04 N03 N04 1.65e+00
C05 N04 N05 3.30e-06
R05 N04 N05 2.99e-01
C06 N05 N06 4.01e-06
R06 N05 N06 4.18e-02
C07 N06 N07 4.58e-06
R07 N06 N07 1.14e-02
L08 N07 N08 1.67e-11
R08 N07 N08 2.90e-01
L09 N08 N09 7.54e-11
R09 N08 N09 1.10e-01
C10 N09 N10 1.46e-06
L10 N09 N10 2.84e-12
R10 N09 N10 5.76e-03
C11 N10 N11 5.18e-08
L11 N10 N11 3.82e-11
R11 N10 N11 3.32e-02
C12 N11 N12 2.94e-11
L12 N11 N12 1.29e-11
R12 N11 N12 2.12e+00
C13 N12 Port2 4.57e-12
L13 N12 Port2 6.25e-11
R13 N12 Port2 2.85e+01
.ENDS GXT155R71C473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GXT155R71E104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71E104KE01 Port1 Port2
C01 Port1 N01 9.09e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.20e-10
R03 N02 N03 1.44e-02
C04 N03 N04 4.94e-06
R04 N03 N04 4.13e-01
C05 N04 N05 7.71e-06
R05 N04 N05 3.89e-02
C06 N05 N06 9.53e-06
R06 N05 N06 7.15e-03
L07 N06 N07 1.30e-11
R07 N06 N07 8.90e-02
L08 N07 N08 9.65e-11
R08 N07 N08 6.74e-02
C09 N08 N09 6.50e-07
L09 N08 N09 1.23e-11
R09 N08 N09 1.12e-02
C10 N09 N10 1.85e-07
L10 N09 N10 2.10e-11
R10 N09 N10 2.12e-02
C11 N10 Port2 2.31e-12
L11 N10 Port2 8.12e-11
R11 N10 Port2 1.94e+01
.ENDS GXT155R71E104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GXT155R71E473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71E473KE01 Port1 Port2
C01 Port1 N01 4.53e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.72e-10
R03 N02 N03 2.19e-02
C04 N03 N04 3.67e-06
R04 N03 N04 1.17e+00
C05 N04 N05 4.27e-06
R05 N04 N05 2.01e-01
C06 N05 N06 3.59e-06
R06 N05 N06 4.68e-02
C07 N06 N07 4.59e-06
R07 N06 N07 7.38e-03
L08 N07 N08 1.82e-11
R08 N07 N08 3.12e-01
L09 N08 N09 7.35e-11
R09 N08 N09 1.09e-01
C10 N09 N10 1.70e-06
L10 N09 N10 2.50e-12
R10 N09 N10 5.59e-03
C11 N10 N11 4.78e-08
L11 N10 N11 4.35e-11
R11 N10 N11 3.58e-02
C12 N11 N12 3.13e-11
L12 N11 N12 1.10e-11
R12 N11 N12 2.07e+00
C13 N12 Port2 5.70e-12
L13 N12 Port2 5.03e-11
R13 N12 Port2 2.12e+01
.ENDS GXT155R71E473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXT155R71H103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71H103KE01 Port1 Port2
C01 Port1 N01 9.66e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.81e-10
R03 N02 N03 4.87e-02
C04 N03 N04 8.69e-07
R04 N03 N04 1.77e+00
C05 N04 N05 7.39e-07
R05 N04 N05 3.60e-01
C06 N05 N06 9.13e-07
R06 N05 N06 6.29e-02
C07 N06 N07 5.45e-07
R07 N06 N07 2.36e-02
L08 N07 N08 5.77e-11
R08 N07 N08 2.28e-01
C09 N08 N09 1.55e-07
L09 N08 N09 4.43e-12
R09 N08 N09 1.53e-02
C10 N09 N10 9.52e-09
L10 N09 N10 3.19e-11
R10 N09 N10 7.37e-02
C11 N10 Port2 4.31e-12
L11 N10 Port2 6.52e-11
R11 N10 Port2 1.11e+01
.ENDS GXT155R71H103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GXT155R71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71H104KE01 Port1 Port2
C01 Port1 N01 9.09e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.20e-10
R03 N02 N03 1.44e-02
C04 N03 N04 4.94e-06
R04 N03 N04 4.13e-01
C05 N04 N05 7.71e-06
R05 N04 N05 3.89e-02
C06 N05 N06 9.53e-06
R06 N05 N06 7.15e-03
L07 N06 N07 1.30e-11
R07 N06 N07 8.90e-02
L08 N07 N08 9.65e-11
R08 N07 N08 6.74e-02
C09 N08 N09 6.50e-07
L09 N08 N09 1.23e-11
R09 N08 N09 1.12e-02
C10 N09 N10 1.85e-07
L10 N09 N10 2.10e-11
R10 N09 N10 2.12e-02
C11 N10 Port2 2.31e-12
L11 N10 Port2 8.12e-11
R11 N10 Port2 1.94e+01
.ENDS GXT155R71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GXT155R71H223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71H223KE01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 2.90e-02
C04 N03 N04 5.68e-06
R04 N03 N04 1.99e+00
C05 N04 N05 3.48e-06
R05 N04 N05 1.00e+00
C06 N05 N06 1.91e-06
R06 N05 N06 3.72e-01
C07 N06 N07 1.64e-06
R07 N06 N07 7.92e-02
C08 N07 N08 1.59e-06
R08 N07 N08 1.25e-02
L09 N08 N09 2.16e-11
R09 N08 N09 4.51e-01
L10 N09 N10 8.90e-11
R10 N09 N10 1.32e-01
C11 N10 N11 2.89e-07
L11 N10 N11 6.79e-12
R11 N10 N11 1.71e-02
C12 N11 N12 5.64e-08
L12 N11 N12 1.62e-11
R12 N11 N12 3.46e-02
C13 N12 N13 8.55e-12
L13 N12 N13 3.31e-11
R13 N12 N13 1.62e+01
C14 N13 Port2 1.92e-11
L14 N13 Port2 1.46e-11
R14 N13 Port2 3.63e+00
.ENDS GXT155R71H223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GXT155R71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155R71H473KE01 Port1 Port2
C01 Port1 N01 4.53e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.87e-10
R03 N02 N03 2.24e-02
C04 N03 N04 2.20e-06
R04 N03 N04 1.40e+00
C05 N04 N05 3.55e-06
R05 N04 N05 1.28e-01
C06 N05 N06 2.70e-06
R06 N05 N06 2.38e-02
L07 N06 N07 1.36e-11
R07 N06 N07 1.32e-01
L08 N07 N08 8.79e-11
R08 N07 N08 1.10e-01
C09 N08 N09 3.32e-07
L09 N08 N09 1.20e-11
R09 N08 N09 1.51e-02
C10 N09 N10 7.35e-08
L10 N09 N10 2.36e-11
R10 N09 N10 2.95e-02
C11 N10 Port2 1.51e-11
L11 N10 Port2 2.18e-11
R11 N10 Port2 5.15e+00
.ENDS GXT155R71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GXT1885C1E102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1885C1E102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GXT1885C1E103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GXT1885C1E103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/25[V]
* Murata P/N :GXT1885C1E122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C1E122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/25[V]
* Murata P/N :GXT1885C1E152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C1E152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GXT1885C1E472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GXT1885C1E472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GXT1885C1E561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXT1885C1E561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-03[uF]/25[V]
* Murata P/N :GXT1885C1E562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GXT1885C1E562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GXT1885C1E681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1E681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GXT1885C1E682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GXT1885C1E682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GXT1885C1E821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXT1885C1E821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-03[uF]/25[V]
* Murata P/N :GXT1885C1E822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1E822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GXT1885C1E822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GXT1885C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.38e-10
R03 N02 N03 3.27e-01
L04 N03 N04 4.34e-11
R04 N03 N04 1.44e+00
C05 N04 N05 7.64e-12
L05 N04 N05 8.81e-11
R05 N04 N05 1.95e+01
C06 N05 N06 8.62e-12
L06 N05 N06 5.79e-11
R06 N05 N06 1.03e+01
C07 N06 Port2 7.05e-13
L07 N06 Port2 3.07e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1885C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GXT1885C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.25e-11
R03 N02 N03 1.20e-01
L04 N03 N04 8.79e-12
R04 N03 N04 3.34e-02
C05 N04 N05 9.42e-10
L05 N04 N05 8.78e-12
R05 N04 N05 3.16e-01
C06 N05 N06 9.53e-11
L06 N05 N06 2.93e-11
R06 N05 N06 1.59e+00
C07 N06 N07 8.94e-13
L07 N06 N07 2.65e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 9.25e-13
L08 N07 Port2 2.28e-10
R08 N07 Port2 6.03e+01
.ENDS GXT1885C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXT1885C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1885C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXT1885C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GXT1885C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GXT1885C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-11
R03 N02 N03 3.60e-01
C04 N03 N04 7.42e-13
L04 N03 N04 4.62e-10
R04 N03 N04 3.51e+02
C05 N04 Port2 1.58e-11
L05 N04 Port2 7.41e-11
R05 N04 Port2 1.06e+01
.ENDS GXT1885C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GXT1885C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GXT1885C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXT1885C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GXT1885C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.50e-11
R03 N02 N03 1.70e-01
L04 N03 N04 3.49e-11
R04 N03 N04 2.68e-01
C05 N04 N05 9.95e-11
L05 N04 N05 1.79e-11
R05 N04 N05 1.87e+00
C06 N05 N06 5.77e-12
L06 N05 N06 6.79e-11
R06 N05 N06 1.21e+01
C07 N06 Port2 4.93e-13
L07 N06 Port2 4.00e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1885C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GXT1885C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXT1885C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GXT1885C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.00e-12
R03 N02 N03 2.50e-01
L04 N03 N04 2.90e-11
R04 N03 N04 1.37e-01
C05 N04 N05 5.00e-13
L05 N04 N05 4.32e-10
C06 N05 N06 1.20e-11
L06 N05 N06 3.30e-11
R06 N05 N06 3.97e+00
C07 N06 N07 3.47e-11
L07 N06 N07 2.33e-11
R07 N06 N07 3.06e+00
C08 N07 Port2 8.29e-11
L08 N07 Port2 2.17e-11
R08 N07 Port2 2.00e+00
.ENDS GXT1885C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GXT1885C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GXT1885C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXT1885C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H182JA02 Port1 Port2
C01 Port1 N01 1.81e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 2.05e-02
L04 N03 N04 5.19e-11
R04 N03 N04 2.29e-02
C05 N04 N05 1.64e-08
L05 N04 N05 1.29e-11
R05 N04 N05 1.80e-01
C06 N05 N06 3.02e-09
L06 N05 N06 2.50e-11
R06 N05 N06 3.70e-01
C07 N06 N07 8.34e-10
L07 N06 N07 2.40e-11
R07 N06 N07 2.24e-01
C08 N07 N08 8.66e-12
L08 N07 N08 4.55e-11
R08 N07 N08 8.81e-01
C09 N08 Port2 9.61e-13
L09 N08 Port2 2.31e-10
R09 N08 Port2 1.00e+05
.ENDS GXT1885C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.93e-10
R03 N02 N03 2.71e-01
L04 N03 N04 1.85e-10
R04 N03 N04 5.65e-01
C05 N04 Port2 9.41e-13
L05 N04 Port2 1.37e-10
R05 N04 Port2 1.00e+05
.ENDS GXT1885C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GXT1885C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.52e-10
R03 N02 N03 2.07e-01
L04 N03 N04 2.23e-11
R04 N03 N04 4.07e-01
C05 N04 N05 4.01e-10
L05 N04 N05 6.40e-12
R05 N04 N05 7.26e-01
C06 N05 N06 2.70e-11
L06 N05 N06 2.53e-11
R06 N05 N06 2.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 3.00e-11
R07 N06 N07 4.71e+00
C08 N07 Port2 1.29e-12
L08 N07 Port2 1.92e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GXT1885C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXT1885C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H222JA02 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.20e-10
R03 N02 N03 1.62e-02
L04 N03 N04 4.87e-11
R04 N03 N04 5.51e-01
L05 N04 N05 7.26e-11
R05 N04 N05 2.02e-02
C06 N05 N06 1.76e-08
L06 N05 N06 1.51e-11
R06 N05 N06 1.94e-01
C07 N06 N07 3.11e-09
L07 N06 N07 3.33e-11
R07 N06 N07 4.17e-01
C08 N07 N08 1.80e-09
L08 N07 N08 1.85e-11
R08 N07 N08 2.06e-01
C09 N08 N09 7.70e-12
L09 N08 N09 3.27e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 3.82e-12
L10 N09 Port2 4.88e-11
R10 N09 Port2 4.39e+01
.ENDS GXT1885C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GXT1885C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-12
R03 N02 N03 2.00e-01
L04 N03 N04 1.04e-11
R04 N03 N04 1.11e-01
C05 N04 N05 3.00e-13
L05 N04 N05 4.30e-10
C06 N05 N06 9.22e-12
L06 N05 N06 3.80e-11
R06 N05 N06 3.34e+00
C07 N06 N07 3.30e-11
L07 N06 N07 3.07e-11
R07 N06 N07 3.19e+00
C08 N07 Port2 1.77e-10
L08 N07 Port2 1.76e-11
R08 N07 Port2 1.72e+00
.ENDS GXT1885C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXT1885C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXT1885C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXT1885C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H272JA02 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.10e-10
R03 N02 N03 8.85e-03
L04 N03 N04 6.97e-11
R04 N03 N04 3.95e-01
L05 N04 N05 5.39e-11
R05 N04 N05 1.70e-02
L06 N05 N06 1.10e-10
R06 N05 N06 5.60e-03
C07 N06 N07 2.25e-08
L07 N06 N07 1.50e-11
R07 N06 N07 2.27e-01
C08 N07 N08 4.93e-09
L08 N07 N08 3.05e-11
R08 N07 N08 3.76e-01
C09 N08 N09 5.43e-09
L09 N08 N09 9.13e-12
R09 N08 N09 1.31e-01
C10 N09 Port2 3.95e-12
L10 N09 Port2 8.52e-11
R10 N09 Port2 3.84e+01
.ENDS GXT1885C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 1.56e-01
L04 N03 N04 1.68e-10
R04 N03 N04 3.08e-01
C05 N04 Port2 5.01e-12
L05 N04 Port2 6.41e-11
R05 N04 Port2 2.80e+01
.ENDS GXT1885C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GXT1885C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.89e-01
L04 N03 N04 2.09e-11
R04 N03 N04 2.94e-01
C05 N04 N05 1.82e-10
L05 N04 N05 2.02e-11
R05 N04 N05 2.22e+00
C06 N05 N06 8.98e-11
L06 N05 N06 1.23e-11
R06 N05 N06 1.59e+00
C07 N06 N07 9.59e-12
L07 N06 N07 4.43e-11
R07 N06 N07 6.69e+00
C08 N07 Port2 9.51e-13
L08 N07 Port2 2.55e-10
R08 N07 Port2 1.41e+09
.ENDS GXT1885C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXT1885C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1885C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXT1885C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H332JA02 Port1 Port2
C01 Port1 N01 3.17e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.80e-10
R03 N02 N03 1.30e-02
L04 N03 N04 6.85e-11
R04 N03 N04 3.59e-01
L05 N04 N05 5.87e-11
R05 N04 N05 9.32e-03
C06 N05 N06 1.87e-08
L06 N05 N06 2.12e-11
R06 N05 N06 2.45e-01
C07 N06 N07 4.92e-09
L07 N06 N07 3.73e-11
R07 N06 N07 4.02e-01
C08 N07 N08 4.77e-09
L08 N07 N08 1.37e-11
R08 N07 N08 1.46e-01
C09 N08 N09 3.76e-11
L09 N08 N09 9.32e-12
R09 N08 N09 1.98e+00
C10 N09 Port2 4.05e-12
L10 N09 Port2 6.98e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GXT1885C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.80e-01
C04 N03 N04 8.14e-13
L04 N03 N04 3.55e-10
C05 N04 N05 4.33e-12
L05 N04 N05 9.14e-11
R05 N04 N05 1.72e+01
C06 N05 N06 3.46e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.56e+00
C07 N06 Port2 2.62e-10
L07 N06 Port2 1.80e-11
R07 N06 Port2 1.45e+00
.ENDS GXT1885C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXT1885C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXT1885C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXT1885C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H392JA02 Port1 Port2
C01 Port1 N01 3.84e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 7.60e-03
L04 N03 N04 1.02e-10
R04 N03 N04 3.69e-01
L05 N04 N05 5.34e-11
R05 N04 N05 1.33e-02
L06 N05 N06 1.38e-10
R06 N05 N06 5.29e-03
C07 N06 N07 2.13e-08
L07 N06 N07 2.39e-11
R07 N06 N07 3.03e-01
C08 N07 N08 8.43e-09
L08 N07 N08 2.82e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 1.70e-11
L09 N08 Port2 2.15e-11
R09 N08 Port2 5.93e+00
.ENDS GXT1885C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.43e-10
R03 N02 N03 1.45e-01
L04 N03 N04 1.39e-10
R04 N03 N04 3.29e-01
C05 N04 Port2 4.81e-12
L05 N04 Port2 7.00e-11
R05 N04 Port2 3.16e+01
.ENDS GXT1885C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GXT1885C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.77e-11
R03 N02 N03 1.51e-01
L04 N03 N04 2.91e-11
R04 N03 N04 2.48e+00
C05 N04 N05 3.18e-10
L05 N04 N05 1.89e-11
R05 N04 N05 1.58e+00
C06 N05 N06 5.06e-11
L06 N05 N06 3.41e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.18e-11
L07 N06 N07 3.87e-11
R07 N06 N07 4.81e+00
C08 N07 Port2 6.00e-13
L08 N07 Port2 3.14e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXT1885C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXT1885C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GXT1885C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.92e-10
R03 N02 N03 1.43e-01
L04 N03 N04 1.14e-10
R04 N03 N04 2.57e-01
C05 N04 N05 8.50e-12
L05 N04 N05 4.98e-11
R05 N04 N05 2.28e+01
C06 N05 Port2 7.58e-12
L06 N05 Port2 4.44e-11
R06 N05 Port2 1.31e+02
.ENDS GXT1885C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GXT1885C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.90e-01
L04 N03 N04 6.82e-11
R04 N03 N04 5.32e+00
C05 N04 N05 6.97e-13
L05 N04 N05 5.30e-10
R05 N04 N05 4.49e+02
C06 N05 N06 9.78e-11
L06 N05 N06 1.22e-11
R06 N05 N06 1.25e+00
C07 N06 Port2 6.52e-10
L07 N06 Port2 9.24e-12
R07 N06 Port2 5.79e-01
.ENDS GXT1885C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXT1885C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXT1885C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXT1885C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GXT1885C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 1.25e-01
L04 N03 N04 5.72e-11
R04 N03 N04 1.82e-01
C05 N04 N05 1.38e-11
L05 N04 N05 4.43e-11
R05 N04 N05 2.47e+01
C06 N05 Port2 1.94e-12
L06 N05 Port2 1.65e-10
R06 N05 Port2 9.72e+01
.ENDS GXT1885C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GXT1885C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.38e-11
R03 N02 N03 1.41e-01
L04 N03 N04 2.21e-11
R04 N03 N04 2.51e-01
C05 N04 N05 4.99e-10
L05 N04 N05 1.53e-11
R05 N04 N05 9.03e-01
C06 N05 N06 1.53e-10
L06 N05 N06 1.33e-11
R06 N05 N06 8.63e-01
C07 N06 N07 1.32e-10
L07 N06 N07 7.74e-12
R07 N06 N07 1.09e+00
C08 N07 N08 1.29e-11
L08 N07 N08 3.12e-11
R08 N07 N08 3.10e+00
C09 N08 Port2 4.13e-13
L09 N08 Port2 4.26e-10
R09 N08 Port2 1.51e+05
.ENDS GXT1885C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXT1885C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXT1885C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GXT1885C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.40e-10
R03 N02 N03 1.10e-01
L04 N03 N04 8.15e-11
R04 N03 N04 2.31e-01
C05 N04 N05 2.29e-09
L05 N04 N05 4.21e-13
R05 N04 N05 1.88e-01
C06 N05 N06 2.26e-11
L06 N05 N06 2.50e-11
R06 N05 N06 7.74e+00
C07 N06 Port2 2.92e-12
L07 N06 Port2 1.10e-10
R07 N06 Port2 6.77e+01
.ENDS GXT1885C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.75e-10
R03 N02 N03 1.07e-01
L04 N03 N04 9.00e-11
R04 N03 N04 2.08e-01
C05 N04 Port2 3.10e-12
L05 N04 Port2 1.10e-10
R05 N04 Port2 5.56e+01
.ENDS GXT1885C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GXT1885C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 1.40e-01
L04 N03 N04 8.63e-11
R04 N03 N04 3.05e+00
C05 N04 N05 7.57e-13
L05 N04 N05 3.72e-10
C06 N05 N06 4.91e-12
L06 N05 N06 7.68e-11
R06 N05 N06 1.24e+01
C07 N06 N07 5.16e-10
L07 N06 N07 5.01e-12
R07 N06 N07 4.41e-01
C08 N07 Port2 6.77e-10
L08 N07 Port2 1.39e-11
R08 N07 Port2 8.02e-01
.ENDS GXT1885C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXT1885C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXT1885C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXT1885C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GXT1885C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.08e-01
L04 N03 N04 6.03e-11
R04 N03 N04 1.82e-01
C05 N04 N05 3.98e-11
L05 N04 N05 2.32e-11
R05 N04 N05 1.21e+01
C06 N05 N06 6.70e-12
L06 N05 N06 6.18e-11
R06 N05 N06 2.22e+01
C07 N06 Port2 2.58e-12
L07 N06 Port2 1.04e-10
R07 N06 Port2 1.17e+02
.ENDS GXT1885C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GXT1885C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.56e-10
R03 N02 N03 1.02e-01
L04 N03 N04 7.41e-11
R04 N03 N04 1.88e-01
C05 N04 N05 4.74e-11
L05 N04 N05 2.21e-11
R05 N04 N05 9.56e+00
C06 N05 N06 8.52e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.89e+01
C07 N06 Port2 8.92e-12
L07 N06 Port2 3.60e-11
R07 N06 Port2 2.37e+01
.ENDS GXT1885C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GXT1885C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.38e-10
R03 N02 N03 3.27e-01
L04 N03 N04 4.34e-11
R04 N03 N04 1.44e+00
C05 N04 N05 7.64e-12
L05 N04 N05 8.81e-11
R05 N04 N05 1.95e+01
C06 N05 N06 8.62e-12
L06 N05 N06 5.79e-11
R06 N05 N06 1.03e+01
C07 N06 Port2 7.05e-13
L07 N06 Port2 3.07e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1885C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GXT1885C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.25e-11
R03 N02 N03 1.20e-01
L04 N03 N04 8.79e-12
R04 N03 N04 3.34e-02
C05 N04 N05 9.42e-10
L05 N04 N05 8.78e-12
R05 N04 N05 3.16e-01
C06 N05 N06 9.53e-11
L06 N05 N06 2.93e-11
R06 N05 N06 1.59e+00
C07 N06 N07 8.94e-13
L07 N06 N07 2.65e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 9.25e-13
L08 N07 Port2 2.28e-10
R08 N07 Port2 6.03e+01
.ENDS GXT1885C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GXT1885C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXT1885C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GXT1885C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-11
R03 N02 N03 3.60e-01
C04 N03 N04 7.42e-13
L04 N03 N04 4.62e-10
R04 N03 N04 3.51e+02
C05 N04 Port2 1.58e-11
L05 N04 Port2 7.41e-11
R05 N04 Port2 1.06e+01
.ENDS GXT1885C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GXT1885C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GXT1885C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GXT1885C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 1.02e-02
L04 N03 N04 5.61e-11
R04 N03 N04 5.09e-01
L05 N04 N05 6.27e-11
R05 N04 N05 2.60e-02
L06 N05 N06 1.55e-10
R06 N05 N06 1.01e-02
C07 N06 N07 1.30e-08
L07 N06 N07 9.93e-12
R07 N06 N07 1.52e-01
C08 N07 N08 1.95e-09
L08 N07 N08 2.77e-11
R08 N07 N08 4.83e-01
C09 N08 N09 3.31e-12
L09 N08 N09 1.00e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 6.28e-12
L10 N09 Port2 4.44e-11
R10 N09 Port2 9.95e+00
.ENDS GXT1885C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GXT1885C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.25e-12
R03 N02 N03 2.46e-01
L04 N03 N04 1.48e-10
R04 N03 N04 4.37e+01
L05 N04 N05 5.03e-12
R05 N04 N05 6.52e-02
C06 N05 N06 1.82e-10
L06 N05 N06 9.87e-12
R06 N05 N06 9.76e-01
C07 N06 N07 3.90e-12
L07 N06 N07 1.00e-10
R07 N06 N07 1.78e+01
C08 N07 Port2 9.65e-13
L08 N07 Port2 2.69e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GXT1885C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GXT1885C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXT1885C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GXT1885C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.00e-12
R03 N02 N03 2.50e-01
L04 N03 N04 2.90e-11
R04 N03 N04 1.37e-01
C05 N04 N05 5.00e-13
L05 N04 N05 4.32e-10
C06 N05 N06 1.20e-11
L06 N05 N06 3.30e-11
R06 N05 N06 3.97e+00
C07 N06 N07 3.47e-11
L07 N06 N07 2.33e-11
R07 N06 N07 3.06e+00
C08 N07 Port2 8.29e-11
L08 N07 Port2 2.17e-11
R08 N07 Port2 2.00e+00
.ENDS GXT1885C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GXT1885C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GXT1885C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.93e-10
R03 N02 N03 2.71e-01
L04 N03 N04 1.85e-10
R04 N03 N04 5.65e-01
C05 N04 Port2 9.41e-13
L05 N04 Port2 1.37e-10
R05 N04 Port2 1.00e+05
.ENDS GXT1885C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GXT1885C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.52e-10
R03 N02 N03 2.07e-01
L04 N03 N04 2.23e-11
R04 N03 N04 4.07e-01
C05 N04 N05 4.01e-10
L05 N04 N05 6.40e-12
R05 N04 N05 7.26e-01
C06 N05 N06 2.70e-11
L06 N05 N06 2.53e-11
R06 N05 N06 2.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 3.00e-11
R07 N06 N07 4.71e+00
C08 N07 Port2 1.29e-12
L08 N07 Port2 1.92e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GXT1885C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GXT1885C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-12
R03 N02 N03 2.00e-01
L04 N03 N04 1.04e-11
R04 N03 N04 1.11e-01
C05 N04 N05 3.00e-13
L05 N04 N05 4.30e-10
C06 N05 N06 9.22e-12
L06 N05 N06 3.80e-11
R06 N05 N06 3.34e+00
C07 N06 N07 3.30e-11
L07 N06 N07 3.07e-11
R07 N06 N07 3.19e+00
C08 N07 Port2 1.77e-10
L08 N07 Port2 1.76e-11
R08 N07 Port2 1.72e+00
.ENDS GXT1885C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GXT1885C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXT1885C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 1.56e-01
L04 N03 N04 1.68e-10
R04 N03 N04 3.08e-01
C05 N04 Port2 5.01e-12
L05 N04 Port2 6.41e-11
R05 N04 Port2 2.80e+01
.ENDS GXT1885C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GXT1885C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.89e-01
L04 N03 N04 2.09e-11
R04 N03 N04 2.94e-01
C05 N04 N05 1.82e-10
L05 N04 N05 2.02e-11
R05 N04 N05 2.22e+00
C06 N05 N06 8.98e-11
L06 N05 N06 1.23e-11
R06 N05 N06 1.59e+00
C07 N06 N07 9.59e-12
L07 N06 N07 4.43e-11
R07 N06 N07 6.69e+00
C08 N07 Port2 9.51e-13
L08 N07 Port2 2.55e-10
R08 N07 Port2 1.41e+09
.ENDS GXT1885C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GXT1885C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXT1885C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GXT1885C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.80e-01
C04 N03 N04 8.14e-13
L04 N03 N04 3.55e-10
C05 N04 N05 4.33e-12
L05 N04 N05 9.14e-11
R05 N04 N05 1.72e+01
C06 N05 N06 3.46e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.56e+00
C07 N06 Port2 2.62e-10
L07 N06 Port2 1.80e-11
R07 N06 Port2 1.45e+00
.ENDS GXT1885C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GXT1885C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXT1885C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.43e-10
R03 N02 N03 1.45e-01
L04 N03 N04 1.39e-10
R04 N03 N04 3.29e-01
C05 N04 Port2 4.81e-12
L05 N04 Port2 7.00e-11
R05 N04 Port2 3.16e+01
.ENDS GXT1885C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GXT1885C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.77e-11
R03 N02 N03 1.51e-01
L04 N03 N04 2.91e-11
R04 N03 N04 2.48e+00
C05 N04 N05 3.18e-10
L05 N04 N05 1.89e-11
R05 N04 N05 1.58e+00
C06 N05 N06 5.06e-11
L06 N05 N06 3.41e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.18e-11
L07 N06 N07 3.87e-11
R07 N06 N07 4.81e+00
C08 N07 Port2 6.00e-13
L08 N07 Port2 3.14e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GXT1885C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.92e-10
R03 N02 N03 1.43e-01
L04 N03 N04 1.14e-10
R04 N03 N04 2.57e-01
C05 N04 N05 8.50e-12
L05 N04 N05 4.98e-11
R05 N04 N05 2.28e+01
C06 N05 Port2 7.58e-12
L06 N05 Port2 4.44e-11
R06 N05 Port2 1.31e+02
.ENDS GXT1885C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GXT1885C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.90e-01
L04 N03 N04 6.82e-11
R04 N03 N04 5.32e+00
C05 N04 N05 6.97e-13
L05 N04 N05 5.30e-10
R05 N04 N05 4.49e+02
C06 N05 N06 9.78e-11
L06 N05 N06 1.22e-11
R06 N05 N06 1.25e+00
C07 N06 Port2 6.52e-10
L07 N06 Port2 9.24e-12
R07 N06 Port2 5.79e-01
.ENDS GXT1885C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GXT1885C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXT1885C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 1.25e-01
L04 N03 N04 5.72e-11
R04 N03 N04 1.82e-01
C05 N04 N05 1.38e-11
L05 N04 N05 4.43e-11
R05 N04 N05 2.47e+01
C06 N05 Port2 1.94e-12
L06 N05 Port2 1.65e-10
R06 N05 Port2 9.72e+01
.ENDS GXT1885C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GXT1885C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.38e-11
R03 N02 N03 1.41e-01
L04 N03 N04 2.21e-11
R04 N03 N04 2.51e-01
C05 N04 N05 4.99e-10
L05 N04 N05 1.53e-11
R05 N04 N05 9.03e-01
C06 N05 N06 1.53e-10
L06 N05 N06 1.33e-11
R06 N05 N06 8.63e-01
C07 N06 N07 1.32e-10
L07 N06 N07 7.74e-12
R07 N06 N07 1.09e+00
C08 N07 N08 1.29e-11
L08 N07 N08 3.12e-11
R08 N07 N08 3.10e+00
C09 N08 Port2 4.13e-13
L09 N08 Port2 4.26e-10
R09 N08 Port2 1.51e+05
.ENDS GXT1885C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GXT1885C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXT1885C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.40e-10
R03 N02 N03 1.10e-01
L04 N03 N04 8.15e-11
R04 N03 N04 2.31e-01
C05 N04 N05 2.29e-09
L05 N04 N05 4.21e-13
R05 N04 N05 1.88e-01
C06 N05 N06 2.26e-11
L06 N05 N06 2.50e-11
R06 N05 N06 7.74e+00
C07 N06 Port2 2.92e-12
L07 N06 Port2 1.10e-10
R07 N06 Port2 6.77e+01
.ENDS GXT1885C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.75e-10
R03 N02 N03 1.07e-01
L04 N03 N04 9.00e-11
R04 N03 N04 2.08e-01
C05 N04 Port2 3.10e-12
L05 N04 Port2 1.10e-10
R05 N04 Port2 5.56e+01
.ENDS GXT1885C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GXT1885C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 1.40e-01
L04 N03 N04 8.63e-11
R04 N03 N04 3.05e+00
C05 N04 N05 7.57e-13
L05 N04 N05 3.72e-10
C06 N05 N06 4.91e-12
L06 N05 N06 7.68e-11
R06 N05 N06 1.24e+01
C07 N06 N07 5.16e-10
L07 N06 N07 5.01e-12
R07 N06 N07 4.41e-01
C08 N07 Port2 6.77e-10
L08 N07 Port2 1.39e-11
R08 N07 Port2 8.02e-01
.ENDS GXT1885C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GXT1885C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXT1885C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.08e-01
L04 N03 N04 6.03e-11
R04 N03 N04 1.82e-01
C05 N04 N05 3.98e-11
L05 N04 N05 2.32e-11
R05 N04 N05 1.21e+01
C06 N05 N06 6.70e-12
L06 N05 N06 6.18e-11
R06 N05 N06 2.22e+01
C07 N06 Port2 2.58e-12
L07 N06 Port2 1.04e-10
R07 N06 Port2 1.17e+02
.ENDS GXT1885C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GXT1885C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT1885C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.56e-10
R03 N02 N03 1.02e-01
L04 N03 N04 7.41e-11
R04 N03 N04 1.88e-01
C05 N04 N05 4.74e-11
L05 N04 N05 2.21e-11
R05 N04 N05 9.56e+00
C06 N05 N06 8.52e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.89e+01
C07 N06 Port2 8.92e-12
L07 N06 Port2 3.60e-11
R07 N06 Port2 2.37e+01
.ENDS GXT1885C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/4[V]
* Murata P/N :GXT188C80G105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C80G105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GXT188C80G105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GXT188C80G106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C80G106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GXT188C80G106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GXT188C81A106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81A106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GXT188C81A106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GXT188C81C106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81C106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GXT188C81C106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GXT188C81C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81C225KE13 Port1 Port2
C01 Port1 N01 1.55e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.49e-10
R03 N02 N03 6.05e-03
C04 N03 N04 5.84e-05
R04 N03 N04 7.38e+01
C05 N04 N05 5.16e-05
R05 N04 N05 9.53e+00
C06 N05 N06 4.52e-05
R06 N05 N06 1.08e+00
C07 N06 N07 3.81e-05
R07 N06 N07 1.25e-01
C08 N07 N08 2.99e-05
R08 N07 N08 1.58e-02
L09 N08 N09 2.88e-11
R09 N08 N09 6.98e-02
L10 N09 N10 2.01e-10
R10 N09 N10 2.99e-02
C11 N10 N11 4.09e-06
L11 N10 N11 5.37e-11
R11 N10 N11 6.06e-03
C12 N11 N12 6.10e-06
L12 N11 N12 2.03e-11
R12 N11 N12 6.17e-03
C13 N12 Port2 2.14e-12
L13 N12 Port2 1.38e-10
R13 N12 Port2 3.10e+01
.ENDS GXT188C81C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GXT188C81C475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81C475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188C81C475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GXT188C81C475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81C475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188C81C475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GXT188C81E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81E225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GXT188C81E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GXT188C81E225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81E225ME13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GXT188C81E225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GXT188C81E475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81E475KE13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GXT188C81E475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GXT188C81E475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C81E475ME13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GXT188C81E475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GXT188C8YA225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188C8YA225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GXT188C8YA225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GXT188R60G106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60G106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GXT188R60G106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GXT188R60J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60J105KE01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GXT188R60J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GXT188R60J105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60J105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GXT188R60J105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GXT188R60J106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60J106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GXT188R60J106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GXT188R60J225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60J225KE13 Port1 Port2
C01 Port1 N01 1.92e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.50e-10
R03 N02 N03 4.58e-03
C04 N03 N04 6.49e-05
R04 N03 N04 8.36e+01
C05 N04 N05 1.07e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.31e-04
R06 N05 N06 3.08e-01
C07 N06 N07 1.12e-04
R07 N06 N07 3.56e-02
C08 N07 N08 7.98e-05
R08 N07 N08 5.07e-03
L09 N08 N09 1.20e-11
R09 N08 N09 9.96e-02
L10 N09 N10 2.71e-11
R10 N09 N10 3.45e-02
L11 N10 N11 2.15e-10
R11 N10 N11 2.36e-02
C12 N11 N12 8.50e-06
L12 N11 N12 3.25e-11
R12 N11 N12 5.00e-03
C13 N12 N13 5.87e-06
L13 N12 N13 2.43e-11
R13 N12 N13 5.08e-03
C14 N13 Port2 2.11e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 4.70e+01
.ENDS GXT188R60J225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GXT188R60J475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R60J475KE01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GXT188R60J475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GXT188R61A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61A105KE01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GXT188R61A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GXT188R61A105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61A105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GXT188R61A105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GXT188R61A225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61A225KE13 Port1 Port2
C01 Port1 N01 1.92e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.50e-10
R03 N02 N03 4.58e-03
C04 N03 N04 6.49e-05
R04 N03 N04 8.36e+01
C05 N04 N05 1.07e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.31e-04
R06 N05 N06 3.08e-01
C07 N06 N07 1.12e-04
R07 N06 N07 3.56e-02
C08 N07 N08 7.98e-05
R08 N07 N08 5.07e-03
L09 N08 N09 1.20e-11
R09 N08 N09 9.96e-02
L10 N09 N10 2.71e-11
R10 N09 N10 3.45e-02
L11 N10 N11 2.15e-10
R11 N10 N11 2.36e-02
C12 N11 N12 8.50e-06
L12 N11 N12 3.25e-11
R12 N11 N12 5.00e-03
C13 N12 N13 5.87e-06
L13 N12 N13 2.43e-11
R13 N12 N13 5.08e-03
C14 N13 Port2 2.11e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 4.70e+01
.ENDS GXT188R61A225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GXT188R61C106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61C106ME13 Port1 Port2
C01 Port1 N01 6.59e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.28e-10
R03 N02 N03 3.44e-03
C04 N03 N04 3.33e-04
R04 N03 N04 9.64e+00
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.70e-04
R06 N05 N06 3.50e-01
C07 N06 N07 2.51e-04
R07 N06 N07 3.86e-02
C08 N07 N08 1.94e-04
R08 N07 N08 5.68e-03
L09 N08 N09 5.94e-12
R09 N08 N09 1.45e-01
L10 N09 N10 1.64e-11
R10 N09 N10 1.03e-01
L11 N10 N11 4.86e-11
R11 N10 N11 3.71e-02
L12 N11 N12 3.08e-10
R12 N11 N12 1.66e-02
C13 N12 N13 4.02e-05
L13 N12 N13 3.37e-11
R13 N12 N13 2.25e-03
C14 N13 N14 1.81e-05
L14 N13 N14 4.59e-11
R14 N13 N14 3.31e-03
C15 N14 Port2 2.31e-11
L15 N14 Port2 1.61e-11
R15 N14 Port2 4.30e+00
.ENDS GXT188R61C106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GXT188R61C475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61C475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188R61C475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GXT188R61C475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61C475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188R61C475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT188R61E106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61E106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GXT188R61E106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GXT188R61E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61E225KE13 Port1 Port2
C01 Port1 N01 1.55e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.49e-10
R03 N02 N03 6.05e-03
C04 N03 N04 5.84e-05
R04 N03 N04 7.38e+01
C05 N04 N05 5.16e-05
R05 N04 N05 9.53e+00
C06 N05 N06 4.52e-05
R06 N05 N06 1.08e+00
C07 N06 N07 3.81e-05
R07 N06 N07 1.25e-01
C08 N07 N08 2.99e-05
R08 N07 N08 1.58e-02
L09 N08 N09 2.88e-11
R09 N08 N09 6.98e-02
L10 N09 N10 2.01e-10
R10 N09 N10 2.99e-02
C11 N10 N11 4.09e-06
L11 N10 N11 5.37e-11
R11 N10 N11 6.06e-03
C12 N11 N12 6.10e-06
L12 N11 N12 2.03e-11
R12 N11 N12 6.17e-03
C13 N12 Port2 2.14e-12
L13 N12 Port2 1.38e-10
R13 N12 Port2 3.10e+01
.ENDS GXT188R61E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GXT188R61E475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61E475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188R61E475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GXT188R61E475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61E475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GXT188R61E475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GXT188R61H225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61H225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GXT188R61H225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GXT188R61H225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R61H225ME13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GXT188R61H225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GXT188R6YA225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R6YA225KE13 Port1 Port2
C01 Port1 N01 1.41e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.78e-10
R03 N02 N03 5.47e-03
C04 N03 N04 7.99e-05
R04 N03 N04 5.52e+01
C05 N04 N05 6.06e-05
R05 N04 N05 6.17e+00
C06 N05 N06 5.00e-05
R06 N05 N06 7.40e-01
C07 N06 N07 4.71e-05
R07 N06 N07 8.61e-02
C08 N07 N08 3.25e-05
R08 N07 N08 1.60e-02
C09 N08 N09 4.41e-05
R09 N08 N09 2.00e-03
L10 N09 N10 3.58e-11
R10 N09 N10 8.02e-02
L11 N10 N11 2.29e-10
R11 N10 N11 3.02e-02
C12 N11 N12 7.53e-06
L12 N11 N12 2.62e-11
R12 N11 N12 5.42e-03
C13 N12 N13 3.80e-06
L13 N12 N13 2.71e-11
R13 N12 N13 6.82e-03
C14 N13 Port2 3.04e-12
L14 N13 Port2 1.23e-10
R14 N13 Port2 3.79e+01
.ENDS GXT188R6YA225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GXT188R6YA475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R6YA475KE13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GXT188R6YA475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GXT188R6YA475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R6YA475ME13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GXT188R6YA475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GXT188R70J225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R70J225KE13 Port1 Port2
C01 Port1 N01 1.71e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.27e-11
R03 N02 N03 5.94e-03
C04 N03 N04 1.31e-05
R04 N03 N04 5.45e+02
C05 N04 N05 4.06e-05
R05 N04 N05 9.88e+00
C06 N05 N06 3.98e-05
R06 N05 N06 9.97e-01
C07 N06 N07 3.39e-05
R07 N06 N07 1.18e-01
C08 N07 N08 2.49e-05
R08 N07 N08 1.59e-02
L09 N08 N09 3.31e-11
R09 N08 N09 6.97e-02
L10 N09 N10 2.13e-10
R10 N09 N10 3.21e-02
C11 N10 N11 4.31e-06
L11 N10 N11 5.61e-11
R11 N10 N11 7.22e-03
C12 N11 N12 4.44e-06
L12 N11 N12 2.54e-11
R12 N11 N12 7.74e-03
C13 N12 Port2 1.28e-12
L13 N12 Port2 1.86e-10
R13 N12 Port2 5.44e+01
.ENDS GXT188R70J225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GXT188R71C105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R71C105KE13 Port1 Port2
C01 Port1 N01 7.22e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.05e-10
R03 N02 N03 6.64e-03
C04 N03 N04 5.45e-06
R04 N03 N04 1.28e+03
C05 N04 N05 1.84e-05
R05 N04 N05 1.75e+01
C06 N05 N06 1.87e-05
R06 N05 N06 1.73e+00
C07 N06 N07 1.44e-05
R07 N06 N07 2.23e-01
C08 N07 N08 1.23e-05
R08 N07 N08 2.61e-02
C09 N08 N09 1.07e-05
R09 N08 N09 2.34e-03
L10 N09 N10 1.19e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.17e-11
R11 N10 N11 4.75e-02
L12 N11 N12 1.75e-10
R12 N11 N12 4.14e-02
C13 N12 N13 2.48e-06
L13 N12 N13 3.63e-11
R13 N12 N13 1.05e-02
C14 N13 N14 1.23e-06
L14 N13 N14 3.64e-11
R14 N13 N14 1.44e-02
C15 N14 Port2 4.05e-12
L15 N14 Port2 9.16e-11
R15 N14 Port2 1.92e+01
.ENDS GXT188R71C105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GXT188R71E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT188R71E105KE13 Port1 Port2
C01 Port1 N01 7.22e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.05e-10
R03 N02 N03 6.64e-03
C04 N03 N04 5.45e-06
R04 N03 N04 1.28e+03
C05 N04 N05 1.84e-05
R05 N04 N05 1.75e+01
C06 N05 N06 1.87e-05
R06 N05 N06 1.73e+00
C07 N06 N07 1.44e-05
R07 N06 N07 2.23e-01
C08 N07 N08 1.23e-05
R08 N07 N08 2.61e-02
C09 N08 N09 1.07e-05
R09 N08 N09 2.34e-03
L10 N09 N10 1.19e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.17e-11
R11 N10 N11 4.75e-02
L12 N11 N12 1.75e-10
R12 N11 N12 4.14e-02
C13 N12 N13 2.48e-06
L13 N12 N13 3.63e-11
R13 N12 N13 1.05e-02
C14 N13 N14 1.23e-06
L14 N13 N14 3.64e-11
R14 N13 N14 1.44e-02
C15 N14 Port2 4.05e-12
L15 N14 Port2 9.16e-11
R15 N14 Port2 1.92e+01
.ENDS GXT188R71E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GXT21BC81A226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BC81A226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GXT21BC81A226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GXT21BR60J106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR60J106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GXT21BR60J106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GXT21BR61A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR61A106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GXT21BR61A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GXT21BR61C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR61C106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GXT21BR61C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GXT21BR61C226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR61C226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GXT21BR61C226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GXT21BR61E226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR61E226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GXT21BR61E226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GXT21BR71A106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR71A106KE13 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GXT21BR71A106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GXT21BR71A475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR71A475KE13 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GXT21BR71A475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GXT21BR71E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR71E225KE13 Port1 Port2
C01 Port1 N01 1.85e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.56e-11
R03 N02 N03 4.83e-03
C04 N03 N04 1.77e-05
R04 N03 N04 3.86e+02
C05 N04 N05 5.67e-05
R05 N04 N05 8.49e+00
C06 N05 N06 4.92e-05
R06 N05 N06 9.87e-01
C07 N06 N07 3.91e-05
R07 N06 N07 1.23e-01
C08 N07 N08 2.92e-05
R08 N07 N08 1.64e-02
L09 N08 N09 7.30e-12
R09 N08 N09 4.41e-02
L10 N09 N10 2.22e-11
R10 N09 N10 3.12e-02
L11 N10 N11 2.40e-10
R11 N10 N11 3.08e-02
C12 N11 N12 5.46e-06
L12 N11 N12 4.73e-11
R12 N11 N12 1.20e-02
C13 N12 N13 2.78e-06
L13 N12 N13 4.65e-11
R13 N12 N13 1.18e-02
C14 N13 N14 8.94e-12
L14 N13 N14 8.64e-11
R14 N13 N14 1.02e+01
C15 N14 Port2 1.61e-12
L15 N14 Port2 1.33e-10
R15 N14 Port2 7.29e+01
.ENDS GXT21BR71E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GXT21BR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT21BR71H105KE01 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 7.42e-11
R03 N02 N03 3.95e-03
C04 N03 N04 2.83e-05
R04 N03 N04 2.36e+02
C05 N04 N05 1.58e-04
R05 N04 N05 1.60e+00
C06 N05 N06 1.60e-04
R06 N05 N06 1.45e-01
C07 N06 N07 1.35e-04
R07 N06 N07 1.68e-02
C08 N07 N08 1.32e-04
R08 N07 N08 1.80e-03
L09 N08 N09 1.85e-10
R09 N08 N09 3.32e-02
L10 N09 N10 1.32e-11
R10 N09 N10 2.59e-02
C11 N10 N11 3.39e-06
L11 N10 N11 4.78e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.96e-06
L12 N11 N12 3.67e-11
R12 N11 N12 1.82e-02
C13 N12 N13 1.19e-11
L13 N12 N13 9.44e-11
R13 N12 N13 9.28e+00
C14 N13 Port2 1.87e-12
L14 N13 Port2 1.62e-10
R14 N13 Port2 4.64e+01
.ENDS GXT21BR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT31CC81E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CC81E106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CC81E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GXT31CC8YA106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CC8YA106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CC8YA106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GXT31CC8YA106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CC8YA106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CC8YA106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT31CR61E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR61E106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CR61E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT31CR61E106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR61E106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CR61E106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GXT31CR6YA106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR6YA106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CR6YA106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GXT31CR6YA106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR6YA106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GXT31CR6YA106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GXT31CR70J226KE13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR70J226KE13 Port1 Port2
C01 Port1 N01 1.57e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 9.52e-11
R03 N02 N03 2.55e-03
C04 N03 N04 3.18e-04
R04 N03 N04 1.79e+01
C05 N04 N05 4.26e-04
R05 N04 N05 1.19e+00
C06 N05 N06 4.20e-04
R06 N05 N06 1.20e-01
C07 N06 N07 3.56e-04
R07 N06 N07 1.44e-02
C08 N07 N08 3.23e-04
R08 N07 N08 1.57e-03
L09 N08 N09 1.93e-11
R09 N08 N09 3.44e-02
L10 N09 N10 6.02e-11
R10 N09 N10 2.23e-02
L11 N10 N11 4.30e-10
R11 N10 N11 1.41e-02
C12 N11 N12 4.06e-05
L12 N11 N12 9.85e-11
R12 N11 N12 4.28e-03
C13 N12 N13 1.86e-05
L13 N12 N13 1.03e-10
R13 N12 N13 4.54e-03
C14 N13 N14 1.94e-11
L14 N13 N14 6.62e-11
R14 N13 N14 1.15e+01
C15 N14 Port2 1.29e-12
L15 N14 Port2 3.27e-10
R15 N14 Port2 9.49e+01
.ENDS GXT31CR70J226KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT31CR71E106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR71E106KE13 Port1 Port2
C01 Port1 N01 7.09e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.66e-10
R03 N02 N03 3.46e-03
C04 N03 N04 1.83e-04
R04 N03 N04 2.90e+01
C05 N04 N05 2.14e-04
R05 N04 N05 2.30e+00
C06 N05 N06 2.00e-04
R06 N05 N06 2.42e-01
C07 N06 N07 1.64e-04
R07 N06 N07 2.96e-02
C08 N07 N08 1.90e-04
R08 N07 N08 3.19e-03
L09 N08 N09 1.39e-11
R09 N08 N09 7.13e-02
L10 N09 N10 4.75e-11
R10 N09 N10 3.32e-02
L11 N10 N11 3.34e-10
R11 N10 N11 1.93e-02
C12 N11 N12 2.36e-05
L12 N11 N12 7.63e-11
R12 N11 N12 7.27e-03
C13 N12 N13 8.63e-06
L13 N12 N13 9.88e-11
R13 N12 N13 8.31e-03
C14 N13 N14 2.10e-11
L14 N13 N14 5.85e-11
R14 N13 N14 9.62e+00
C15 N14 Port2 1.69e-12
L15 N14 Port2 2.60e-10
R15 N14 Port2 1.06e+02
.ENDS GXT31CR71E106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GXT32DC81E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT32DC81E106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GXT32DC81E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GXT32EC80J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT32EC80J476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GXT32EC80J476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GXT32EC81A476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT32EC81A476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GXT32EC81A476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/16[V]
* Murata P/N :GXT32EC81C476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT32EC81C476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GXT32EC81C476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GXT32ER70J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT32ER70J476KE13 Port1 Port2
C01 Port1 N01 3.28e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.86e-10
R03 N02 N03 1.49e-03
C04 N03 N04 7.17e-04
R04 N03 N04 7.57e+00
C05 N04 N05 1.00e-03
R05 N04 N05 3.80e-01
C06 N05 N06 9.35e-04
R06 N05 N06 4.04e-02
C07 N06 N07 7.45e-04
R07 N06 N07 4.99e-03
C08 N07 N08 2.56e-03
R08 N07 N08 1.78e-04
L09 N08 N09 1.28e-11
R09 N08 N09 6.18e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.00e-02
L11 N10 N11 4.74e-10
R11 N10 N11 1.08e-02
C12 N11 N12 7.29e-05
L12 N11 N12 1.35e-10
R12 N11 N12 4.95e-03
C13 N12 N13 5.25e-05
L13 N12 N13 8.77e-11
R13 N12 N13 4.13e-03
C14 N13 Port2 2.33e-12
L14 N13 Port2 2.88e-10
R14 N13 Port2 4.47e+01
.ENDS GXT32ER70J476KE13
