*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N4B02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N4B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.72e-10
R2 1 port2 1.55e-2
R3 port1 port2 1.68e+3
L4 port1 2 1.41e-8
R4 2 port2 62.4
L5 port1 3 7.15e-9
R5 3 port2 4.79
L6 port1 4 4.08e-9
R6 4 port2 7.93e-2
.ENDS LQP02HQ0N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N4C02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N4C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.72e-10
R2 1 port2 1.55e-2
R3 port1 port2 1.68e+3
L4 port1 2 1.41e-8
R4 2 port2 62.4
L5 port1 3 7.15e-9
R5 3 port2 4.79
L6 port1 4 4.08e-9
R6 4 port2 7.93e-2
.ENDS LQP02HQ0N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N4W02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N4W02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.72e-10
R2 1 port2 1.55e-2
R3 port1 port2 1.68e+3
L4 port1 2 1.41e-8
R4 2 port2 62.4
L5 port1 3 7.15e-9
R5 3 port2 4.79
L6 port1 4 4.08e-9
R6 4 port2 7.93e-2
.ENDS LQP02HQ0N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N5B02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N5B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.75e-10
R2 1 port2 1.83e-2
R3 port1 port2 2.65e+3
L4 port1 2 1.40e-8
R4 2 port2 59.6
L5 port1 3 1.68e-8
R5 3 port2 12.9
L6 port1 4 2.69e-8
R6 4 port2 5.74
.ENDS LQP02HQ0N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N5C02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N5C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.75e-10
R2 1 port2 1.83e-2
R3 port1 port2 2.65e+3
L4 port1 2 1.40e-8
R4 2 port2 59.6
L5 port1 3 1.68e-8
R5 3 port2 12.9
L6 port1 4 2.69e-8
R6 4 port2 5.74
.ENDS LQP02HQ0N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N5W02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N5W02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 6.75e-10
R2 1 port2 1.83e-2
R3 port1 port2 2.65e+3
L4 port1 2 1.40e-8
R4 2 port2 59.6
L5 port1 3 1.68e-8
R5 3 port2 12.9
L6 port1 4 2.69e-8
R6 4 port2 5.74
.ENDS LQP02HQ0N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N6B02 port1 port2
C1 port1 port2 3.94e-14
L2 port1 1 8.92e-10
R2 1 port2 2.88e-2
R3 port1 port2 5.54e+3
L4 port1 2 2.08e-8
R4 2 port2 96.6
L5 port1 3 2.42e-8
R5 3 port2 24.0
L6 port1 4 1.59e-8
R6 4 port2 2.95
.ENDS LQP02HQ0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N6C02 port1 port2
C1 port1 port2 3.94e-14
L2 port1 1 8.92e-10
R2 1 port2 2.88e-2
R3 port1 port2 5.54e+3
L4 port1 2 2.08e-8
R4 2 port2 96.6
L5 port1 3 2.42e-8
R5 3 port2 24.0
L6 port1 4 1.59e-8
R6 4 port2 2.95
.ENDS LQP02HQ0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N6W02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N6W02 port1 port2
C1 port1 port2 3.94e-14
L2 port1 1 8.92e-10
R2 1 port2 2.88e-2
R3 port1 port2 5.54e+3
L4 port1 2 2.08e-8
R4 2 port2 96.6
L5 port1 3 2.42e-8
R5 3 port2 24.0
L6 port1 4 1.59e-8
R6 4 port2 2.95
.ENDS LQP02HQ0N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N7B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 9.34e-10
R2 1 port2 2.96e-2
R3 port1 port2 5.41e+3
L4 port1 2 2.62e-8
R4 2 port2 172
L5 port1 3 1.88e-8
R5 3 port2 24.6
L6 port1 4 1.18e-8
R6 4 port2 5.24
.ENDS LQP02HQ0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N7C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 9.34e-10
R2 1 port2 2.96e-2
R3 port1 port2 5.41e+3
L4 port1 2 2.62e-8
R4 2 port2 172
L5 port1 3 1.88e-8
R5 3 port2 24.6
L6 port1 4 1.18e-8
R6 4 port2 5.24
.ENDS LQP02HQ0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N7W02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N7W02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 9.34e-10
R2 1 port2 2.96e-2
R3 port1 port2 5.41e+3
L4 port1 2 2.62e-8
R4 2 port2 172
L5 port1 3 1.88e-8
R5 3 port2 24.6
L6 port1 4 1.18e-8
R6 4 port2 5.24
.ENDS LQP02HQ0N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N8B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 1.12e-9
R2 1 port2 3.55e-2
R3 port1 port2 3.93e+3
L4 port1 2 2.50e-8
R4 2 port2 122
L5 port1 3 1.49e-8
R5 3 port2 12.0
L6 port1 4 2.40e-8
R6 4 port2 5.12
.ENDS LQP02HQ0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N8C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 1.12e-9
R2 1 port2 3.55e-2
R3 port1 port2 3.93e+3
L4 port1 2 2.50e-8
R4 2 port2 122
L5 port1 3 1.49e-8
R5 3 port2 12.0
L6 port1 4 2.40e-8
R6 4 port2 5.12
.ENDS LQP02HQ0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N8W02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N8W02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 1.12e-9
R2 1 port2 3.55e-2
R3 port1 port2 3.93e+3
L4 port1 2 2.50e-8
R4 2 port2 122
L5 port1 3 1.49e-8
R5 3 port2 12.0
L6 port1 4 2.40e-8
R6 4 port2 5.12
.ENDS LQP02HQ0N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N9B02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.20e-9
R2 1 port2 4.47e-2
R3 port1 port2 3.84e+3
L4 port1 2 2.23e-8
R4 2 port2 113
L5 port1 3 1.19e-8
R5 3 port2 9.56
L6 port1 4 9.57e-8
R6 4 port2 1.58
.ENDS LQP02HQ0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N9C02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.20e-9
R2 1 port2 4.47e-2
R3 port1 port2 3.84e+3
L4 port1 2 2.23e-8
R4 2 port2 113
L5 port1 3 1.19e-8
R5 3 port2 9.56
L6 port1 4 9.57e-8
R6 4 port2 1.58
.ENDS LQP02HQ0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ0N9W02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ0N9W02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.20e-9
R2 1 port2 4.47e-2
R3 port1 port2 3.84e+3
L4 port1 2 2.23e-8
R4 2 port2 113
L5 port1 3 1.19e-8
R5 3 port2 9.56
L6 port1 4 9.57e-8
R6 4 port2 1.58
.ENDS LQP02HQ0N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ10NH02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 1.64e-8
R2 1 port2 8.13e-1
R3 port1 port2 2.11e+4
L4 port1 2 2.39e-7
R4 2 port2 944
L5 port1 3 1.49e-7
R5 3 port2 100
L6 port1 4 3.99e-8
R6 4 port2 1.55
.ENDS LQP02HQ10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ10NJ02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 1.64e-8
R2 1 port2 8.13e-1
R3 port1 port2 2.11e+4
L4 port1 2 2.39e-7
R4 2 port2 944
L5 port1 3 1.49e-7
R5 3 port2 100
L6 port1 4 3.99e-8
R6 4 port2 1.55
.ENDS LQP02HQ10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ11NH02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.32e-8
R2 1 port2 4.79e-1
R3 port1 port2 3.05e+4
L4 port1 2 2.34e-7
R4 2 port2 1.04e+3
L5 port1 3 1.19e-7
R5 3 port2 70.9
L6 port1 4 6.33e-6
R6 4 port2 932
.ENDS LQP02HQ11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ11NJ02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.32e-8
R2 1 port2 4.79e-1
R3 port1 port2 3.05e+4
L4 port1 2 2.34e-7
R4 2 port2 1.04e+3
L5 port1 3 1.19e-7
R5 3 port2 70.9
L6 port1 4 6.33e-6
R6 4 port2 932
.ENDS LQP02HQ11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ12NH02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 1.48e-8
R2 1 port2 7.25e-1
R3 port1 port2 4.72e+4
L4 port1 2 3.62e-7
R4 2 port2 2.26e+3
L5 port1 3 1.80e-7
R5 3 port2 170
L6 port1 4 2.35e-7
R6 4 port2 18.6
.ENDS LQP02HQ12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ12NJ02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 1.48e-8
R2 1 port2 7.25e-1
R3 port1 port2 4.72e+4
L4 port1 2 3.62e-7
R4 2 port2 2.26e+3
L5 port1 3 1.80e-7
R5 3 port2 170
L6 port1 4 2.35e-7
R6 4 port2 18.6
.ENDS LQP02HQ12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ13NH02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 1.59e-8
R2 1 port2 7.25e-1
R3 port1 port2 3.34e+4
L4 port1 2 5.35e-7
R4 2 port2 3.35e+3
L5 port1 3 2.11e-7
R5 3 port2 276
L6 port1 4 2.35e-7
R6 4 port2 32.3
.ENDS LQP02HQ13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ13NJ02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 1.59e-8
R2 1 port2 7.25e-1
R3 port1 port2 3.34e+4
L4 port1 2 5.35e-7
R4 2 port2 3.35e+3
L5 port1 3 2.11e-7
R5 3 port2 276
L6 port1 4 2.35e-7
R6 4 port2 32.3
.ENDS LQP02HQ13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ15NH02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.77e-8
R2 1 port2 8.52e-1
R3 port1 port2 3.34e+4
L4 port1 2 3.22e-7
R4 2 port2 1.22e+3
L5 port1 3 2.31e-7
R5 3 port2 155
L6 port1 4 1.78e-6
R6 4 port2 22.9
L7 port1 5 1.73e-8
C7 5 6 4.09e-15
R7 6 port2 64.4
.ENDS LQP02HQ15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ15NJ02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.77e-8
R2 1 port2 8.52e-1
R3 port1 port2 3.34e+4
L4 port1 2 3.22e-7
R4 2 port2 1.22e+3
L5 port1 3 2.31e-7
R5 3 port2 155
L6 port1 4 1.78e-6
R6 4 port2 22.9
L7 port1 5 1.73e-8
C7 5 6 4.09e-15
R7 6 port2 64.4
.ENDS LQP02HQ15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ16NH02 port1 port2
C1 port1 port2 4.97e-14
L2 port1 1 1.82e-8
R2 1 port2 8.92e-1
R3 port1 port2 6.98e+4
L4 port1 2 4.25e-7
R4 2 port2 2.60e+3
L5 port1 3 2.60e-7
R5 3 port2 258
L6 port1 4 2.46e-6
R6 4 port2 889
L7 port1 5 6.00e-9
C7 5 6 1.07e-14
R7 6 port2 48.1
.ENDS LQP02HQ16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ16NJ02 port1 port2
C1 port1 port2 4.97e-14
L2 port1 1 1.82e-8
R2 1 port2 8.92e-1
R3 port1 port2 6.98e+4
L4 port1 2 4.25e-7
R4 2 port2 2.60e+3
L5 port1 3 2.60e-7
R5 3 port2 258
L6 port1 4 2.46e-6
R6 4 port2 889
L7 port1 5 6.00e-9
C7 5 6 1.07e-14
R7 6 port2 48.1
.ENDS LQP02HQ16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ18NH02 port1 port2
C1 port1 port2 4.74e-14
L2 port1 1 2.29e-8
R2 1 port2 1.74
R3 port1 port2 6.22e+4
L4 port1 2 6.14e-7
R4 2 port2 4.03e+3
L5 port1 3 4.51e-7
R5 3 port2 551
L6 port1 4 2.00e-7
R6 4 port2 12.3
L7 port1 5 5.11e-9
C7 5 6 1.51e-14
R7 6 port2 36.5
.ENDS LQP02HQ18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ18NJ02 port1 port2
C1 port1 port2 4.74e-14
L2 port1 1 2.29e-8
R2 1 port2 1.74
R3 port1 port2 6.22e+4
L4 port1 2 6.14e-7
R4 2 port2 4.03e+3
L5 port1 3 4.51e-7
R5 3 port2 551
L6 port1 4 2.00e-7
R6 4 port2 12.3
L7 port1 5 5.11e-9
C7 5 6 1.51e-14
R7 6 port2 36.5
.ENDS LQP02HQ18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N0B02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 1.26e-9
R2 1 port2 5.25e-2
R3 port1 port2 4.02e+3
L4 port1 2 3.54e-8
R4 2 port2 193
L5 port1 3 1.42e-8
R5 3 port2 16.6
L6 port1 4 1.52e-7
R6 4 port2 1.99
.ENDS LQP02HQ1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N0C02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 1.26e-9
R2 1 port2 5.25e-2
R3 port1 port2 4.02e+3
L4 port1 2 3.54e-8
R4 2 port2 193
L5 port1 3 1.42e-8
R5 3 port2 16.6
L6 port1 4 1.52e-7
R6 4 port2 1.99
.ENDS LQP02HQ1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N0W02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N0W02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 1.26e-9
R2 1 port2 5.25e-2
R3 port1 port2 4.02e+3
L4 port1 2 3.54e-8
R4 2 port2 193
L5 port1 3 1.42e-8
R5 3 port2 16.6
L6 port1 4 1.52e-7
R6 4 port2 1.99
.ENDS LQP02HQ1N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N1B02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.38e-9
R2 1 port2 5.02e-2
R3 port1 port2 4.11e+3
L4 port1 2 3.22e-8
R4 2 port2 143
L5 port1 3 1.75e-8
R5 3 port2 19.1
L6 port1 4 5.77e-8
R6 4 port2 2.88
.ENDS LQP02HQ1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N1C02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.38e-9
R2 1 port2 5.02e-2
R3 port1 port2 4.11e+3
L4 port1 2 3.22e-8
R4 2 port2 143
L5 port1 3 1.75e-8
R5 3 port2 19.1
L6 port1 4 5.77e-8
R6 4 port2 2.88
.ENDS LQP02HQ1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N1W02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N1W02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.38e-9
R2 1 port2 5.02e-2
R3 port1 port2 4.11e+3
L4 port1 2 3.22e-8
R4 2 port2 143
L5 port1 3 1.75e-8
R5 3 port2 19.1
L6 port1 4 5.77e-8
R6 4 port2 2.88
.ENDS LQP02HQ1N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N2B02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.51e-9
R2 1 port2 6.31e-2
R3 port1 port2 6.51e+3
L4 port1 2 3.38e-8
R4 2 port2 160
L5 port1 3 2.48e-8
R5 3 port2 25.7
L6 port1 4 8.53e-6
R6 4 port2 107
.ENDS LQP02HQ1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N2C02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.51e-9
R2 1 port2 6.31e-2
R3 port1 port2 6.51e+3
L4 port1 2 3.38e-8
R4 2 port2 160
L5 port1 3 2.48e-8
R5 3 port2 25.7
L6 port1 4 8.53e-6
R6 4 port2 107
.ENDS LQP02HQ1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N2W02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N2W02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.51e-9
R2 1 port2 6.31e-2
R3 port1 port2 6.51e+3
L4 port1 2 3.38e-8
R4 2 port2 160
L5 port1 3 2.48e-8
R5 3 port2 25.7
L6 port1 4 8.53e-6
R6 4 port2 107
.ENDS LQP02HQ1N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N3B02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 1.95e-9
R2 1 port2 8.13e-2
R3 port1 port2 8.01e+3
L4 port1 2 4.45e-8
R4 2 port2 254
L5 port1 3 1.97e-8
R5 3 port2 22.9
L6 port1 4 1.21e-8
R6 4 port2 4.07e-1
.ENDS LQP02HQ1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N3C02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 1.95e-9
R2 1 port2 8.13e-2
R3 port1 port2 8.01e+3
L4 port1 2 4.45e-8
R4 2 port2 254
L5 port1 3 1.97e-8
R5 3 port2 22.9
L6 port1 4 1.21e-8
R6 4 port2 4.07e-1
.ENDS LQP02HQ1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N3W02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N3W02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 1.95e-9
R2 1 port2 8.13e-2
R3 port1 port2 8.01e+3
L4 port1 2 4.45e-8
R4 2 port2 254
L5 port1 3 1.97e-8
R5 3 port2 22.9
L6 port1 4 1.21e-8
R6 4 port2 4.07e-1
.ENDS LQP02HQ1N3W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N4B02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 1.95e-9
R2 1 port2 8.51e-2
R3 port1 port2 7.00e+3
L4 port1 2 6.14e-8
R4 2 port2 335
L5 port1 3 2.21e-8
R5 3 port2 27.6
L6 port1 4 6.62e-8
R6 4 port2 5.61e-1
.ENDS LQP02HQ1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N4C02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 1.95e-9
R2 1 port2 8.51e-2
R3 port1 port2 7.00e+3
L4 port1 2 6.14e-8
R4 2 port2 335
L5 port1 3 2.21e-8
R5 3 port2 27.6
L6 port1 4 6.62e-8
R6 4 port2 5.61e-1
.ENDS LQP02HQ1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N4W02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N4W02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 1.95e-9
R2 1 port2 8.51e-2
R3 port1 port2 7.00e+3
L4 port1 2 6.14e-8
R4 2 port2 335
L5 port1 3 2.21e-8
R5 3 port2 27.6
L6 port1 4 6.62e-8
R6 4 port2 5.61e-1
.ENDS LQP02HQ1N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N5B02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.04e-9
R2 1 port2 5.02e-2
R3 port1 port2 5.17e+3
L4 port1 2 2.62e-8
R4 2 port2 96.6
L5 port1 3 1.13e-8
R5 3 port2 4.18
L6 port1 4 7.78e-8
R6 4 port2 26.3
.ENDS LQP02HQ1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N5C02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.04e-9
R2 1 port2 5.02e-2
R3 port1 port2 5.17e+3
L4 port1 2 2.62e-8
R4 2 port2 96.6
L5 port1 3 1.13e-8
R5 3 port2 4.18
L6 port1 4 7.78e-8
R6 4 port2 26.3
.ENDS LQP02HQ1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N5W02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N5W02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.04e-9
R2 1 port2 5.02e-2
R3 port1 port2 5.17e+3
L4 port1 2 2.62e-8
R4 2 port2 96.6
L5 port1 3 1.13e-8
R5 3 port2 4.18
L6 port1 4 7.78e-8
R6 4 port2 26.3
.ENDS LQP02HQ1N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N6B02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.14e-9
R2 1 port2 6.03e-2
R3 port1 port2 5.80e+3
L4 port1 2 2.74e-8
R4 2 port2 101
L5 port1 3 1.36e-8
R5 3 port2 5.38
L6 port1 4 7.78e-8
R6 4 port2 26.3
.ENDS LQP02HQ1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N6C02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.14e-9
R2 1 port2 6.03e-2
R3 port1 port2 5.80e+3
L4 port1 2 2.74e-8
R4 2 port2 101
L5 port1 3 1.36e-8
R5 3 port2 5.38
L6 port1 4 7.78e-8
R6 4 port2 26.3
.ENDS LQP02HQ1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N7B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.24e-9
R2 1 port2 8.32e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 343
L5 port1 3 1.88e-8
R5 3 port2 20.5
L6 port1 4 6.47e-8
R6 4 port2 4.89e-1
.ENDS LQP02HQ1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N7C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.24e-9
R2 1 port2 8.32e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 343
L5 port1 3 1.88e-8
R5 3 port2 20.5
L6 port1 4 6.47e-8
R6 4 port2 4.89e-1
.ENDS LQP02HQ1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N8B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.35e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 351
L5 port1 3 2.02e-8
R5 3 port2 20.0
L6 port1 4 6.33e-8
R6 4 port2 4.07e-1
.ENDS LQP02HQ1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N8C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.35e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 351
L5 port1 3 2.02e-8
R5 3 port2 20.0
L6 port1 4 6.33e-8
R6 4 port2 4.07e-1
.ENDS LQP02HQ1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N9B02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 2.51e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 320
L5 port1 3 2.02e-8
R5 3 port2 20.0
L6 port1 4 6.62e-8
R6 4 port2 3.88e-1
.ENDS LQP02HQ1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ1N9C02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 2.51e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.11e+4
L4 port1 2 6.43e-8
R4 2 port2 320
L5 port1 3 2.02e-8
R5 3 port2 20.0
L6 port1 4 6.62e-8
R6 4 port2 3.88e-1
.ENDS LQP02HQ1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ20NH02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 2.69e-8
R2 1 port2 1.70
R3 port1 port2 3.84e+4
L4 port1 2 5.47e-7
R4 2 port2 2.85e+3
L5 port1 3 4.11e-7
R5 3 port2 514
L6 port1 4 2.09e-7
R6 4 port2 12.6
L7 port1 5 3.45e-8
C7 5 6 3.09e-15
R7 6 port2 79.9
.ENDS LQP02HQ20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ20NJ02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 2.69e-8
R2 1 port2 1.70
R3 port1 port2 3.84e+4
L4 port1 2 5.47e-7
R4 2 port2 2.85e+3
L5 port1 3 4.11e-7
R5 3 port2 514
L6 port1 4 2.09e-7
R6 4 port2 12.6
L7 port1 5 3.45e-8
C7 5 6 3.09e-15
R7 6 port2 79.9
.ENDS LQP02HQ20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ22NH02 port1 port2
C1 port1 port2 5.84e-14
L2 port1 1 2.82e-8
R2 1 port2 1.78
R3 port1 port2 3.84e+4
L4 port1 2 5.47e-7
R4 2 port2 2.85e+3
L5 port1 3 5.81e-7
R5 3 port2 726
L6 port1 4 2.09e-7
R6 4 port2 13.2
L7 port1 5 1.25e-8
C7 5 6 8.51e-15
R7 6 port2 149
.ENDS LQP02HQ22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ22NJ02 port1 port2
C1 port1 port2 5.84e-14
L2 port1 1 2.82e-8
R2 1 port2 1.78
R3 port1 port2 3.84e+4
L4 port1 2 5.47e-7
R4 2 port2 2.85e+3
L5 port1 3 5.81e-7
R5 3 port2 726
L6 port1 4 2.09e-7
R6 4 port2 13.2
L7 port1 5 1.25e-8
C7 5 6 8.51e-15
R7 6 port2 149
.ENDS LQP02HQ22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ24NH02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ24NH02 port1 port2
C1 port1 port2 2.55e-14
L2 port1 1 2.75e-8
R2 1 port2 1.45
R3 port1 port2 5.18e+4
L4 port1 2 4.25e-7
R4 2 port2 1.46e+3
L5 port1 3 4.51e-7
R5 3 port2 356
L6 port1 4 1.42e-6
R6 4 port2 53.6
L7 port1 5 2.53e-9
C7 5 6 4.42e-14
R7 6 port2 83.7
.ENDS LQP02HQ24NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ24NJ02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ24NJ02 port1 port2
C1 port1 port2 2.55e-14
L2 port1 1 2.75e-8
R2 1 port2 1.45
R3 port1 port2 5.18e+4
L4 port1 2 4.25e-7
R4 2 port2 1.46e+3
L5 port1 3 4.51e-7
R5 3 port2 356
L6 port1 4 1.42e-6
R6 4 port2 53.6
L7 port1 5 2.53e-9
C7 5 6 4.42e-14
R7 6 port2 83.7
.ENDS LQP02HQ24NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ27NH02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.99e-8
R2 1 port2 1.82
R3 port1 port2 3.19e+4
L4 port1 2 6.89e-7
R4 2 port2 3.67e+3
L5 port1 3 5.81e-7
R5 3 port2 526
L6 port1 4 1.48e-4
R6 4 port2 9.78e+3
L7 port1 5 4.06e-8
C7 5 6 3.47e-15
R7 6 port2 98.3
.ENDS LQP02HQ27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ27NJ02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.99e-8
R2 1 port2 1.82
R3 port1 port2 3.19e+4
L4 port1 2 6.89e-7
R4 2 port2 3.67e+3
L5 port1 3 5.81e-7
R5 3 port2 526
L6 port1 4 1.48e-4
R6 4 port2 9.78e+3
L7 port1 5 4.06e-8
C7 5 6 3.47e-15
R7 6 port2 98.3
.ENDS LQP02HQ27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N0B02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 2.57e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.27e+4
L4 port1 2 6.43e-8
R4 2 port2 313
L5 port1 3 2.26e-8
R5 3 port2 21.9
L6 port1 4 7.60e-8
R6 4 port2 7.93e-1
.ENDS LQP02HQ2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N0C02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 2.57e-9
R2 1 port2 8.72e-2
R3 port1 port2 1.27e+4
L4 port1 2 6.43e-8
R4 2 port2 313
L5 port1 3 2.26e-8
R5 3 port2 21.9
L6 port1 4 7.60e-8
R6 4 port2 7.93e-1
.ENDS LQP02HQ2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N1B02 port1 port2
C1 port1 port2 7.01e-14
L2 port1 1 2.82e-9
R2 1 port2 9.13e-2
R3 port1 port2 1.56e+4
L4 port1 2 6.00e-8
R4 2 port2 266
L5 port1 3 2.42e-8
R5 3 port2 17.4
L6 port1 4 7.96e-7
R6 4 port2 7.07
.ENDS LQP02HQ2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N1C02 port1 port2
C1 port1 port2 7.01e-14
L2 port1 1 2.82e-9
R2 1 port2 9.13e-2
R3 port1 port2 1.56e+4
L4 port1 2 6.00e-8
R4 2 port2 266
L5 port1 3 2.42e-8
R5 3 port2 17.4
L6 port1 4 7.96e-7
R6 4 port2 7.07
.ENDS LQP02HQ2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N2B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.82e-9
R2 1 port2 1.23e-1
R3 port1 port2 1.79e+4
L4 port1 2 6.00e-8
R4 2 port2 272
L5 port1 3 3.67e-8
R5 3 port2 31.7
L6 port1 4 1.42e-7
R6 4 port2 3.01
.ENDS LQP02HQ2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N2C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.82e-9
R2 1 port2 1.23e-1
R3 port1 port2 1.79e+4
L4 port1 2 6.00e-8
R4 2 port2 272
L5 port1 3 3.67e-8
R5 3 port2 31.7
L6 port1 4 1.42e-7
R6 4 port2 3.01
.ENDS LQP02HQ2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N3B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.95e-9
R2 1 port2 6.77e-2
R3 port1 port2 1.79e+4
L4 port1 2 7.73e-8
R4 2 port2 422
L5 port1 3 2.42e-8
R5 3 port2 12.9
L6 port1 4 2.64e-6
R6 4 port2 25.7
.ENDS LQP02HQ2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N3C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 2.95e-9
R2 1 port2 6.77e-2
R3 port1 port2 1.79e+4
L4 port1 2 7.73e-8
R4 2 port2 422
L5 port1 3 2.42e-8
R5 3 port2 12.9
L6 port1 4 2.64e-6
R6 4 port2 25.7
.ENDS LQP02HQ2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N4B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.09e-9
R2 1 port2 9.56e-2
R3 port1 port2 1.71e+4
L4 port1 2 8.10e-8
R4 2 port2 442
L5 port1 3 2.37e-8
R5 3 port2 13.8
L6 port1 4 2.58e-6
R6 4 port2 25.1
.ENDS LQP02HQ2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N4C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.09e-9
R2 1 port2 9.56e-2
R3 port1 port2 1.71e+4
L4 port1 2 8.10e-8
R4 2 port2 442
L5 port1 3 2.37e-8
R5 3 port2 13.8
L6 port1 4 2.58e-6
R6 4 port2 25.1
.ENDS LQP02HQ2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N5B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 3.24e-9
R2 1 port2 1.48e-1
R3 port1 port2 1.79e+4
L4 port1 2 6.29e-8
R4 2 port2 272
L5 port1 3 3.19e-8
R5 3 port2 23.5
L6 port1 4 2.24e-7
R6 4 port2 3.23
.ENDS LQP02HQ2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N5C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 3.24e-9
R2 1 port2 1.48e-1
R3 port1 port2 1.79e+4
L4 port1 2 6.29e-8
R4 2 port2 272
L5 port1 3 3.19e-8
R5 3 port2 23.5
L6 port1 4 2.24e-7
R6 4 port2 3.23
.ENDS LQP02HQ2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N6B02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.39e-9
R2 1 port2 1.48e-1
R3 port1 port2 1.60e+4
L4 port1 2 6.74e-8
R4 2 port2 292
L5 port1 3 3.19e-8
R5 3 port2 23.5
L6 port1 4 1.91e-7
R6 4 port2 2.75
.ENDS LQP02HQ2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N6C02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.39e-9
R2 1 port2 1.48e-1
R3 port1 port2 1.60e+4
L4 port1 2 6.74e-8
R4 2 port2 292
L5 port1 3 3.19e-8
R5 3 port2 23.5
L6 port1 4 1.91e-7
R6 4 port2 2.75
.ENDS LQP02HQ2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N7B02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.47e-9
R2 1 port2 1.48e-1
R3 port1 port2 2.16e+4
L4 port1 2 7.05e-8
R4 2 port2 306
L5 port1 3 3.50e-8
R5 3 port2 25.8
L6 port1 4 3.10e-7
R6 4 port2 86.9
.ENDS LQP02HQ2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N7C02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.47e-9
R2 1 port2 1.48e-1
R3 port1 port2 2.16e+4
L4 port1 2 7.05e-8
R4 2 port2 306
L5 port1 3 3.50e-8
R5 3 port2 25.8
L6 port1 4 3.10e-7
R6 4 port2 86.9
.ENDS LQP02HQ2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N8B02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.63e-9
R2 1 port2 1.62e-1
R3 port1 port2 2.06e+4
L4 port1 2 7.22e-8
R4 2 port2 313
L5 port1 3 4.72e-8
R5 3 port2 34.7
L6 port1 4 9.57e-8
R6 4 port2 26.9
.ENDS LQP02HQ2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N8C02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 3.63e-9
R2 1 port2 1.62e-1
R3 port1 port2 2.06e+4
L4 port1 2 7.22e-8
R4 2 port2 313
L5 port1 3 4.72e-8
R5 3 port2 34.7
L6 port1 4 9.57e-8
R6 4 port2 26.9
.ENDS LQP02HQ2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N9B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.72e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.11e+4
L4 port1 2 7.05e-8
R4 2 port2 279
L5 port1 3 4.62e-8
R5 3 port2 36.4
L6 port1 4 1.12e-7
R6 4 port2 33.1
.ENDS LQP02HQ2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ2N9C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.72e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.11e+4
L4 port1 2 7.05e-8
R4 2 port2 279
L5 port1 3 4.62e-8
R5 3 port2 36.4
L6 port1 4 1.12e-7
R6 4 port2 33.1
.ENDS LQP02HQ2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ30NH02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ30NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 3.54e-8
R2 1 port2 1.95
R3 port1 port2 3.42e+4
L4 port1 2 4.88e-7
R4 2 port2 1.76e+3
L5 port1 3 4.51e-7
R5 3 port2 438
L6 port1 4 1.45e-6
R6 4 port2 84.9
L7 port1 5 6.50e-9
C7 5 6 2.16e-14
R7 6 port2 167
L8 port1 7 3.45e-8
C8 7 8 3.10e-15
R8 8 port2 153
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ30NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ30NJ02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ30NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 3.54e-8
R2 1 port2 1.95
R3 port1 port2 3.42e+4
L4 port1 2 4.88e-7
R4 2 port2 1.76e+3
L5 port1 3 4.51e-7
R5 3 port2 438
L6 port1 4 1.45e-6
R6 4 port2 84.9
L7 port1 5 6.50e-9
C7 5 6 2.16e-14
R7 6 port2 167
L8 port1 7 3.45e-8
C8 7 8 3.10e-15
R8 8 port2 153
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ30NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ33NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 3.79e-8
R2 1 port2 2.35
R3 port1 port2 3.42e+4
L4 port1 2 7.56e-7
R4 2 port2 2.72e+3
L5 port1 3 6.37e-7
R5 3 port2 815
L6 port1 4 1.82e-6
R6 4 port2 107
L7 port1 5 6.97e-9
C7 5 6 2.21e-14
R7 6 port2 124
L8 port1 7 3.45e-8
C8 7 8 3.10e-15
R8 8 port2 153
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ33NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 3.79e-8
R2 1 port2 2.35
R3 port1 port2 3.42e+4
L4 port1 2 7.56e-7
R4 2 port2 2.72e+3
L5 port1 3 6.37e-7
R5 3 port2 815
L6 port1 4 1.82e-6
R6 4 port2 107
L7 port1 5 6.97e-9
C7 5 6 2.21e-14
R7 6 port2 124
L8 port1 7 3.45e-8
C8 7 8 3.10e-15
R8 8 port2 153
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ36NH02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ36NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 4.25e-8
R2 1 port2 2.51
R3 port1 port2 1.49e+6
L4 port1 2 6.00e-7
R4 2 port2 2.60e+3
L5 port1 3 4.95e-7
R5 3 port2 604
L6 port1 4 1.74e-6
R6 4 port2 93.1
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ36NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ36NJ02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ36NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 4.25e-8
R2 1 port2 2.51
R3 port1 port2 1.49e+6
L4 port1 2 6.00e-7
R4 2 port2 2.60e+3
L5 port1 3 4.95e-7
R5 3 port2 604
L6 port1 4 1.74e-6
R6 4 port2 93.1
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ36NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ39NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 4.35e-8
R2 1 port2 2.76
R3 port1 port2 3.42e+4
L4 port1 2 7.39e-7
R4 2 port2 2.32e+3
L5 port1 3 8.59e-7
R5 3 port2 1.15e+3
L6 port1 4 2.52e-5
R6 4 port2 169
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ39NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 4.35e-8
R2 1 port2 2.76
R3 port1 port2 3.42e+4
L4 port1 2 7.39e-7
R4 2 port2 2.32e+3
L5 port1 3 8.59e-7
R5 3 port2 1.15e+3
L6 port1 4 2.52e-5
R6 4 port2 169
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N0B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.80e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.53e+4
L4 port1 2 7.05e-8
R4 2 port2 279
L5 port1 3 5.18e-8
R5 3 port2 40.8
L6 port1 4 1.35e-7
R6 4 port2 39.7
.ENDS LQP02HQ3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N0C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.80e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.53e+4
L4 port1 2 7.05e-8
R4 2 port2 279
L5 port1 3 5.18e-8
R5 3 port2 40.8
L6 port1 4 1.35e-7
R6 4 port2 39.7
.ENDS LQP02HQ3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N1B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.98e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.42e+4
L4 port1 2 7.91e-8
R4 2 port2 313
L5 port1 3 5.42e-8
R5 3 port2 42.7
L6 port1 4 1.15e-7
R6 4 port2 33.8
.ENDS LQP02HQ3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N1C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.98e-9
R2 1 port2 1.55e-1
R3 port1 port2 2.42e+4
L4 port1 2 7.91e-8
R4 2 port2 313
L5 port1 3 5.42e-8
R5 3 port2 42.7
L6 port1 4 1.15e-7
R6 4 port2 33.8
.ENDS LQP02HQ3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N2B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 4.17e-9
R2 1 port2 1.74e-1
R3 port1 port2 2.26e+4
L4 port1 2 8.29e-8
R4 2 port2 327
L5 port1 3 5.18e-8
R5 3 port2 40.8
L6 port1 4 1.07e-7
R6 4 port2 10.5
.ENDS LQP02HQ3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N2C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 4.17e-9
R2 1 port2 1.74e-1
R3 port1 port2 2.26e+4
L4 port1 2 8.29e-8
R4 2 port2 327
L5 port1 3 5.18e-8
R5 3 port2 40.8
L6 port1 4 1.07e-7
R6 4 port2 10.5
.ENDS LQP02HQ3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N3B02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 4.37e-9
R2 1 port2 2.14e-1
R3 port1 port2 2.71e+4
L4 port1 2 8.88e-8
R4 2 port2 367
L5 port1 3 5.30e-8
R5 3 port2 41.8
L6 port1 4 8.15e-8
R6 4 port2 7.93
.ENDS LQP02HQ3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N3C02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 4.37e-9
R2 1 port2 2.14e-1
R3 port1 port2 2.71e+4
L4 port1 2 8.88e-8
R4 2 port2 367
L5 port1 3 5.30e-8
R5 3 port2 41.8
L6 port1 4 8.15e-8
R6 4 port2 7.93
.ENDS LQP02HQ3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N4B02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 4.47e-9
R2 1 port2 2.19e-1
R3 port1 port2 2.48e+4
L4 port1 2 9.09e-8
R4 2 port2 376
L5 port1 3 5.68e-8
R5 3 port2 46.9
L6 port1 4 7.10e-8
R6 4 port2 1.86
.ENDS LQP02HQ3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N4C02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 4.47e-9
R2 1 port2 2.19e-1
R3 port1 port2 2.48e+4
L4 port1 2 9.09e-8
R4 2 port2 376
L5 port1 3 5.68e-8
R5 3 port2 46.9
L6 port1 4 7.10e-8
R6 4 port2 1.86
.ENDS LQP02HQ3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N5B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 4.68e-9
R2 1 port2 2.04e-1
R3 port1 port2 2.31e+4
L4 port1 2 9.30e-8
R4 2 port2 403
L5 port1 3 4.83e-8
R5 3 port2 40.8
L6 port1 4 5.90e-8
R6 4 port2 3.23
.ENDS LQP02HQ3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N5C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 4.68e-9
R2 1 port2 2.04e-1
R3 port1 port2 2.31e+4
L4 port1 2 9.30e-8
R4 2 port2 403
L5 port1 3 4.83e-8
R5 3 port2 40.8
L6 port1 4 5.90e-8
R6 4 port2 3.23
.ENDS LQP02HQ3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N6B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 4.79e-9
R2 1 port2 2.24e-1
R3 port1 port2 2.36e+4
L4 port1 2 9.96e-8
R4 2 port2 452
L5 port1 3 4.83e-8
R5 3 port2 40.8
L6 port1 4 5.77e-8
R6 4 port2 3.16
.ENDS LQP02HQ3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N6C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 4.79e-9
R2 1 port2 2.24e-1
R3 port1 port2 2.36e+4
L4 port1 2 9.96e-8
R4 2 port2 452
L5 port1 3 4.83e-8
R5 3 port2 40.8
L6 port1 4 5.77e-8
R6 4 port2 3.16
.ENDS LQP02HQ3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N7B02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 5.02e-9
R2 1 port2 2.24e-1
R3 port1 port2 2.36e+4
L4 port1 2 9.08e-8
R4 2 port2 412
L5 port1 3 5.81e-8
R5 3 port2 40.8
L6 port1 4 5.26e-8
R6 4 port2 2.75
.ENDS LQP02HQ3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N7C02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 5.02e-9
R2 1 port2 2.24e-1
R3 port1 port2 2.36e+4
L4 port1 2 9.08e-8
R4 2 port2 412
L5 port1 3 5.81e-8
R5 3 port2 40.8
L6 port1 4 5.26e-8
R6 4 port2 2.75
.ENDS LQP02HQ3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N8B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 5.50e-9
R2 1 port2 2.51e-1
R3 port1 port2 1.79e+4
L4 port1 2 8.48e-8
R4 2 port2 327
L5 port1 3 5.30e-8
R5 3 port2 24.0
L6 port1 4 3.56e-8
R6 4 port2 8.30e-1
.ENDS LQP02HQ3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N8C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 5.50e-9
R2 1 port2 2.51e-1
R3 port1 port2 1.79e+4
L4 port1 2 8.48e-8
R4 2 port2 327
L5 port1 3 5.30e-8
R5 3 port2 24.0
L6 port1 4 3.56e-8
R6 4 port2 8.30e-1
.ENDS LQP02HQ3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N9B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 5.76e-9
R2 1 port2 2.24e-1
R3 port1 port2 1.79e+4
L4 port1 2 8.88e-8
R4 2 port2 335
L5 port1 3 4.72e-8
R5 3 port2 20.5
L6 port1 4 3.99e-8
R6 4 port2 1.26
.ENDS LQP02HQ3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ3N9C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 5.76e-9
R2 1 port2 2.24e-1
R3 port1 port2 1.79e+4
L4 port1 2 8.88e-8
R4 2 port2 335
L5 port1 3 4.72e-8
R5 3 port2 20.5
L6 port1 4 3.99e-8
R6 4 port2 1.26
.ENDS LQP02HQ3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ43NH02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ43NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 5.11e-8
R2 1 port2 2.46
R3 port1 port2 2.66e+4
L4 port1 2 1.02e-6
R4 2 port2 4.42e+3
L5 port1 3 3.50e-7
R5 3 port2 364
L6 port1 4 2.05e-5
R6 4 port2 169
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ43NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ43NJ02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ43NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 5.11e-8
R2 1 port2 2.46
R3 port1 port2 2.66e+4
L4 port1 2 1.02e-6
R4 2 port2 4.42e+3
L5 port1 3 3.50e-7
R5 3 port2 364
L6 port1 4 2.05e-5
R6 4 port2 169
L7 port1 5 7.82e-9
C7 5 6 2.48e-14
R7 6 port2 201
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ43NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ47NH02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ47NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 5.48e-8
R2 1 port2 2.95
R3 port1 port2 5.06e+4
L4 port1 2 6.89e-7
R4 2 port2 2.16e+3
L5 port1 3 5.95e-7
R5 3 port2 577
L6 port1 4 9.57e-6
R6 4 port2 61.5
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ47NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ47NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 5.48e-8
R2 1 port2 2.95
R3 port1 port2 5.06e+4
L4 port1 2 6.89e-7
R4 2 port2 2.16e+3
L5 port1 3 5.95e-7
R5 3 port2 577
L6 port1 4 9.57e-6
R6 4 port2 61.5
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N0B02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 5.37e-9
R2 1 port2 2.69e-1
R3 port1 port2 3.58e+4
L4 port1 2 1.04e-7
R4 2 port2 543
L5 port1 3 6.23e-8
R5 3 port2 51.4
L6 port1 4 5.14e-8
R6 4 port2 2.75
.ENDS LQP02HQ4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N0C02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 5.37e-9
R2 1 port2 2.69e-1
R3 port1 port2 3.58e+4
L4 port1 2 1.04e-7
R4 2 port2 543
L5 port1 3 6.23e-8
R5 3 port2 51.4
L6 port1 4 5.14e-8
R6 4 port2 2.75
.ENDS LQP02HQ4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N1B02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 5.50e-9
R2 1 port2 2.46e-1
R3 port1 port2 2.21e+4
L4 port1 2 1.51e-7
R4 2 port2 785
L5 port1 3 5.95e-8
R5 3 port2 79.6
L6 port1 4 4.48e-8
R6 4 port2 2.13
.ENDS LQP02HQ4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N1C02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 5.50e-9
R2 1 port2 2.46e-1
R3 port1 port2 2.21e+4
L4 port1 2 1.51e-7
R4 2 port2 785
L5 port1 3 5.95e-8
R5 3 port2 79.6
L6 port1 4 4.48e-8
R6 4 port2 2.13
.ENDS LQP02HQ4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N2B02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 5.50e-9
R2 1 port2 2.46e-1
R3 port1 port2 2.36e+4
L4 port1 2 1.28e-7
R4 2 port2 668
L5 port1 3 4.83e-8
R5 3 port2 44.8
L6 port1 4 9.80e-8
R6 4 port2 3.88
.ENDS LQP02HQ4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N2C02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 5.50e-9
R2 1 port2 2.46e-1
R3 port1 port2 2.36e+4
L4 port1 2 1.28e-7
R4 2 port2 668
L5 port1 3 4.83e-8
R5 3 port2 44.8
L6 port1 4 9.80e-8
R6 4 port2 3.88
.ENDS LQP02HQ4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N3H02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 5.76e-9
R2 1 port2 2.51e-1
R3 port1 port2 2.65e+4
L4 port1 2 9.96e-8
R4 2 port2 484
L5 port1 3 4.51e-8
R5 3 port2 29.6
L6 port1 4 8.53e-8
R6 4 port2 4.07
.ENDS LQP02HQ4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N3J02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 5.76e-9
R2 1 port2 2.51e-1
R3 port1 port2 2.65e+4
L4 port1 2 9.96e-8
R4 2 port2 484
L5 port1 3 4.51e-8
R5 3 port2 29.6
L6 port1 4 8.53e-8
R6 4 port2 4.07
.ENDS LQP02HQ4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N7H02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 6.03e-9
R2 1 port2 2.95e-1
R3 port1 port2 2.65e+4
L4 port1 2 1.38e-7
R4 2 port2 716
L5 port1 3 5.30e-8
R5 3 port2 44.8
L6 port1 4 9.80e-8
R6 4 port2 3.88
.ENDS LQP02HQ4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ4N7J02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 6.03e-9
R2 1 port2 2.95e-1
R3 port1 port2 2.65e+4
L4 port1 2 1.38e-7
R4 2 port2 716
L5 port1 3 5.30e-8
R5 3 port2 44.8
L6 port1 4 9.80e-8
R6 4 port2 3.88
.ENDS LQP02HQ4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ51NH02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ51NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 6.15e-8
R2 1 port2 2.82
R3 port1 port2 2.42e+4
L4 port1 2 4.88e-7
R4 2 port2 989
L5 port1 3 8.21e-7
R5 3 port2 564
L6 port1 4 3.24e-6
R6 4 port2 166
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ51NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ51NJ02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ51NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 6.15e-8
R2 1 port2 2.82
R3 port1 port2 2.42e+4
L4 port1 2 4.88e-7
R4 2 port2 989
L5 port1 3 8.21e-7
R5 3 port2 564
L6 port1 4 3.24e-6
R6 4 port2 166
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ51NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ56NH02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ56NH02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 6.59e-8
R2 1 port2 3.47
R3 port1 port2 2.42e+4
L4 port1 2 5.23e-7
R4 2 port2 1.01e+3
L5 port1 3 1.80e-6
R5 3 port2 1.18e+3
L6 port1 4 2.46e-6
R6 4 port2 132
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ56NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ56NJ02 port1 port2
C1 port1 port2 4.33e-14
L2 port1 1 6.59e-8
R2 1 port2 3.47
R3 port1 port2 2.42e+4
L4 port1 2 5.23e-7
R4 2 port2 1.01e+3
L5 port1 3 1.80e-6
R5 3 port2 1.18e+3
L6 port1 4 2.46e-6
R6 4 port2 132
L7 port1 5 9.62e-9
C7 5 6 3.05e-14
R7 6 port2 145
L8 port1 7 2.93e-8
C8 7 8 3.99e-15
R8 8 port2 106
L9 port1 9 1.34e-8
C9 9 10 5.26e-15
R9 10 port2 69.8
.ENDS LQP02HQ56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ5N1H02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 6.29e-9
R2 1 port2 3.16e-1
R3 port1 port2 2.71e+4
L4 port1 2 1.86e-7
R4 2 port2 1.11e+3
L5 port1 3 1.01e-7
R5 3 port2 126
L6 port1 4 1.03e-7
R6 4 port2 36.2
.ENDS LQP02HQ5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ5N1J02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 6.29e-9
R2 1 port2 3.16e-1
R3 port1 port2 2.71e+4
L4 port1 2 1.86e-7
R4 2 port2 1.11e+3
L5 port1 3 1.01e-7
R5 3 port2 126
L6 port1 4 1.03e-7
R6 4 port2 36.2
.ENDS LQP02HQ5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ5N6H02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 6.61e-9
R2 1 port2 3.47e-1
R3 port1 port2 2.78e+4
L4 port1 2 1.69e-7
R4 2 port2 902
L5 port1 3 8.21e-8
R5 3 port2 66.2
L6 port1 4 1.78e-5
R6 4 port2 4.07e-4
.ENDS LQP02HQ5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ5N6J02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 6.61e-9
R2 1 port2 3.47e-1
R3 port1 port2 2.78e+4
L4 port1 2 1.69e-7
R4 2 port2 902
L5 port1 3 8.21e-8
R5 3 port2 66.2
L6 port1 4 1.78e-5
R6 4 port2 4.07e-4
.ENDS LQP02HQ5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ6N2H02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 7.77e-9
R2 1 port2 3.89e-1
R3 port1 port2 3.66e+4
L4 port1 2 1.58e-7
R4 2 port2 750
L5 port1 3 7.32e-8
R5 3 port2 56.4
L6 port1 4 2.14e-7
R6 4 port2 51.2
.ENDS LQP02HQ6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ6N2J02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 7.77e-9
R2 1 port2 3.89e-1
R3 port1 port2 3.66e+4
L4 port1 2 1.58e-7
R4 2 port2 750
L5 port1 3 7.32e-8
R5 3 port2 56.4
L6 port1 4 2.14e-7
R6 4 port2 51.2
.ENDS LQP02HQ6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ6N8H02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 8.52e-9
R2 1 port2 3.89e-1
R3 port1 port2 3.66e+4
L4 port1 2 1.77e-7
R4 2 port2 841
L5 port1 3 8.80e-8
R5 3 port2 67.7
L6 port1 4 2.19e-7
R6 4 port2 34.6
.ENDS LQP02HQ6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ6N8J02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 8.52e-9
R2 1 port2 3.89e-1
R3 port1 port2 3.66e+4
L4 port1 2 1.77e-7
R4 2 port2 841
L5 port1 3 8.80e-8
R5 3 port2 67.7
L6 port1 4 2.19e-7
R6 4 port2 34.6
.ENDS LQP02HQ6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ7N5H02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 9.13e-9
R2 1 port2 4.79e-1
R3 port1 port2 3.05e+4
L4 port1 2 1.65e-7
R4 2 port2 610
L5 port1 3 1.13e-7
R5 3 port2 63.2
L6 port1 4 1.10e-6
R6 4 port2 63.0
.ENDS LQP02HQ7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ7N5J02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 9.13e-9
R2 1 port2 4.79e-1
R3 port1 port2 3.05e+4
L4 port1 2 1.65e-7
R4 2 port2 610
L5 port1 3 1.13e-7
R5 3 port2 63.2
L6 port1 4 1.10e-6
R6 4 port2 63.0
.ENDS LQP02HQ7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ8N2H02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 1.02e-8
R2 1 port2 3.89e-1
R3 port1 port2 1.60e+4
L4 port1 2 1.73e-7
R4 2 port2 569
L5 port1 3 9.21e-8
R5 3 port2 44.8
L6 port1 4 6.47e-6
R6 4 port2 2.18e+4
.ENDS LQP02HQ8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ8N2J02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 1.02e-8
R2 1 port2 3.89e-1
R3 port1 port2 1.60e+4
L4 port1 2 1.73e-7
R4 2 port2 569
L5 port1 3 9.21e-8
R5 3 port2 44.8
L6 port1 4 6.47e-6
R6 4 port2 2.18e+4
.ENDS LQP02HQ8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ9N1H02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.38e-8
R2 1 port2 6.03e-1
R3 port1 port2 2.42e+4
L4 port1 2 2.39e-7
R4 2 port2 1.08e+3
L5 port1 3 1.08e-7
R5 3 port2 81.5
L6 port1 4 5.26e-8
R6 4 port2 1.82
.ENDS LQP02HQ9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02HQ9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02HQ9N1J02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 1.38e-8
R2 1 port2 6.03e-1
R3 port1 port2 2.42e+4
L4 port1 2 2.39e-7
R4 2 port2 1.08e+3
L5 port1 3 1.08e-7
R5 3 port2 81.5
L6 port1 4 5.26e-8
R6 4 port2 1.82
.ENDS LQP02HQ9N1J02
*----------------------------------------------------------------------
