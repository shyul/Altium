*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN11NG00
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN11NG00 port1 port2
C1 port1 port2 4.98e-14
L2 port1 1 1.15e-8
R2 1 port2 3.30e-2
R3 port1 port2 1.64e+4
L4 port1 2 1.41e-7
R4 2 port2 9.63
L5 port1 3 3.96e-7
R5 3 port2 261
L6 port1 4 7.66e-7
R6 4 port2 4.49e+3
L7 port1 5 4.16e-7
C7 5 6 7.58e-16
R7 6 port2 301
.ENDS LQW2BAN11NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN11NJ00
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN11NJ00 port1 port2
C1 port1 port2 4.98e-14
L2 port1 1 1.15e-8
R2 1 port2 3.30e-2
R3 port1 port2 1.64e+4
L4 port1 2 1.41e-7
R4 2 port2 9.63
L5 port1 3 3.96e-7
R5 3 port2 261
L6 port1 4 7.66e-7
R6 4 port2 4.49e+3
L7 port1 5 4.16e-7
C7 5 6 7.58e-16
R7 6 port2 301
.ENDS LQW2BAN11NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN12NG00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN12NG00 port1 port2
C1 port1 port2 6.88e-14
L2 port1 1 1.26e-8
R2 1 port2 3.30e-2
R3 port1 port2 2.32e+4
L4 port1 2 6.14e-8
R4 2 port2 5.43
L5 port1 3 6.06e-7
R5 3 port2 1.32e+3
L6 port1 4 9.90e-7
R6 4 port2 9.78e+3
L7 port1 5 4.16e-7
C7 5 6 6.16e-16
R7 6 port2 301
.ENDS LQW2BAN12NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN12NJ00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN12NJ00 port1 port2
C1 port1 port2 6.88e-14
L2 port1 1 1.26e-8
R2 1 port2 3.30e-2
R3 port1 port2 2.32e+4
L4 port1 2 6.14e-8
R4 2 port2 5.43
L5 port1 3 6.06e-7
R5 3 port2 1.32e+3
L6 port1 4 9.90e-7
R6 4 port2 9.78e+3
L7 port1 5 4.16e-7
C7 5 6 6.16e-16
R7 6 port2 301
.ENDS LQW2BAN12NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN13NG00
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN13NG00 port1 port2
C1 port1 port2 9.07e-14
L2 port1 1 1.35e-8
R2 1 port2 3.30e-2
R3 port1 port2 1.53e+4
L4 port1 2 2.79e-7
R4 2 port2 16.3
L5 port1 3 3.79e-7
R5 3 port2 128
L6 port1 4 8.47e-7
R6 4 port2 3.24e+3
L7 port1 5 4.16e-7
C7 5 6 5.24e-16
R7 6 port2 301
.ENDS LQW2BAN13NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN13NJ00
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN13NJ00 port1 port2
C1 port1 port2 9.07e-14
L2 port1 1 1.35e-8
R2 1 port2 3.30e-2
R3 port1 port2 1.53e+4
L4 port1 2 2.79e-7
R4 2 port2 16.3
L5 port1 3 3.79e-7
R5 3 port2 128
L6 port1 4 8.47e-7
R6 4 port2 3.24e+3
L7 port1 5 4.16e-7
C7 5 6 5.24e-16
R7 6 port2 301
.ENDS LQW2BAN13NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN15NG00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN15NG00 port1 port2
C1 port1 port2 6.72e-14
L2 port1 1 1.55e-8
R2 1 port2 9.60e-2
R3 port1 port2 2.99e+4
L4 port1 2 4.45e-7
R4 2 port2 122
L5 port1 3 1.02e-6
R5 3 port2 1.74e+3
L6 port1 4 1.01e-6
R6 4 port2 8.43e+3
L7 port1 5 6.60e-7
C7 5 6 8.31e-16
R7 6 port2 301
L8 port1 7 1.17e-8
C8 7 8 2.65e-14
R8 8 port2 21.4
.ENDS LQW2BAN15NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN15NJ00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN15NJ00 port1 port2
C1 port1 port2 6.72e-14
L2 port1 1 1.55e-8
R2 1 port2 9.60e-2
R3 port1 port2 2.99e+4
L4 port1 2 4.45e-7
R4 2 port2 122
L5 port1 3 1.02e-6
R5 3 port2 1.74e+3
L6 port1 4 1.01e-6
R6 4 port2 8.43e+3
L7 port1 5 6.60e-7
C7 5 6 8.31e-16
R7 6 port2 301
L8 port1 7 1.17e-8
C8 7 8 2.65e-14
R8 8 port2 21.4
.ENDS LQW2BAN15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN18NG00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN18NG00 port1 port2
C1 port1 port2 3.29e-14
L2 port1 1 1.82e-8
R2 1 port2 4.10e-2
R3 port1 port2 2.99e+4
L4 port1 2 3.88e-7
R4 2 port2 66.8
L5 port1 3 1.62e-6
R5 3 port2 1.45e+3
L6 port1 4 1.22e-6
R6 4 port2 7.34e+3
L7 port1 5 6.60e-7
C7 5 6 7.24e-16
R7 6 port2 301
L8 port1 7 1.17e-8
C8 7 8 2.47e-14
R8 8 port2 17.0
.ENDS LQW2BAN18NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN18NJ00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN18NJ00 port1 port2
C1 port1 port2 3.29e-14
L2 port1 1 1.82e-8
R2 1 port2 4.10e-2
R3 port1 port2 2.99e+4
L4 port1 2 3.88e-7
R4 2 port2 66.8
L5 port1 3 1.62e-6
R5 3 port2 1.45e+3
L6 port1 4 1.22e-6
R6 4 port2 7.34e+3
L7 port1 5 6.60e-7
C7 5 6 7.24e-16
R7 6 port2 301
L8 port1 7 1.17e-8
C8 7 8 2.47e-14
R8 8 port2 17.0
.ENDS LQW2BAN18NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN20NG00
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN20NG00 port1 port2
C1 port1 port2 7.36e-14
L2 port1 1 2.09e-8
R2 1 port2 4.10e-2
R3 port1 port2 3.60e+4
L4 port1 2 3.79e-7
R4 2 port2 33.5
L5 port1 3 9.97e-7
R5 3 port2 603
L6 port1 4 1.28e-6
R6 4 port2 7.69e+3
L7 port1 5 6.60e-7
C7 5 6 6.60e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.75e-14
R8 8 port2 25.2
.ENDS LQW2BAN20NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN20NJ00
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN20NJ00 port1 port2
C1 port1 port2 7.36e-14
L2 port1 1 2.09e-8
R2 1 port2 4.10e-2
R3 port1 port2 3.60e+4
L4 port1 2 3.79e-7
R4 2 port2 33.5
L5 port1 3 9.97e-7
R5 3 port2 603
L6 port1 4 1.28e-6
R6 4 port2 7.69e+3
L7 port1 5 6.60e-7
C7 5 6 6.60e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.75e-14
R8 8 port2 25.2
.ENDS LQW2BAN20NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN22NG00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN22NG00 port1 port2
C1 port1 port2 8.65e-14
L2 port1 1 2.35e-8
R2 1 port2 5.80e-2
R3 port1 port2 3.60e+4
L4 port1 2 2.76e-7
R4 2 port2 21.9
L5 port1 3 9.30e-7
R5 3 port2 603
L6 port1 4 1.57e-6
R6 4 port2 8.63e+3
L7 port1 5 6.60e-7
C7 5 6 6.30e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.75e-14
R8 8 port2 25.2
.ENDS LQW2BAN22NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN22NJ00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN22NJ00 port1 port2
C1 port1 port2 8.65e-14
L2 port1 1 2.35e-8
R2 1 port2 5.80e-2
R3 port1 port2 3.60e+4
L4 port1 2 2.76e-7
R4 2 port2 21.9
L5 port1 3 9.30e-7
R5 3 port2 603
L6 port1 4 1.57e-6
R6 4 port2 8.63e+3
L7 port1 5 6.60e-7
C7 5 6 6.30e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.75e-14
R8 8 port2 25.2
.ENDS LQW2BAN22NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN24NG00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN24NG00 port1 port2
C1 port1 port2 9.48e-14
L2 port1 1 2.46e-8
R2 1 port2 1.20e-1
R3 port1 port2 3.60e+4
L4 port1 2 5.63e-7
R4 2 port2 125
L5 port1 3 2.49e-6
R5 3 port2 3.78e+3
L6 port1 4 1.64e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 6.75e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.52e-14
R8 8 port2 25.2
.ENDS LQW2BAN24NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN24NJ00
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN24NJ00 port1 port2
C1 port1 port2 9.48e-14
L2 port1 1 2.46e-8
R2 1 port2 1.20e-1
R3 port1 port2 3.60e+4
L4 port1 2 5.63e-7
R4 2 port2 125
L5 port1 3 2.49e-6
R5 3 port2 3.78e+3
L6 port1 4 1.64e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 6.75e-16
R7 6 port2 1.90e+3
L8 port1 7 9.11e-9
C8 7 8 1.52e-14
R8 8 port2 25.2
.ENDS LQW2BAN24NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN27NG00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN27NG00 port1 port2
C1 port1 port2 6.56e-14
L2 port1 1 2.70e-8
R2 1 port2 5.70e-2
R3 port1 port2 3.60e+4
L4 port1 2 6.46e-7
R4 2 port2 125
L5 port1 3 3.52e-6
R5 3 port2 3.78e+3
L6 port1 4 2.06e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 1.12e-15
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 8.35e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.43e-15
R9 10 port2 119
.ENDS LQW2BAN27NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN27NJ00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN27NJ00 port1 port2
C1 port1 port2 6.56e-14
L2 port1 1 2.70e-8
R2 1 port2 5.70e-2
R3 port1 port2 3.60e+4
L4 port1 2 6.46e-7
R4 2 port2 125
L5 port1 3 3.52e-6
R5 3 port2 3.78e+3
L6 port1 4 2.06e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 1.12e-15
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 8.35e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.43e-15
R9 10 port2 119
.ENDS LQW2BAN27NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN30NG00
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN30NG00 port1 port2
C1 port1 port2 9.27e-14
L2 port1 1 3.03e-8
R2 1 port2 6.30e-2
R3 port1 port2 3.60e+4
L4 port1 2 6.76e-7
R4 2 port2 125
L5 port1 3 3.95e-6
R5 3 port2 3.78e+3
L6 port1 4 2.16e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 1.07e-15
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 8.35e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.43e-15
R9 10 port2 119
.ENDS LQW2BAN30NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN30NJ00
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN30NJ00 port1 port2
C1 port1 port2 9.27e-14
L2 port1 1 3.03e-8
R2 1 port2 6.30e-2
R3 port1 port2 3.60e+4
L4 port1 2 6.76e-7
R4 2 port2 125
L5 port1 3 3.95e-6
R5 3 port2 3.78e+3
L6 port1 4 2.16e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 1.07e-15
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 8.35e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.43e-15
R9 10 port2 119
.ENDS LQW2BAN30NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN33NG00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN33NG00 port1 port2
C1 port1 port2 9.71e-14
L2 port1 1 3.40e-8
R2 1 port2 9.60e-2
R3 port1 port2 3.68e+4
L4 port1 2 6.76e-7
R4 2 port2 125
L5 port1 3 4.97e-6
R5 3 port2 3.78e+3
L6 port1 4 2.31e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 9.76e-16
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 6.95e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.35e-15
R9 10 port2 119
.ENDS LQW2BAN33NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN33NJ00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN33NJ00 port1 port2
C1 port1 port2 9.71e-14
L2 port1 1 3.40e-8
R2 1 port2 9.60e-2
R3 port1 port2 3.68e+4
L4 port1 2 6.76e-7
R4 2 port2 125
L5 port1 3 4.97e-6
R5 3 port2 3.78e+3
L6 port1 4 2.31e-6
R6 4 port2 9.04e+3
L7 port1 5 6.60e-7
C7 5 6 9.76e-16
R7 6 port2 1.90e+3
L8 port1 7 2.88e-8
C8 7 8 6.95e-15
R8 8 port2 79.7
L9 port1 9 3.27e-8
C9 9 10 3.35e-15
R9 10 port2 119
.ENDS LQW2BAN33NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN36NG00
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN36NG00 port1 port2
C1 port1 port2 7.54e-14
L2 port1 1 3.73e-8
R2 1 port2 6.40e-2
R3 port1 port2 3.68e+4
L4 port1 2 8.32e-7
R4 2 port2 125
L5 port1 3 5.71e-6
R5 3 port2 4.24e+3
L6 port1 4 2.53e-6
R6 4 port2 7.52e+3
L7 port1 5 6.60e-7
C7 5 6 1.62e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 6.79e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 3.35e-15
R9 10 port2 119
.ENDS LQW2BAN36NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN36NJ00
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN36NJ00 port1 port2
C1 port1 port2 7.54e-14
L2 port1 1 3.73e-8
R2 1 port2 6.40e-2
R3 port1 port2 3.68e+4
L4 port1 2 8.32e-7
R4 2 port2 125
L5 port1 3 5.71e-6
R5 3 port2 4.24e+3
L6 port1 4 2.53e-6
R6 4 port2 7.52e+3
L7 port1 5 6.60e-7
C7 5 6 1.62e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 6.79e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 3.35e-15
R9 10 port2 119
.ENDS LQW2BAN36NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN39NG00
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN39NG00 port1 port2
C1 port1 port2 8.86e-14
L2 port1 1 4.00e-8
R2 1 port2 6.40e-2
R3 port1 port2 3.68e+4
L4 port1 2 9.34e-7
R4 2 port2 122
L5 port1 3 4.43e-6
R5 3 port2 1.81e+3
L6 port1 4 2.59e-6
R6 4 port2 7.52e+3
L7 port1 5 6.60e-7
C7 5 6 1.55e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 5.39e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 2.99e-15
R9 10 port2 119
.ENDS LQW2BAN39NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN39NJ00
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN39NJ00 port1 port2
C1 port1 port2 8.86e-14
L2 port1 1 4.00e-8
R2 1 port2 6.40e-2
R3 port1 port2 3.68e+4
L4 port1 2 9.34e-7
R4 2 port2 122
L5 port1 3 4.43e-6
R5 3 port2 1.81e+3
L6 port1 4 2.59e-6
R6 4 port2 7.52e+3
L7 port1 5 6.60e-7
C7 5 6 1.55e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 5.39e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 2.99e-15
R9 10 port2 119
.ENDS LQW2BAN39NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN3N2J00
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN3N2J00 port1 port2
C1 port1 port2 2.87e-14
L2 port1 1 2.96e-9
R2 1 port2 1.30e-2
R3 port1 port2 4.40e+3
L4 port1 2 2.67e-8
R4 2 port2 2.47
L5 port1 3 5.23e-8
R5 3 port2 20.8
L6 port1 4 1.23e-7
R6 4 port2 692
.ENDS LQW2BAN3N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN3N6J00
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN3N6J00 port1 port2
C1 port1 port2 2.74e-14
L2 port1 1 3.40e-9
R2 1 port2 2.52e-2
R3 port1 port2 4.11e+3
L4 port1 2 5.47e-8
R4 2 port2 11.8
L5 port1 3 1.05e-7
R5 3 port2 116
L6 port1 4 2.13e-7
R6 4 port2 1.60e+3
.ENDS LQW2BAN3N6J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN43NG00
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN43NG00 port1 port2
C1 port1 port2 9.71e-14
L2 port1 1 4.49e-8
R2 1 port2 1.00e-1
R3 port1 port2 3.68e+4
L4 port1 2 7.18e-7
R4 2 port2 43.7
L5 port1 3 1.50e-6
R5 3 port2 428
L6 port1 4 2.93e-6
R6 4 port2 8.01e+3
L7 port1 5 6.60e-7
C7 5 6 1.51e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 5.91e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 2.92e-15
R9 10 port2 119
.ENDS LQW2BAN43NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN43NJ00
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN43NJ00 port1 port2
C1 port1 port2 9.71e-14
L2 port1 1 4.49e-8
R2 1 port2 1.00e-1
R3 port1 port2 3.68e+4
L4 port1 2 7.18e-7
R4 2 port2 43.7
L5 port1 3 1.50e-6
R5 3 port2 428
L6 port1 4 2.93e-6
R6 4 port2 8.01e+3
L7 port1 5 6.60e-7
C7 5 6 1.51e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 5.91e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 2.92e-15
R9 10 port2 119
.ENDS LQW2BAN43NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN47NG00
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN47NG00 port1 port2
C1 port1 port2 9.83e-14
L2 port1 1 4.89e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.19e-6
R4 2 port2 204
L5 port1 3 5.23e-6
R5 3 port2 4.73e+3
L6 port1 4 3.87e-6
R6 4 port2 1.96e+4
L7 port1 5 2.08e-7
C7 5 6 5.25e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.23e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.52e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAN47NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN47NJ00
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN47NJ00 port1 port2
C1 port1 port2 9.83e-14
L2 port1 1 4.89e-8
R2 1 port2 1.70e-1
R3 port1 port2 5.45e+4
L4 port1 2 1.19e-6
R4 2 port2 204
L5 port1 3 5.23e-6
R5 3 port2 4.73e+3
L6 port1 4 3.87e-6
R6 4 port2 1.96e+4
L7 port1 5 2.08e-7
C7 5 6 5.25e-15
R7 6 port2 376
L8 port1 7 3.53e-8
C8 7 8 9.23e-15
R8 8 port2 176
L9 port1 9 5.32e-7
C9 9 10 1.52e-16
R9 10 port2 1.40e+3
.ENDS LQW2BAN47NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN51NG00
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN51NG00 port1 port2
C1 port1 port2 1.04e-13
L2 port1 1 5.52e-8
R2 1 port2 8.70e-2
R3 port1 port2 3.68e+4
L4 port1 2 9.58e-7
R4 2 port2 53.4
L5 port1 3 1.80e-6
R5 3 port2 438
L6 port1 4 3.52e-6
R6 4 port2 8.01e+3
L7 port1 5 6.60e-7
C7 5 6 2.39e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 7.79e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 4.42e-15
R9 10 port2 119
.ENDS LQW2BAN51NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN51NJ00
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN51NJ00 port1 port2
C1 port1 port2 1.04e-13
L2 port1 1 5.52e-8
R2 1 port2 8.70e-2
R3 port1 port2 3.68e+4
L4 port1 2 9.58e-7
R4 2 port2 53.4
L5 port1 3 1.80e-6
R5 3 port2 438
L6 port1 4 3.52e-6
R6 4 port2 8.01e+3
L7 port1 5 6.60e-7
C7 5 6 2.39e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 7.79e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 4.42e-15
R9 10 port2 119
.ENDS LQW2BAN51NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN56NG00
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN56NG00 port1 port2
C1 port1 port2 8.45e-14
L2 port1 1 6.05e-8
R2 1 port2 1.50e-1
R3 port1 port2 4.74e+4
L4 port1 2 1.42e-6
R4 2 port2 53.4
L5 port1 3 1.84e-6
R5 3 port2 564
L6 port1 4 4.19e-6
R6 4 port2 1.12e+4
L7 port1 5 6.60e-7
C7 5 6 2.13e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 8.35e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 3.76e-15
R9 10 port2 119
.ENDS LQW2BAN56NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN56NJ00
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN56NJ00 port1 port2
C1 port1 port2 8.45e-14
L2 port1 1 6.05e-8
R2 1 port2 1.50e-1
R3 port1 port2 4.74e+4
L4 port1 2 1.42e-6
R4 2 port2 53.4
L5 port1 3 1.84e-6
R5 3 port2 564
L6 port1 4 4.19e-6
R6 4 port2 1.12e+4
L7 port1 5 6.60e-7
C7 5 6 2.13e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 8.35e-15
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 3.76e-15
R9 10 port2 119
.ENDS LQW2BAN56NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN62NG00
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN62NG00 port1 port2
C1 port1 port2 8.85e-14
L2 port1 1 6.34e-8
R2 1 port2 9.40e-2
R3 port1 port2 4.85e+4
L4 port1 2 1.21e-6
R4 2 port2 53.4
L5 port1 3 2.02e-6
R5 3 port2 564
L6 port1 4 4.19e-6
R6 4 port2 1.12e+4
L7 port1 5 6.60e-7
C7 5 6 2.81e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 1.08e-14
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 5.69e-15
R9 10 port2 119
L10 port1 11 4.09e-7
C10 11 12 2.38e-16
R10 12 port2 266
.ENDS LQW2BAN62NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN62NJ00
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN62NJ00 port1 port2
C1 port1 port2 8.85e-14
L2 port1 1 6.34e-8
R2 1 port2 9.40e-2
R3 port1 port2 4.85e+4
L4 port1 2 1.21e-6
R4 2 port2 53.4
L5 port1 3 2.02e-6
R5 3 port2 564
L6 port1 4 4.19e-6
R6 4 port2 1.12e+4
L7 port1 5 6.60e-7
C7 5 6 2.81e-15
R7 6 port2 477
L8 port1 7 5.75e-8
C8 7 8 1.08e-14
R8 8 port2 159
L9 port1 9 3.27e-8
C9 9 10 5.69e-15
R9 10 port2 119
L10 port1 11 4.09e-7
C10 11 12 2.38e-16
R10 12 port2 266
.ENDS LQW2BAN62NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN68NG00
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN68NG00 port1 port2
C1 port1 port2 7.36e-14
L2 port1 1 7.28e-8
R2 1 port2 1.60e-1
R3 port1 port2 4.85e+4
L4 port1 2 1.56e-6
R4 2 port2 53.4
L5 port1 3 2.27e-6
R5 3 port2 551
L6 port1 4 4.81e-6
R6 4 port2 1.02e+4
L7 port1 5 6.60e-7
C7 5 6 3.23e-15
R7 6 port2 301
L8 port1 7 5.75e-8
C8 7 8 1.21e-14
R8 8 port2 81.5
L9 port1 9 3.27e-8
C9 9 10 5.31e-15
R9 10 port2 119
L10 port1 11 1.63e-8
C10 11 12 4.75e-15
R10 12 port2 66.8
.ENDS LQW2BAN68NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN68NJ00
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN68NJ00 port1 port2
C1 port1 port2 7.36e-14
L2 port1 1 7.28e-8
R2 1 port2 1.60e-1
R3 port1 port2 4.85e+4
L4 port1 2 1.56e-6
R4 2 port2 53.4
L5 port1 3 2.27e-6
R5 3 port2 551
L6 port1 4 4.81e-6
R6 4 port2 1.02e+4
L7 port1 5 6.60e-7
C7 5 6 3.23e-15
R7 6 port2 301
L8 port1 7 5.75e-8
C8 7 8 1.21e-14
R8 8 port2 81.5
L9 port1 9 3.27e-8
C9 9 10 5.31e-15
R9 10 port2 119
L10 port1 11 1.63e-8
C10 11 12 4.75e-15
R10 12 port2 66.8
.ENDS LQW2BAN68NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN6N8J00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN6N8J00 port1 port2
C1 port1 port2 4.98e-14
L2 port1 1 6.78e-9
R2 1 port2 2.30e-2
R3 port1 port2 1.01e+4
L4 port1 2 1.44e-7
R4 2 port2 11.8
L5 port1 3 2.05e-7
R5 3 port2 88.0
L6 port1 4 3.70e-7
R6 4 port2 1.79e+3
L7 port1 5 2.23e-7
C7 5 6 4.68e-16
R7 6 port2 301
.ENDS LQW2BAN6N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN75NG00
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN75NG00 port1 port2
C1 port1 port2 7.89e-14
L2 port1 1 7.98e-8
R2 1 port2 2.30e-1
R3 port1 port2 4.85e+4
L4 port1 2 1.75e-6
R4 2 port2 53.4
L5 port1 3 2.32e-6
R5 3 port2 551
L6 port1 4 4.92e-6
R6 4 port2 1.02e+4
L7 port1 5 6.60e-7
C7 5 6 3.16e-15
R7 6 port2 301
L8 port1 7 5.75e-8
C8 7 8 1.21e-14
R8 8 port2 81.5
L9 port1 9 3.27e-8
C9 9 10 5.31e-15
R9 10 port2 119
L10 port1 11 1.63e-8
C10 11 12 4.75e-15
R10 12 port2 66.8
.ENDS LQW2BAN75NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN75NJ00
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN75NJ00 port1 port2
C1 port1 port2 7.89e-14
L2 port1 1 7.98e-8
R2 1 port2 2.30e-1
R3 port1 port2 4.85e+4
L4 port1 2 1.75e-6
R4 2 port2 53.4
L5 port1 3 2.32e-6
R5 3 port2 551
L6 port1 4 4.92e-6
R6 4 port2 1.02e+4
L7 port1 5 6.60e-7
C7 5 6 3.16e-15
R7 6 port2 301
L8 port1 7 5.75e-8
C8 7 8 1.21e-14
R8 8 port2 81.5
L9 port1 9 3.27e-8
C9 9 10 5.31e-15
R9 10 port2 119
L10 port1 11 1.63e-8
C10 11 12 4.75e-15
R10 12 port2 66.8
.ENDS LQW2BAN75NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN7N5J00
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN7N5J00 port1 port2
C1 port1 port2 7.03e-14
L2 port1 1 7.26e-9
R2 1 port2 3.10e-2
R3 port1 port2 1.64e+4
L4 port1 2 9.78e-8
R4 2 port2 14.1
L5 port1 3 3.24e-7
R5 3 port2 636
L6 port1 4 3.96e-7
R6 4 port2 7.33e+3
L7 port1 5 2.23e-7
C7 5 6 3.89e-16
R7 6 port2 301
.ENDS LQW2BAN7N5J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN82NG00
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN82NG00 port1 port2
C1 port1 port2 6.72e-14
L2 port1 1 8.75e-8
R2 1 port2 2.00e-1
R3 port1 port2 7.34e+4
L4 port1 2 2.06e-6
R4 2 port2 53.4
L5 port1 3 2.54e-6
R5 3 port2 604
L6 port1 4 5.27e-6
R6 4 port2 1.31e+4
L7 port1 5 6.60e-7
C7 5 6 4.07e-15
R7 6 port2 301
L8 port1 7 6.91e-8
C8 7 8 1.45e-14
R8 8 port2 81.5
L9 port1 9 3.84e-8
C9 9 10 6.24e-15
R9 10 port2 119
L10 port1 11 2.01e-8
C10 11 12 5.84e-15
R10 12 port2 66.8
.ENDS LQW2BAN82NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN82NJ00
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN82NJ00 port1 port2
C1 port1 port2 6.72e-14
L2 port1 1 8.75e-8
R2 1 port2 2.00e-1
R3 port1 port2 7.34e+4
L4 port1 2 2.06e-6
R4 2 port2 53.4
L5 port1 3 2.54e-6
R5 3 port2 604
L6 port1 4 5.27e-6
R6 4 port2 1.31e+4
L7 port1 5 6.60e-7
C7 5 6 4.07e-15
R7 6 port2 301
L8 port1 7 6.91e-8
C8 7 8 1.45e-14
R8 8 port2 81.5
L9 port1 9 3.84e-8
C9 9 10 6.24e-15
R9 10 port2 119
L10 port1 11 2.01e-8
C10 11 12 5.84e-15
R10 12 port2 66.8
.ENDS LQW2BAN82NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN8N2G00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN8N2G00 port1 port2
C1 port1 port2 7.89e-14
L2 port1 1 8.53e-9
R2 1 port2 7.10e-2
R3 port1 port2 1.64e+4
L4 port1 2 9.75e-8
R4 2 port2 14.9
L5 port1 3 3.22e-7
R5 3 port2 521
L6 port1 4 4.83e-7
R6 4 port2 6.20e+3
L7 port1 5 2.23e-7
C7 5 6 3.89e-16
R7 6 port2 301
.ENDS LQW2BAN8N2G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN8N2J00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN8N2J00 port1 port2
C1 port1 port2 7.89e-14
L2 port1 1 8.53e-9
R2 1 port2 7.10e-2
R3 port1 port2 1.64e+4
L4 port1 2 9.75e-8
R4 2 port2 14.9
L5 port1 3 3.22e-7
R5 3 port2 521
L6 port1 4 4.83e-7
R6 4 port2 6.20e+3
L7 port1 5 2.23e-7
C7 5 6 3.89e-16
R7 6 port2 301
.ENDS LQW2BAN8N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN91NG00
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN91NG00 port1 port2
C1 port1 port2 7.54e-14
L2 port1 1 9.59e-8
R2 1 port2 1.70e-1
R3 port1 port2 7.34e+4
L4 port1 2 1.75e-6
R4 2 port2 53.4
L5 port1 3 2.66e-6
R5 3 port2 604
L6 port1 4 5.52e-6
R6 4 port2 1.31e+4
L7 port1 5 1.17e-6
C7 5 6 2.40e-15
R7 6 port2 268
L8 port1 7 6.91e-8
C8 7 8 1.83e-14
R8 8 port2 81.5
L9 port1 9 3.84e-8
C9 9 10 8.81e-15
R9 10 port2 119
L10 port1 11 2.01e-8
C10 11 12 8.06e-15
R10 12 port2 66.8
.ENDS LQW2BAN91NG00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BAN91NJ00
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BAN91NJ00 port1 port2
C1 port1 port2 7.54e-14
L2 port1 1 9.59e-8
R2 1 port2 1.70e-1
R3 port1 port2 7.34e+4
L4 port1 2 1.75e-6
R4 2 port2 53.4
L5 port1 3 2.66e-6
R5 3 port2 604
L6 port1 4 5.52e-6
R6 4 port2 1.31e+4
L7 port1 5 1.17e-6
C7 5 6 2.40e-15
R7 6 port2 268
L8 port1 7 6.91e-8
C8 7 8 1.83e-14
R8 8 port2 81.5
L9 port1 9 3.84e-8
C9 9 10 8.81e-15
R9 10 port2 119
L10 port1 11 2.01e-8
C10 11 12 8.06e-15
R10 12 port2 66.8
.ENDS LQW2BAN91NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR10G00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR10G00 port1 port2
C1 port1 port2 8.96e-14
L2 port1 1 1.07e-7
R2 1 port2 2.90e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.83e-6
R4 2 port2 269
L5 port1 3 1.19e-5
R5 3 port2 5.06e+3
L6 port1 4 1.17e-5
R6 4 port2 1.32e+4
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.67e-6
C9 9 10 6.31e-17
R9 10 port2 4.95e+3
L10 port1 11 9.50e-7
C10 11 12 1.47e-16
R10 12 port2 1.93e+3
L11 port1 13 1.13e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR10G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR10J00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR10J00 port1 port2
C1 port1 port2 8.96e-14
L2 port1 1 1.07e-7
R2 1 port2 2.90e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.83e-6
R4 2 port2 269
L5 port1 3 1.19e-5
R5 3 port2 5.06e+3
L6 port1 4 1.17e-5
R6 4 port2 1.32e+4
L7 port1 5 1.52e-6
C7 5 6 2.04e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 5.21e-17
R8 8 port2 1.14e+4
L9 port1 9 4.67e-6
C9 9 10 6.31e-17
R9 10 port2 4.95e+3
L10 port1 11 9.50e-7
C10 11 12 1.47e-16
R10 12 port2 1.93e+3
L11 port1 13 1.13e-6
C11 13 14 7.90e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR10J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR11G00
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR11G00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 1.12e-7
R2 1 port2 3.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.51e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.87e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.95e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.98e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 9.72e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR11G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR11J00
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR11J00 port1 port2
C1 port1 port2 8.17e-14
L2 port1 1 1.12e-7
R2 1 port2 3.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.51e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.87e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.95e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.98e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 9.72e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR11J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR12G00
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR12G00 port1 port2
C1 port1 port2 9.38e-14
L2 port1 1 1.23e-7
R2 1 port2 3.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.51e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.56e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.95e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.98e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 9.72e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR12G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR12J00
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR12J00 port1 port2
C1 port1 port2 9.38e-14
L2 port1 1 1.23e-7
R2 1 port2 3.20e-1
R3 port1 port2 5.45e+4
L4 port1 2 2.96e-6
R4 2 port2 269
L5 port1 3 1.22e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 2.51e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 6.56e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 7.95e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 1.98e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 9.72e-17
R11 14 port2 2.19e+3
.ENDS LQW2BANR12J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR13G00
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR13G00 port1 port2
C1 port1 port2 8.55e-14
L2 port1 1 1.35e-7
R2 1 port2 3.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.10e-6
R4 2 port2 269
L5 port1 3 1.31e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 3.02e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 8.45e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 9.13e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.03e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.14e-16
R11 14 port2 2.19e+3
.ENDS LQW2BANR13G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR13J00
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR13J00 port1 port2
C1 port1 port2 8.55e-14
L2 port1 1 1.35e-7
R2 1 port2 3.50e-1
R3 port1 port2 5.45e+4
L4 port1 2 3.10e-6
R4 2 port2 269
L5 port1 3 1.31e-5
R5 3 port2 5.06e+3
L6 port1 4 1.26e-5
R6 4 port2 9.80e+3
L7 port1 5 1.52e-6
C7 5 6 3.02e-15
R7 6 port2 1.12e+3
L8 port1 7 1.87e-5
C8 7 8 8.45e-17
R8 8 port2 1.14e+4
L9 port1 9 4.56e-6
C9 9 10 9.13e-17
R9 10 port2 4.95e+3
L10 port1 11 9.07e-7
C10 11 12 2.03e-16
R10 12 port2 1.93e+3
L11 port1 13 1.05e-6
C11 13 14 1.14e-16
R11 14 port2 2.19e+3
.ENDS LQW2BANR13J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR15G00
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR15G00 port1 port2
C1 port1 port2 6.13e-14
L2 port1 1 1.56e-7
R2 1 port2 3.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 4.64e-6
R4 2 port2 855
L5 port1 3 6.38e-6
R5 3 port2 296
L6 port1 4 1.08e-5
R6 4 port2 1.77e+4
L7 port1 5 1.17e-6
C7 5 6 4.79e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 9.39e-15
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 3.51e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 5.09e-15
R10 12 port2 168
L11 port1 13 3.86e-7
C11 13 14 3.59e-16
R11 14 port2 1.04e+3
.ENDS LQW2BANR15G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR15J00
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR15J00 port1 port2
C1 port1 port2 6.13e-14
L2 port1 1 1.56e-7
R2 1 port2 3.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 4.64e-6
R4 2 port2 855
L5 port1 3 6.38e-6
R5 3 port2 296
L6 port1 4 1.08e-5
R6 4 port2 1.77e+4
L7 port1 5 1.17e-6
C7 5 6 4.79e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 9.39e-15
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 3.51e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 5.09e-15
R10 12 port2 168
L11 port1 13 3.86e-7
C11 13 14 3.59e-16
R11 14 port2 1.04e+3
.ENDS LQW2BANR15J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR16G00
* Property : L = 160[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR16G00 port1 port2
C1 port1 port2 8.27e-14
L2 port1 1 1.67e-7
R2 1 port2 3.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 9.05e-6
R4 2 port2 728
L5 port1 3 4.62e-6
R5 3 port2 854
L6 port1 4 1.06e-5
R6 4 port2 1.61e+4
L7 port1 5 1.17e-6
C7 5 6 4.79e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 8.56e-15
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 3.43e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 4.97e-15
R10 12 port2 168
L11 port1 13 3.60e-8
C11 13 14 3.94e-15
R11 14 port2 97.1
.ENDS LQW2BANR16G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR16J00
* Property : L = 160[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR16J00 port1 port2
C1 port1 port2 8.27e-14
L2 port1 1 1.67e-7
R2 1 port2 3.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 9.05e-6
R4 2 port2 728
L5 port1 3 4.62e-6
R5 3 port2 854
L6 port1 4 1.06e-5
R6 4 port2 1.61e+4
L7 port1 5 1.17e-6
C7 5 6 4.79e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 8.56e-15
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 3.43e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 4.97e-15
R10 12 port2 168
L11 port1 13 3.60e-8
C11 13 14 3.94e-15
R11 14 port2 97.1
.ENDS LQW2BANR16J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR18G00
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR18G00 port1 port2
C1 port1 port2 6.13e-14
L2 port1 1 1.83e-7
R2 1 port2 4.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 1.40e-5
R4 2 port2 283
L5 port1 3 4.51e-6
R5 3 port2 744
L6 port1 4 1.33e-5
R6 4 port2 1.69e+4
L7 port1 5 1.17e-6
C7 5 6 5.50e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 1.13e-14
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 4.03e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 5.58e-15
R10 12 port2 168
L11 port1 13 3.60e-8
C11 13 14 4.63e-15
R11 14 port2 97.1
L12 port1 15 1.21e-7
C12 15 16 8.35e-16
R12 16 port2 383
.ENDS LQW2BANR18G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR18J00
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR18J00 port1 port2
C1 port1 port2 6.13e-14
L2 port1 1 1.83e-7
R2 1 port2 4.80e-1
R3 port1 port2 7.34e+4
L4 port1 2 1.40e-5
R4 2 port2 283
L5 port1 3 4.51e-6
R5 3 port2 744
L6 port1 4 1.33e-5
R6 4 port2 1.69e+4
L7 port1 5 1.17e-6
C7 5 6 5.50e-15
R7 6 port2 330
L8 port1 7 2.19e-7
C8 7 8 1.13e-14
R8 8 port2 258
L9 port1 9 1.53e-7
C9 9 10 4.03e-15
R9 10 port2 474
L10 port1 11 5.05e-8
C10 11 12 5.58e-15
R10 12 port2 168
L11 port1 13 3.60e-8
C11 13 14 4.63e-15
R11 14 port2 97.1
L12 port1 15 1.21e-7
C12 15 16 8.35e-16
R12 16 port2 383
.ENDS LQW2BANR18J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR20G00
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR20G00 port1 port2
C1 port1 port2 4.54e-14
L2 port1 1 2.10e-7
R2 1 port2 5.20e-1
R3 port1 port2 7.34e+4
L4 port1 2 2.07e-5
R4 2 port2 283
L5 port1 3 5.06e-6
R5 3 port2 937
L6 port1 4 1.67e-5
R6 4 port2 1.69e+4
L7 port1 5 1.17e-6
C7 5 6 7.42e-15
R7 6 port2 208
L8 port1 7 2.19e-7
C8 7 8 1.52e-14
R8 8 port2 163
L9 port1 9 1.53e-7
C9 9 10 5.19e-15
R9 10 port2 238
L10 port1 11 6.36e-8
C10 11 12 5.45e-15
R10 12 port2 211
L11 port1 13 3.60e-8
C11 13 14 5.57e-15
R11 14 port2 97.1
L12 port1 15 1.21e-7
C12 15 16 1.05e-15
R12 16 port2 383
.ENDS LQW2BANR20G00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW2BANR20J00
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW2BANR20J00 port1 port2
C1 port1 port2 4.54e-14
L2 port1 1 2.10e-7
R2 1 port2 5.20e-1
R3 port1 port2 7.34e+4
L4 port1 2 2.07e-5
R4 2 port2 283
L5 port1 3 5.06e-6
R5 3 port2 937
L6 port1 4 1.67e-5
R6 4 port2 1.69e+4
L7 port1 5 1.17e-6
C7 5 6 7.42e-15
R7 6 port2 208
L8 port1 7 2.19e-7
C8 7 8 1.52e-14
R8 8 port2 163
L9 port1 9 1.53e-7
C9 9 10 5.19e-15
R9 10 port2 238
L10 port1 11 6.36e-8
C10 11 12 5.45e-15
R10 12 port2 211
L11 port1 13 3.60e-8
C11 13 14 5.57e-15
R11 14 port2 97.1
L12 port1 15 1.21e-7
C12 15 16 1.05e-15
R12 16 port2 383
.ENDS LQW2BANR20J00
*----------------------------------------------------------------------
