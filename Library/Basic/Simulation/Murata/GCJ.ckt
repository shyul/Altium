*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/3.30e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J335KE02
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J335KE02 Port1 Port2
C01 Port1 N01 2.63e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 2.02e-10
R03 N02 N03 1.44e-02
C04 N03 N04 2.62e-05
R04 N03 N04 3.94e+02
C05 N04 N05 1.28e-04
R05 N04 N05 7.58e+00
C06 N05 N06 1.09e-04
R06 N05 N06 8.89e-01
C07 N06 N07 1.20e-04
R07 N06 N07 8.00e-02
C08 N07 N08 6.35e-05
R08 N07 N08 1.99e-02
L09 N08 N09 3.36e-11
R09 N08 N09 7.01e-02
L10 N09 N10 2.03e-10
R10 N09 N10 2.86e-02
C11 N10 N11 1.01e-05
L11 N10 N11 3.81e-11
R11 N10 N11 4.91e-03
C12 N11 N12 2.54e-06
L12 N11 N12 6.75e-11
R12 N11 N12 7.79e-03
C13 N12 N13 8.65e-12
L13 N12 N13 7.15e-11
R13 N12 N13 1.08e+01
C14 N13 Port2 3.85e-12
L14 N13 Port2 7.84e-11
R14 N13 Port2 2.86e+01
.ENDS GCJ188C70J335KE02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/3.30e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J335ME02
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J335ME02 Port1 Port2
C01 Port1 N01 2.63e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 2.02e-10
R03 N02 N03 1.44e-02
C04 N03 N04 2.62e-05
R04 N03 N04 3.94e+02
C05 N04 N05 1.28e-04
R05 N04 N05 7.58e+00
C06 N05 N06 1.09e-04
R06 N05 N06 8.89e-01
C07 N06 N07 1.20e-04
R07 N06 N07 8.00e-02
C08 N07 N08 6.35e-05
R08 N07 N08 1.99e-02
L09 N08 N09 3.36e-11
R09 N08 N09 7.01e-02
L10 N09 N10 2.03e-10
R10 N09 N10 2.86e-02
C11 N10 N11 1.01e-05
L11 N10 N11 3.81e-11
R11 N10 N11 4.91e-03
C12 N11 N12 2.54e-06
L12 N11 N12 6.75e-11
R12 N11 N12 7.79e-03
C13 N12 N13 8.65e-12
L13 N12 N13 7.15e-11
R13 N12 N13 1.08e+01
C14 N13 Port2 3.85e-12
L14 N13 Port2 7.84e-11
R14 N13 Port2 2.86e+01
.ENDS GCJ188C70J335ME02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J475KE02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J475KE02 Port1 Port2
C01 Port1 N01 3.56e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.35e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.26e-04
R04 N03 N04 6.70e+01
C05 N04 N05 1.93e-04
R05 N04 N05 3.66e+00
C06 N05 N06 1.87e-04
R06 N05 N06 5.37e-01
C07 N06 N07 2.56e-04
R07 N06 N07 6.57e-02
C08 N07 N08 1.81e-04
R08 N07 N08 2.06e-02
C09 N08 N09 1.51e-04
R09 N08 N09 7.47e-03
L10 N09 N10 2.03e-11
R10 N09 N10 1.33e-01
L11 N10 N11 4.31e-11
R11 N10 N11 3.46e-02
L12 N11 N12 2.75e-10
R12 N11 N12 2.33e-02
C13 N12 N13 1.18e-05
L13 N12 N13 5.56e-11
R13 N12 N13 4.76e-03
C14 N13 N14 8.14e-06
L14 N13 N14 3.96e-11
R14 N13 N14 5.58e-03
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 4.07e+01
.ENDS GCJ188C70J475KE02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J475ME02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J475ME02 Port1 Port2
C01 Port1 N01 3.56e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.35e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.26e-04
R04 N03 N04 6.70e+01
C05 N04 N05 1.93e-04
R05 N04 N05 3.66e+00
C06 N05 N06 1.87e-04
R06 N05 N06 5.37e-01
C07 N06 N07 2.56e-04
R07 N06 N07 6.57e-02
C08 N07 N08 1.81e-04
R08 N07 N08 2.06e-02
C09 N08 N09 1.51e-04
R09 N08 N09 7.47e-03
L10 N09 N10 2.03e-11
R10 N09 N10 1.33e-01
L11 N10 N11 4.31e-11
R11 N10 N11 3.46e-02
L12 N11 N12 2.75e-10
R12 N11 N12 2.33e-02
C13 N12 N13 1.18e-05
L13 N12 N13 5.56e-11
R13 N12 N13 4.76e-03
C14 N13 N14 8.14e-06
L14 N13 N14 3.96e-11
R14 N13 N14 5.58e-03
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 4.07e+01
.ENDS GCJ188C70J475ME02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GCJ188L81C104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C104KA01 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188L81C104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GCJ188L81C104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C104MA01 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188L81C104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GCJ188L81C124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C124KA01 Port1 Port2
C01 Port1 N01 1.17e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.03e-10
R03 N02 N03 5.93e-02
C04 N03 N04 1.21e-05
R04 N03 N04 5.97e+02
C05 N04 N05 1.44e-05
R05 N04 N05 4.63e+01
C06 N05 N06 1.54e-05
R06 N05 N06 4.32e+00
C07 N06 N07 1.15e-05
R07 N06 N07 6.11e-01
C08 N07 N08 8.09e-06
R08 N07 N08 8.58e-02
C09 N08 N09 1.09e-05
R09 N08 N09 7.87e-03
L10 N09 N10 1.10e-10
R10 N09 N10 8.54e-02
L11 N10 N11 1.17e-11
R11 N10 N11 7.30e-02
C12 N11 N12 5.21e-07
L12 N11 N12 2.46e-11
R12 N11 N12 1.41e-02
C13 N12 N13 1.54e-07
L13 N12 N13 3.45e-11
R13 N12 N13 2.66e-02
C14 N13 N14 6.67e-12
L14 N13 N14 9.77e-11
R14 N13 N14 1.40e+01
C15 N14 Port2 4.04e-12
L15 N14 Port2 8.39e-11
R15 N14 Port2 2.20e+01
.ENDS GCJ188L81C124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/16[V]
* Murata P/N :GCJ188L81C154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188L81C154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/16[V]
* Murata P/N :GCJ188L81C154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C154MA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188L81C154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCJ188L81C224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C224KA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188L81C224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCJ188L81C224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C224MA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188L81C224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.90e-02[uF]/16[V]
* Murata P/N :GCJ188L81C393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C393KA01 Port1 Port2
C01 Port1 N01 3.97e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 2.73e-02
C04 N03 N04 4.76e-06
R04 N03 N04 1.51e+03
C05 N04 N05 5.69e-06
R05 N04 N05 1.18e+02
C06 N05 N06 5.71e-06
R06 N05 N06 1.18e+01
C07 N06 N07 4.62e-06
R07 N06 N07 1.45e+00
C08 N07 N08 3.60e-06
R08 N07 N08 1.87e-01
C09 N08 N09 2.55e-06
R09 N08 N09 2.96e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.20e-01
C11 N10 N11 2.15e-07
L11 N10 N11 2.11e-11
R11 N10 N11 2.80e-02
C12 N11 N12 6.67e-08
L12 N11 N12 2.91e-11
R12 N11 N12 4.14e-02
C13 N12 N13 3.99e-12
L13 N12 N13 1.15e-10
R13 N12 N13 1.44e+01
C14 N13 Port2 4.03e-12
L14 N13 Port2 6.46e-11
R14 N13 Port2 2.01e+01
.ENDS GCJ188L81C393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GCJ188L81C473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C473KA01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.13e-01
C04 N03 N04 2.90e-06
R04 N03 N04 2.05e+00
C05 N04 N05 5.66e-06
R05 N04 N05 1.22e-01
C06 N05 N06 4.11e-06
R06 N05 N06 4.69e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.43e-01
C08 N07 N08 3.95e-07
L08 N07 N08 1.42e-11
R08 N07 N08 2.83e-02
C09 N08 N09 8.56e-08
L09 N08 N09 3.06e-11
R09 N08 N09 4.42e-02
C10 N09 Port2 4.43e-12
L10 N09 Port2 8.24e-11
R10 N09 Port2 7.26e+00
.ENDS GCJ188L81C473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GCJ188L81C473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C473MA01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.13e-01
C04 N03 N04 2.90e-06
R04 N03 N04 2.05e+00
C05 N04 N05 5.66e-06
R05 N04 N05 1.22e-01
C06 N05 N06 4.11e-06
R06 N05 N06 4.69e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.43e-01
C08 N07 N08 3.95e-07
L08 N07 N08 1.42e-11
R08 N07 N08 2.83e-02
C09 N08 N09 8.56e-08
L09 N08 N09 3.06e-11
R09 N08 N09 4.42e-02
C10 N09 Port2 4.43e-12
L10 N09 Port2 8.24e-11
R10 N09 Port2 7.26e+00
.ENDS GCJ188L81C473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/16[V]
* Murata P/N :GCJ188L81C683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C683KA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L81C683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/16[V]
* Murata P/N :GCJ188L81C683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L81C683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ188L81E154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188L81E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ188L81E154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E154MA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188L81E154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ188L81E224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E224KA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188L81E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ188L81E224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E224MA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188L81E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCJ188L81E393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E393KA01 Port1 Port2
C01 Port1 N01 3.97e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 2.73e-02
C04 N03 N04 4.76e-06
R04 N03 N04 1.51e+03
C05 N04 N05 5.69e-06
R05 N04 N05 1.18e+02
C06 N05 N06 5.71e-06
R06 N05 N06 1.18e+01
C07 N06 N07 4.62e-06
R07 N06 N07 1.45e+00
C08 N07 N08 3.60e-06
R08 N07 N08 1.87e-01
C09 N08 N09 2.55e-06
R09 N08 N09 2.96e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.20e-01
C11 N10 N11 2.15e-07
L11 N10 N11 2.11e-11
R11 N10 N11 2.80e-02
C12 N11 N12 6.67e-08
L12 N11 N12 2.91e-11
R12 N11 N12 4.14e-02
C13 N12 N13 3.99e-12
L13 N12 N13 1.15e-10
R13 N12 N13 1.44e+01
C14 N13 Port2 4.03e-12
L14 N13 Port2 6.46e-11
R14 N13 Port2 2.01e+01
.ENDS GCJ188L81E393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ188L81E683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E683KA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L81E683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ188L81E683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L81E683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ188L81H102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188L81H102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ188L81H102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188L81H102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188L81H103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H103KA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188L81H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188L81H103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H103MA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188L81H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GCJ188L81H123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H123KA01 Port1 Port2
C01 Port1 N01 1.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.93e-01
C04 N03 N04 1.96e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.18e-06
R05 N04 N05 3.06e+02
C06 N05 N06 2.12e-06
R06 N05 N06 7.18e+01
C07 N06 N07 1.74e-06
R07 N06 N07 7.87e+00
C08 N07 N08 1.40e-06
R08 N07 N08 9.08e-01
C09 N08 N09 1.48e-06
R09 N08 N09 1.40e-01
C10 N09 N10 8.30e-07
R10 N09 N10 4.94e-02
L11 N10 N11 3.59e-11
R11 N10 N11 3.06e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.86e-01
C13 N12 N13 1.60e-07
L13 N12 N13 4.29e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.72e-07
L14 N13 N14 1.97e-12
R14 N13 N14 1.15e-02
C15 N14 Port2 1.84e-12
L15 N14 Port2 1.44e-10
R15 N14 Port2 2.43e+01
.ENDS GCJ188L81H123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCJ188L81H152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188L81H152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCJ188L81H152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H152MA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188L81H152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ188L81H153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188L81H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ188L81H153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188L81H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GCJ188L81H182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H182KA01 Port1 Port2
C01 Port1 N01 1.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.11e-01
C04 N03 N04 1.93e-07
R04 N03 N04 3.74e+04
C05 N04 N05 2.90e-07
R05 N04 N05 2.31e+03
C06 N05 N06 2.88e-07
R06 N05 N06 2.31e+02
C07 N06 N07 2.31e-07
R07 N06 N07 3.04e+01
C08 N07 N08 1.63e-07
R08 N07 N08 4.04e+00
C09 N08 N09 9.58e-08
R09 N08 N09 7.24e-01
C10 N09 N10 2.82e-08
R10 N09 N10 1.96e-01
C11 N10 N11 3.54e-09
L11 N10 N11 1.14e-11
R11 N10 N11 1.52e-01
C12 N11 N12 2.96e-11
L12 N11 N12 1.22e-10
R12 N11 N12 2.48e+00
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.15e-10
R13 N12 Port2 2.00e+01
.ENDS GCJ188L81H182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ188L81H222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H222KA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188L81H222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ188L81H222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H222MA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188L81H222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ188L81H223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H223KA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188L81H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ188L81H223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H223MA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188L81H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCJ188L81H272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H272KA01 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.57e-01
C04 N03 N04 4.07e-07
R04 N03 N04 6.74e+03
C05 N04 N05 8.37e-07
R05 N04 N05 4.77e+02
C06 N05 N06 6.66e-07
R06 N05 N06 1.58e+02
C07 N06 N07 5.75e-07
R07 N06 N07 4.16e+01
C08 N07 N08 3.73e-07
R08 N07 N08 7.92e+00
C09 N08 N09 2.32e-07
R09 N08 N09 1.29e+00
C10 N09 N10 1.25e-07
R10 N09 N10 2.61e-01
C11 N10 N11 5.84e-08
R11 N10 N11 8.11e-02
L12 N11 N12 4.17e-11
R12 N11 N12 2.02e-01
C13 N12 N13 2.63e-08
L13 N12 N13 9.19e-12
R13 N12 N13 6.16e-02
C14 N13 N14 3.53e-09
L14 N13 N14 2.74e-11
R14 N13 N14 1.60e-01
C15 N14 N15 1.68e-11
L15 N14 N15 1.17e-10
R15 N14 N15 2.53e+00
C16 N15 Port2 2.02e-12
L16 N15 Port2 1.89e-10
R16 N15 Port2 3.22e+01
.ENDS GCJ188L81H272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCJ188L81H332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H332KA01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.91e-01
C04 N03 N04 2.83e-07
R04 N03 N04 2.30e+04
C05 N04 N05 5.79e-07
R05 N04 N05 1.16e+03
C06 N05 N06 4.68e-07
R06 N05 N06 1.45e+02
C07 N06 N07 3.97e-07
R07 N06 N07 1.67e+01
C08 N07 N08 3.13e-07
R08 N07 N08 2.11e+00
C09 N08 N09 1.40e-07
R09 N08 N09 3.95e-01
C10 N09 N10 1.42e-07
R10 N09 N10 6.92e-02
C11 N10 N11 7.01e-09
L11 N10 N11 1.69e-11
R11 N10 N11 5.37e-02
C12 N11 N12 9.33e-09
L12 N11 N12 7.96e-12
R12 N11 N12 8.10e-02
C13 N12 N13 3.61e-11
L13 N12 N13 9.10e-11
R13 N12 N13 1.97e+00
C14 N13 Port2 1.20e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 2.40e+01
.ENDS GCJ188L81H332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GCJ188L81H392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H392KA01 Port1 Port2
C01 Port1 N01 4.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 4.25e-01
C04 N03 N04 6.88e-07
R04 N03 N04 5.37e+03
C05 N04 N05 7.99e-07
R05 N04 N05 7.25e+02
C06 N05 N06 8.64e-07
R06 N05 N06 1.41e+02
C07 N06 N07 5.65e-07
R07 N06 N07 2.40e+01
C08 N07 N08 4.94e-07
R08 N07 N08 3.00e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.00e-01
C10 N09 N10 1.31e-07
R10 N09 N10 1.64e-01
L11 N10 N11 6.55e-11
R11 N10 N11 2.65e-01
C12 N11 N12 2.27e-08
L12 N11 N12 6.34e-12
R12 N11 N12 5.03e-02
C13 N12 N13 3.52e-08
L13 N12 N13 3.01e-12
R13 N12 N13 1.88e-02
C14 N13 N14 6.63e-11
L14 N13 N14 3.77e-11
R14 N13 N14 8.95e-01
C15 N14 Port2 1.79e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 3.08e+01
.ENDS GCJ188L81H392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188L81H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H472KA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188L81H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188L81H472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H472MA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188L81H472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCJ188L81H562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H562KA01 Port1 Port2
C01 Port1 N01 5.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.32e-01
C04 N03 N04 6.71e-07
R04 N03 N04 1.04e+04
C05 N04 N05 9.09e-07
R05 N04 N05 7.36e+02
C06 N05 N06 9.05e-07
R06 N05 N06 7.36e+01
C07 N06 N07 7.59e-07
R07 N06 N07 9.26e+00
C08 N07 N08 6.08e-07
R08 N07 N08 1.17e+00
C09 N08 N09 2.91e-07
R09 N08 N09 2.16e-01
C10 N09 N10 4.93e-06
R10 N09 N10 6.58e-02
C11 N10 N11 5.09e-07
R11 N10 N11 2.50e-02
C12 N11 N12 8.18e-09
L12 N11 N12 2.01e-11
R12 N11 N12 7.68e-02
C13 N12 N13 6.68e-09
L13 N12 N13 1.66e-11
R13 N12 N13 9.91e-02
C14 N13 N14 2.04e-11
L14 N13 N14 2.68e-10
R14 N13 N14 4.11e+00
C15 N14 Port2 3.07e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 1.01e+01
.ENDS GCJ188L81H562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCJ188L81H682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H682KA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.11e-01
C04 N03 N04 8.16e-07
R04 N03 N04 7.69e+03
C05 N04 N05 1.07e-06
R05 N04 N05 5.97e+02
C06 N05 N06 1.00e-06
R06 N05 N06 6.40e+01
C07 N06 N07 8.49e-07
R07 N06 N07 7.51e+00
C08 N07 N08 6.49e-07
R08 N07 N08 1.02e+00
C09 N08 N09 3.34e-07
R09 N08 N09 2.01e-01
C10 N09 N10 5.49e-07
R10 N09 N10 1.51e-02
C11 N10 N11 2.37e-08
L11 N10 N11 8.73e-12
R11 N10 N11 5.07e-02
C12 N11 N12 4.65e-09
L12 N11 N12 2.71e-11
R12 N11 N12 1.36e-01
C13 N12 N13 3.22e-11
L13 N12 N13 1.64e-10
R13 N12 N13 2.40e+00
C14 N13 Port2 1.90e-12
L14 N13 Port2 1.64e-10
R14 N13 Port2 2.25e+01
.ENDS GCJ188L81H682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GCJ188L81H822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H822KA01 Port1 Port2
C01 Port1 N01 8.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 1.19e-01
C04 N03 N04 9.76e-07
R04 N03 N04 6.52e+03
C05 N04 N05 1.35e-06
R05 N04 N05 4.94e+02
C06 N05 N06 1.21e-06
R06 N05 N06 5.55e+01
C07 N06 N07 1.15e-06
R07 N06 N07 5.81e+00
C08 N07 N08 7.65e-07
R08 N07 N08 8.56e-01
C09 N08 N09 3.61e-07
R09 N08 N09 1.35e-01
C10 N09 N10 7.22e-06
R10 N09 N10 5.13e-02
C11 N10 N11 3.16e-08
L11 N10 N11 9.29e-12
R11 N10 N11 4.31e-02
C12 N11 N12 4.51e-09
L12 N11 N12 3.77e-11
R12 N11 N12 9.04e-02
C13 N12 N13 2.21e-11
L13 N12 N13 1.99e-10
R13 N12 N13 3.25e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 1.43e+01
.ENDS GCJ188L81H822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.30e+00[uF]/6.3[V]
* Murata P/N :GCJ188L8EC335KE08
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8EC335KE08 Port1 Port2
C01 Port1 N01 2.63e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 2.02e-10
R03 N02 N03 1.44e-02
C04 N03 N04 2.62e-05
R04 N03 N04 3.94e+02
C05 N04 N05 1.28e-04
R05 N04 N05 7.58e+00
C06 N05 N06 1.09e-04
R06 N05 N06 8.89e-01
C07 N06 N07 1.20e-04
R07 N06 N07 8.00e-02
C08 N07 N08 6.35e-05
R08 N07 N08 1.99e-02
L09 N08 N09 3.36e-11
R09 N08 N09 7.01e-02
L10 N09 N10 2.03e-10
R10 N09 N10 2.86e-02
C11 N10 N11 1.01e-05
L11 N10 N11 3.81e-11
R11 N10 N11 4.91e-03
C12 N11 N12 2.54e-06
L12 N11 N12 6.75e-11
R12 N11 N12 7.79e-03
C13 N12 N13 8.65e-12
L13 N12 N13 7.15e-11
R13 N12 N13 1.08e+01
C14 N13 Port2 3.85e-12
L14 N13 Port2 7.84e-11
R14 N13 Port2 2.86e+01
.ENDS GCJ188L8EC335KE08
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ188L8EH154KA07
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8EH154KA07 Port1 Port2
C01 Port1 N01 1.51e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 9.07e-11
R03 N02 N03 4.05e-02
C04 N03 N04 2.01e-05
R04 N03 N04 7.94e+02
C05 N04 N05 2.90e-05
R05 N04 N05 4.57e+01
C06 N05 N06 3.07e-05
R06 N05 N06 4.07e+00
C07 N06 N07 2.77e-05
R07 N06 N07 4.16e-01
C08 N07 N08 1.61e-05
R08 N07 N08 4.84e-02
L09 N08 N09 1.66e-11
R09 N08 N09 9.43e-02
L10 N09 N10 1.32e-10
R10 N09 N10 6.78e-02
C11 N10 N11 4.42e-07
L11 N10 N11 3.53e-11
R11 N10 N11 1.29e-02
C12 N11 N12 2.51e-07
L12 N11 N12 3.01e-11
R12 N11 N12 2.11e-02
C13 N12 N13 7.59e-12
L13 N12 N13 1.03e-10
R13 N12 N13 1.51e+01
C14 N13 Port2 1.31e-12
L14 N13 Port2 1.96e-10
R14 N13 Port2 1.45e+02
.ENDS GCJ188L8EH154KA07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188L8EH224KA07
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8EH224KA07 Port1 Port2
C01 Port1 N01 2.13e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 2.42e-10
R03 N02 N03 1.89e-02
C04 N03 N04 3.97e-05
R04 N03 N04 1.02e-01
C05 N04 N05 4.34e-05
R05 N04 N05 2.37e-02
C06 N05 N06 2.49e-05
R06 N05 N06 9.52e-03
L07 N06 N07 2.74e-11
R07 N06 N07 7.67e-02
L08 N07 N08 2.01e-10
R08 N07 N08 5.28e-02
C09 N08 N09 3.25e-06
L09 N08 N09 9.18e-12
R09 N08 N09 7.10e-03
C10 N09 N10 8.01e-07
L10 N09 N10 1.72e-11
R10 N09 N10 1.39e-02
C11 N10 Port2 6.48e-12
L11 N10 Port2 7.97e-11
R11 N10 Port2 9.49e+00
.ENDS GCJ188L8EH224KA07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ188L8EL104KA07
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8EL104KA07 Port1 Port2
C01 Port1 N01 9.91e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.39e-10
R03 N02 N03 3.51e-02
C04 N03 N04 5.63e-06
R04 N03 N04 6.57e-01
C05 N04 N05 6.91e-06
R05 N04 N05 3.15e-02
L06 N05 N06 1.36e-10
R06 N05 N06 8.09e-02
L07 N06 N07 1.12e-11
R07 N06 N07 6.27e-02
C08 N07 N08 5.56e-07
L08 N07 N08 2.55e-11
R08 N07 N08 1.86e-02
C09 N08 N09 2.05e-07
L09 N08 N09 1.97e-11
R09 N08 N09 1.69e-02
C10 N09 Port2 1.99e-12
L10 N09 Port2 1.61e-10
R10 N09 Port2 1.95e+01
.ENDS GCJ188L8EL104KA07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.90e-02[uF]/35[V]
* Murata P/N :GCJ188L8YA393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8YA393KA01 Port1 Port2
C01 Port1 N01 3.97e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 2.73e-02
C04 N03 N04 4.76e-06
R04 N03 N04 1.51e+03
C05 N04 N05 5.69e-06
R05 N04 N05 1.18e+02
C06 N05 N06 5.71e-06
R06 N05 N06 1.18e+01
C07 N06 N07 4.62e-06
R07 N06 N07 1.45e+00
C08 N07 N08 3.60e-06
R08 N07 N08 1.87e-01
C09 N08 N09 2.55e-06
R09 N08 N09 2.96e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.20e-01
C11 N10 N11 2.15e-07
L11 N10 N11 2.11e-11
R11 N10 N11 2.80e-02
C12 N11 N12 6.67e-08
L12 N11 N12 2.91e-11
R12 N11 N12 4.14e-02
C13 N12 N13 3.99e-12
L13 N12 N13 1.15e-10
R13 N12 N13 1.44e+01
C14 N13 Port2 4.03e-12
L14 N13 Port2 6.46e-11
R14 N13 Port2 2.01e+01
.ENDS GCJ188L8YA393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/35[V]
* Murata P/N :GCJ188L8YA683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8YA683KA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L8YA683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/6.80e-02[uF]/35[V]
* Murata P/N :GCJ188L8YA683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8YA683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188L8YA683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8M(-55to150[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GCJ188M8EC475KE08
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188M8EC475KE08 Port1 Port2
C01 Port1 N01 3.56e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.35e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.26e-04
R04 N03 N04 6.70e+01
C05 N04 N05 1.93e-04
R05 N04 N05 3.66e+00
C06 N05 N06 1.87e-04
R06 N05 N06 5.37e-01
C07 N06 N07 2.56e-04
R07 N06 N07 6.57e-02
C08 N07 N08 1.81e-04
R08 N07 N08 2.06e-02
C09 N08 N09 1.51e-04
R09 N08 N09 7.47e-03
L10 N09 N10 2.03e-11
R10 N09 N10 1.33e-01
L11 N10 N11 4.31e-11
R11 N10 N11 3.46e-02
L12 N11 N12 2.75e-10
R12 N11 N12 2.33e-02
C13 N12 N13 1.18e-05
L13 N12 N13 5.56e-11
R13 N12 N13 4.76e-03
C14 N13 N14 8.14e-06
L14 N13 N14 3.96e-11
R14 N13 N14 5.58e-03
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 4.07e+01
.ENDS GCJ188M8EC475KE08
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GCJ188R70J225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R70J225KE01 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.70e-10
R03 N02 N03 1.94e-02
C04 N03 N04 5.47e-05
R04 N03 N04 9.69e+01
C05 N04 N05 6.73e-05
R05 N04 N05 1.17e+01
C06 N05 N06 6.42e-05
R06 N05 N06 2.35e+00
C07 N06 N07 5.40e-05
R07 N06 N07 4.98e-01
C08 N07 N08 4.69e-05
R08 N07 N08 8.29e-02
C09 N08 N09 2.63e-05
R09 N08 N09 2.15e-02
L10 N09 N10 5.27e-11
R10 N09 N10 7.28e-02
L11 N10 N11 2.50e-10
R11 N10 N11 2.77e-02
C12 N11 N12 2.02e-05
L12 N11 N12 1.24e-11
R12 N11 N12 2.90e-03
C13 N12 N13 4.35e-06
L13 N12 N13 2.83e-11
R13 N12 N13 6.41e-03
C14 N13 Port2 3.70e-12
L14 N13 Port2 1.09e-10
R14 N13 Port2 1.65e+01
.ENDS GCJ188R70J225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GCJ188R70J225ME01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R70J225ME01 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.70e-10
R03 N02 N03 1.94e-02
C04 N03 N04 5.47e-05
R04 N03 N04 9.69e+01
C05 N04 N05 6.73e-05
R05 N04 N05 1.17e+01
C06 N05 N06 6.42e-05
R06 N05 N06 2.35e+00
C07 N06 N07 5.40e-05
R07 N06 N07 4.98e-01
C08 N07 N08 4.69e-05
R08 N07 N08 8.29e-02
C09 N08 N09 2.63e-05
R09 N08 N09 2.15e-02
L10 N09 N10 5.27e-11
R10 N09 N10 7.28e-02
L11 N10 N11 2.50e-10
R11 N10 N11 2.77e-02
C12 N11 N12 2.02e-05
L12 N11 N12 1.24e-11
R12 N11 N12 2.90e-03
C13 N12 N13 4.35e-06
L13 N12 N13 2.83e-11
R13 N12 N13 6.41e-03
C14 N13 Port2 3.70e-12
L14 N13 Port2 1.09e-10
R14 N13 Port2 1.65e+01
.ENDS GCJ188R70J225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-01[uF]/10[V]
* Murata P/N :GCJ188R71A124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71A124KA01 Port1 Port2
C01 Port1 N01 1.17e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.03e-10
R03 N02 N03 5.93e-02
C04 N03 N04 1.21e-05
R04 N03 N04 5.97e+02
C05 N04 N05 1.44e-05
R05 N04 N05 4.63e+01
C06 N05 N06 1.54e-05
R06 N05 N06 4.32e+00
C07 N06 N07 1.15e-05
R07 N06 N07 6.11e-01
C08 N07 N08 8.09e-06
R08 N07 N08 8.58e-02
C09 N08 N09 1.09e-05
R09 N08 N09 7.87e-03
L10 N09 N10 1.10e-10
R10 N09 N10 8.54e-02
L11 N10 N11 1.17e-11
R11 N10 N11 7.30e-02
C12 N11 N12 5.21e-07
L12 N11 N12 2.46e-11
R12 N11 N12 1.41e-02
C13 N12 N13 1.54e-07
L13 N12 N13 3.45e-11
R13 N12 N13 2.66e-02
C14 N13 N14 6.67e-12
L14 N13 N14 9.77e-11
R14 N13 N14 1.40e+01
C15 N14 Port2 4.04e-12
L15 N14 Port2 8.39e-11
R15 N14 Port2 2.20e+01
.ENDS GCJ188R71A124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/10[V]
* Murata P/N :GCJ188R71A154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71A154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71A154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/10[V]
* Murata P/N :GCJ188R71A154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71A154MA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71A154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GCJ188R71A224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71A224KA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71A224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GCJ188R71A224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71A224MA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71A224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/16[V]
* Murata P/N :GCJ188R71C103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C103KA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71C103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/16[V]
* Murata P/N :GCJ188R71C103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C103MA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71C103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GCJ188R71C124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C124KA01 Port1 Port2
C01 Port1 N01 1.17e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.03e-10
R03 N02 N03 5.93e-02
C04 N03 N04 1.21e-05
R04 N03 N04 5.97e+02
C05 N04 N05 1.44e-05
R05 N04 N05 4.63e+01
C06 N05 N06 1.54e-05
R06 N05 N06 4.32e+00
C07 N06 N07 1.15e-05
R07 N06 N07 6.11e-01
C08 N07 N08 8.09e-06
R08 N07 N08 8.58e-02
C09 N08 N09 1.09e-05
R09 N08 N09 7.87e-03
L10 N09 N10 1.10e-10
R10 N09 N10 8.54e-02
L11 N10 N11 1.17e-11
R11 N10 N11 7.30e-02
C12 N11 N12 5.21e-07
L12 N11 N12 2.46e-11
R12 N11 N12 1.41e-02
C13 N12 N13 1.54e-07
L13 N12 N13 3.45e-11
R13 N12 N13 2.66e-02
C14 N13 N14 6.67e-12
L14 N13 N14 9.77e-11
R14 N13 N14 1.40e+01
C15 N14 Port2 4.04e-12
L15 N14 Port2 8.39e-11
R15 N14 Port2 2.20e+01
.ENDS GCJ188R71C124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/16[V]
* Murata P/N :GCJ188R71C154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71C154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/16[V]
* Murata P/N :GCJ188R71C154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C154MA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71C154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCJ188R71C224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C224KA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71C224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCJ188R71C224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C224MA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71C224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/16[V]
* Murata P/N :GCJ188R71C273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C273KA01 Port1 Port2
C01 Port1 N01 2.65e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 5.92e-02
C04 N03 N04 1.60e-06
R04 N03 N04 3.05e+00
C05 N04 N05 2.10e-06
R05 N04 N05 3.86e-01
C06 N05 N06 1.52e-06
R06 N05 N06 6.79e-02
L07 N06 N07 5.66e-11
R07 N06 N07 1.27e-01
C08 N07 N08 1.79e-08
L08 N07 N08 5.71e-11
R08 N07 N08 5.89e-02
C09 N08 N09 4.55e-11
L09 N08 N09 1.29e-10
R09 N08 N09 1.70e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.57e-10
R10 N09 Port2 4.75e+01
.ENDS GCJ188R71C273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/16[V]
* Murata P/N :GCJ188R71C273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C273MA01 Port1 Port2
C01 Port1 N01 2.65e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 5.92e-02
C04 N03 N04 1.60e-06
R04 N03 N04 3.05e+00
C05 N04 N05 2.10e-06
R05 N04 N05 3.86e-01
C06 N05 N06 1.52e-06
R06 N05 N06 6.79e-02
L07 N06 N07 5.66e-11
R07 N06 N07 1.27e-01
C08 N07 N08 1.79e-08
L08 N07 N08 5.71e-11
R08 N07 N08 5.89e-02
C09 N08 N09 4.55e-11
L09 N08 N09 1.29e-10
R09 N08 N09 1.70e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.57e-10
R10 N09 Port2 4.75e+01
.ENDS GCJ188R71C273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-01[uF]/16[V]
* Murata P/N :GCJ188R71C274KA01
* Property : C = 2.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C274KA01 Port1 Port2
C01 Port1 N01 2.67e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.78e-10
R03 N02 N03 2.36e-02
C04 N03 N04 3.17e-05
R04 N03 N04 1.25e+02
C05 N04 N05 4.41e-05
R05 N04 N05 1.14e+01
C06 N05 N06 3.57e-05
R06 N05 N06 1.94e+00
C07 N06 N07 3.05e-05
R07 N06 N07 2.39e-01
C08 N07 N08 1.76e-05
R08 N07 N08 3.59e-02
L09 N08 N09 1.99e-11
R09 N08 N09 1.10e-01
L10 N09 N10 1.41e-10
R10 N09 N10 6.25e-02
C11 N10 N11 2.24e-06
L11 N10 N11 1.68e-11
R11 N10 N11 6.51e-03
C12 N11 N12 2.75e-07
L12 N11 N12 5.43e-11
R12 N11 N12 1.88e-02
C13 N12 N13 5.83e-12
L13 N12 N13 1.09e-10
R13 N12 N13 1.49e+01
C14 N13 Port2 4.39e-12
L14 N13 Port2 7.54e-11
R14 N13 Port2 2.73e+01
.ENDS GCJ188R71C274KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/16[V]
* Murata P/N :GCJ188R71C333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C333KA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 1.41e-01
C04 N03 N04 2.59e-06
R04 N03 N04 4.35e+00
C05 N04 N05 3.05e-06
R05 N04 N05 5.23e-01
C06 N05 N06 3.48e-06
R06 N05 N06 8.38e-02
C07 N06 N07 2.11e-06
R07 N06 N07 4.27e-02
L08 N07 N08 9.97e-11
R08 N07 N08 1.66e-01
C09 N08 N09 3.64e-08
L09 N08 N09 5.29e-11
R09 N08 N09 4.73e-02
C10 N09 N10 6.98e-11
L10 N09 N10 7.73e-11
R10 N09 N10 1.25e+00
C11 N10 Port2 2.00e-12
L11 N10 Port2 1.56e-10
R11 N10 Port2 1.62e+01
.ENDS GCJ188R71C333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/16[V]
* Murata P/N :GCJ188R71C333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 1.41e-01
C04 N03 N04 2.59e-06
R04 N03 N04 4.35e+00
C05 N04 N05 3.05e-06
R05 N04 N05 5.23e-01
C06 N05 N06 3.48e-06
R06 N05 N06 8.38e-02
C07 N06 N07 2.11e-06
R07 N06 N07 4.27e-02
L08 N07 N08 9.97e-11
R08 N07 N08 1.66e-01
C09 N08 N09 3.64e-08
L09 N08 N09 5.29e-11
R09 N08 N09 4.73e-02
C10 N09 N10 6.98e-11
L10 N09 N10 7.73e-11
R10 N09 N10 1.25e+00
C11 N10 Port2 2.00e-12
L11 N10 Port2 1.56e-10
R11 N10 Port2 1.62e+01
.ENDS GCJ188R71C333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GCJ188R71C334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C334KA01 Port1 Port2
C01 Port1 N01 3.25e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 2.19e-10
R03 N02 N03 1.92e-02
C04 N03 N04 1.35e-05
R04 N03 N04 5.34e-01
C05 N04 N05 2.48e-05
R05 N04 N05 2.38e-02
C06 N05 N06 2.93e-05
R06 N05 N06 4.67e-03
L07 N06 N07 2.52e-11
R07 N06 N07 1.14e-01
L08 N07 N08 1.64e-10
R08 N07 N08 5.67e-02
C09 N08 N09 2.43e-06
L09 N08 N09 1.79e-11
R09 N08 N09 7.31e-03
C10 N09 N10 4.47e-07
L10 N09 N10 4.52e-11
R10 N09 N10 1.83e-02
C11 N10 Port2 3.20e-12
L11 N10 Port2 1.14e-10
R11 N10 Port2 1.58e+01
.ENDS GCJ188R71C334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GCJ188R71C334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C334MA01 Port1 Port2
C01 Port1 N01 3.25e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 2.19e-10
R03 N02 N03 1.92e-02
C04 N03 N04 1.35e-05
R04 N03 N04 5.34e-01
C05 N04 N05 2.48e-05
R05 N04 N05 2.38e-02
C06 N05 N06 2.93e-05
R06 N05 N06 4.67e-03
L07 N06 N07 2.52e-11
R07 N06 N07 1.14e-01
L08 N07 N08 1.64e-10
R08 N07 N08 5.67e-02
C09 N08 N09 2.43e-06
L09 N08 N09 1.79e-11
R09 N08 N09 7.31e-03
C10 N09 N10 4.47e-07
L10 N09 N10 4.52e-11
R10 N09 N10 1.83e-02
C11 N10 Port2 3.20e-12
L11 N10 Port2 1.14e-10
R11 N10 Port2 1.58e+01
.ENDS GCJ188R71C334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/16[V]
* Murata P/N :GCJ188R71C393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C393KA01 Port1 Port2
C01 Port1 N01 3.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 8.02e-02
C04 N03 N04 2.79e-06
R04 N03 N04 3.49e+00
C05 N04 N05 3.65e-06
R05 N04 N05 3.47e-01
C06 N05 N06 4.76e-06
R06 N05 N06 5.85e-02
C07 N06 N07 2.36e-06
R07 N06 N07 2.94e-02
L08 N07 N08 1.11e-10
R08 N07 N08 1.29e-01
C09 N08 N09 2.04e-07
L09 N08 N09 2.13e-11
R09 N08 N09 2.01e-02
C10 N09 N10 8.29e-08
L10 N09 N10 2.14e-11
R10 N09 N10 3.48e-02
C11 N10 N11 5.88e-11
L11 N10 N11 9.08e-11
R11 N10 N11 1.38e+00
C12 N11 Port2 1.05e-12
L12 N11 Port2 2.27e-10
R12 N11 Port2 4.27e+01
.ENDS GCJ188R71C393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/16[V]
* Murata P/N :GCJ188R71C393MA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C393MA01 Port1 Port2
C01 Port1 N01 3.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 8.02e-02
C04 N03 N04 2.79e-06
R04 N03 N04 3.49e+00
C05 N04 N05 3.65e-06
R05 N04 N05 3.47e-01
C06 N05 N06 4.76e-06
R06 N05 N06 5.85e-02
C07 N06 N07 2.36e-06
R07 N06 N07 2.94e-02
L08 N07 N08 1.11e-10
R08 N07 N08 1.29e-01
C09 N08 N09 2.04e-07
L09 N08 N09 2.13e-11
R09 N08 N09 2.01e-02
C10 N09 N10 8.29e-08
L10 N09 N10 2.14e-11
R10 N09 N10 3.48e-02
C11 N10 N11 5.88e-11
L11 N10 N11 9.08e-11
R11 N10 N11 1.38e+00
C12 N11 Port2 1.05e-12
L12 N11 Port2 2.27e-10
R12 N11 Port2 4.27e+01
.ENDS GCJ188R71C393MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GCJ188R71C473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C473KA01 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GCJ188R71C473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GCJ188R71C473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C473MA01 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GCJ188R71C473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GCJ188R71C474KA12
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C474KA12 Port1 Port2
C01 Port1 N01 4.41e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.04e-10
R03 N02 N03 4.47e-02
C04 N03 N04 3.54e-05
R04 N03 N04 2.08e-01
C05 N04 N05 2.35e-05
R05 N04 N05 2.71e-02
L06 N05 N06 2.53e-11
R06 N05 N06 1.19e-01
L07 N06 N07 1.77e-10
R07 N06 N07 5.09e-02
C08 N07 N08 2.75e-06
L08 N07 N08 2.16e-11
R08 N07 N08 7.11e-03
C09 N08 N09 8.89e-07
L09 N08 N09 3.15e-11
R09 N08 N09 1.40e-02
C10 N09 N10 9.30e-12
L10 N09 N10 6.18e-11
R10 N09 N10 1.02e+01
C11 N10 Port2 1.57e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 6.56e+01
.ENDS GCJ188R71C474KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GCJ188R71C474MA12
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C474MA12 Port1 Port2
C01 Port1 N01 4.41e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.04e-10
R03 N02 N03 4.47e-02
C04 N03 N04 3.54e-05
R04 N03 N04 2.08e-01
C05 N04 N05 2.35e-05
R05 N04 N05 2.71e-02
L06 N05 N06 2.53e-11
R06 N05 N06 1.19e-01
L07 N06 N07 1.77e-10
R07 N06 N07 5.09e-02
C08 N07 N08 2.75e-06
L08 N07 N08 2.16e-11
R08 N07 N08 7.11e-03
C09 N08 N09 8.89e-07
L09 N08 N09 3.15e-11
R09 N08 N09 1.40e-02
C10 N09 N10 9.30e-12
L10 N09 N10 6.18e-11
R10 N09 N10 1.02e+01
C11 N10 Port2 1.57e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 6.56e+01
.ENDS GCJ188R71C474MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-02[uF]/16[V]
* Murata P/N :GCJ188R71C563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C563KA01 Port1 Port2
C01 Port1 N01 5.81e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 7.30e-11
R03 N02 N03 9.36e-02
C04 N03 N04 7.59e-06
R04 N03 N04 4.89e+02
C05 N04 N05 1.09e-05
R05 N04 N05 4.26e+01
C06 N05 N06 1.03e-05
R06 N05 N06 7.07e+00
C07 N06 N07 8.36e-06
R07 N06 N07 1.17e+00
C08 N07 N08 5.19e-06
R08 N07 N08 2.04e-01
C09 N08 N09 5.45e-06
R09 N08 N09 2.27e-02
L10 N09 N10 7.80e-11
R10 N09 N10 1.56e-01
C11 N10 N11 4.15e-08
L11 N10 N11 5.63e-11
R11 N10 N11 3.45e-02
C12 N11 N12 1.04e-10
L12 N11 N12 5.30e-11
R12 N11 N12 7.90e-01
C13 N12 Port2 1.03e-12
L13 N12 Port2 2.44e-10
R13 N12 Port2 6.84e+01
.ENDS GCJ188R71C563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-02[uF]/16[V]
* Murata P/N :GCJ188R71C823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C823KA01 Port1 Port2
C01 Port1 N01 8.26e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.31e-10
R03 N02 N03 9.78e-02
C04 N03 N04 1.67e-05
R04 N03 N04 2.38e+02
C05 N04 N05 1.26e-05
R05 N04 N05 9.69e+01
C06 N05 N06 1.03e-05
R06 N05 N06 1.11e+01
C07 N06 N07 9.50e-06
R07 N06 N07 1.31e+00
C08 N07 N08 1.01e-05
R08 N07 N08 1.34e-01
C09 N08 N09 5.22e-06
R09 N08 N09 1.90e-02
L10 N09 N10 9.30e-11
R10 N09 N10 6.17e-02
C11 N10 N11 5.90e-07
L11 N10 N11 1.83e-11
R11 N10 N11 1.43e-02
C12 N11 N12 1.67e-07
L12 N11 N12 2.79e-11
R12 N11 N12 2.81e-02
C13 N12 N13 3.16e-11
L13 N12 N13 1.71e-10
R13 N12 N13 2.03e+00
C14 N13 Port2 1.07e-12
L14 N13 Port2 1.80e-10
R14 N13 Port2 2.75e+01
.ENDS GCJ188R71C823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GCJ188R71E102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R71E102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GCJ188R71E102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R71E102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCJ188R71E103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E103KA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71E103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCJ188R71E103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E103MA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71E103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ188R71E104KA12
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E104KA12 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188R71E104KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ188R71E104MA12
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E104MA12 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188R71E104MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/25[V]
* Murata P/N :GCJ188R71E123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E123KA01 Port1 Port2
C01 Port1 N01 1.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.93e-01
C04 N03 N04 1.96e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.18e-06
R05 N04 N05 3.06e+02
C06 N05 N06 2.12e-06
R06 N05 N06 7.18e+01
C07 N06 N07 1.74e-06
R07 N06 N07 7.87e+00
C08 N07 N08 1.40e-06
R08 N07 N08 9.08e-01
C09 N08 N09 1.48e-06
R09 N08 N09 1.40e-01
C10 N09 N10 8.30e-07
R10 N09 N10 4.94e-02
L11 N10 N11 3.59e-11
R11 N10 N11 3.06e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.86e-01
C13 N12 N13 1.60e-07
L13 N12 N13 4.29e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.72e-07
L14 N13 N14 1.97e-12
R14 N13 N14 1.15e-02
C15 N14 Port2 1.84e-12
L15 N14 Port2 1.44e-10
R15 N14 Port2 2.43e+01
.ENDS GCJ188R71E123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GCJ188R71E124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E124KA01 Port1 Port2
C01 Port1 N01 1.17e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.03e-10
R03 N02 N03 5.93e-02
C04 N03 N04 1.21e-05
R04 N03 N04 5.97e+02
C05 N04 N05 1.44e-05
R05 N04 N05 4.63e+01
C06 N05 N06 1.54e-05
R06 N05 N06 4.32e+00
C07 N06 N07 1.15e-05
R07 N06 N07 6.11e-01
C08 N07 N08 8.09e-06
R08 N07 N08 8.58e-02
C09 N08 N09 1.09e-05
R09 N08 N09 7.87e-03
L10 N09 N10 1.10e-10
R10 N09 N10 8.54e-02
L11 N10 N11 1.17e-11
R11 N10 N11 7.30e-02
C12 N11 N12 5.21e-07
L12 N11 N12 2.46e-11
R12 N11 N12 1.41e-02
C13 N12 N13 1.54e-07
L13 N12 N13 3.45e-11
R13 N12 N13 2.66e-02
C14 N13 N14 6.67e-12
L14 N13 N14 9.77e-11
R14 N13 N14 1.40e+01
C15 N14 Port2 4.04e-12
L15 N14 Port2 8.39e-11
R15 N14 Port2 2.20e+01
.ENDS GCJ188R71E124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/25[V]
* Murata P/N :GCJ188R71E152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R71E152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/25[V]
* Murata P/N :GCJ188R71E152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E152MA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R71E152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/25[V]
* Murata P/N :GCJ188R71E153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R71E153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/25[V]
* Murata P/N :GCJ188R71E153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R71E153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ188R71E154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ188R71E154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E154MA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188R71E154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/25[V]
* Murata P/N :GCJ188R71E182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E182KA01 Port1 Port2
C01 Port1 N01 1.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.11e-01
C04 N03 N04 1.93e-07
R04 N03 N04 3.74e+04
C05 N04 N05 2.90e-07
R05 N04 N05 2.31e+03
C06 N05 N06 2.88e-07
R06 N05 N06 2.31e+02
C07 N06 N07 2.31e-07
R07 N06 N07 3.04e+01
C08 N07 N08 1.63e-07
R08 N07 N08 4.04e+00
C09 N08 N09 9.58e-08
R09 N08 N09 7.24e-01
C10 N09 N10 2.82e-08
R10 N09 N10 1.96e-01
C11 N10 N11 3.54e-09
L11 N10 N11 1.14e-11
R11 N10 N11 1.52e-01
C12 N11 N12 2.96e-11
L12 N11 N12 1.22e-10
R12 N11 N12 2.48e+00
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.15e-10
R13 N12 Port2 2.00e+01
.ENDS GCJ188R71E182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/25[V]
* Murata P/N :GCJ188R71E222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E222KA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R71E222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/25[V]
* Murata P/N :GCJ188R71E222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E222MA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R71E222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCJ188R71E223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E223KA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R71E223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCJ188R71E223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E223MA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R71E223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ188R71E224KA12
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E224KA12 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71E224KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ188R71E224MA12
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E224MA12 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.76e-10
R03 N02 N03 6.36e-02
C04 N03 N04 1.83e-05
R04 N03 N04 5.30e-01
C05 N04 N05 3.36e-05
R05 N04 N05 4.48e-02
C06 N05 N06 1.24e-05
R06 N05 N06 2.90e-02
L07 N06 N07 2.33e-11
R07 N06 N07 1.18e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.24e-02
C09 N08 N09 1.07e-06
L09 N08 N09 2.57e-11
R09 N08 N09 1.41e-02
C10 N09 N10 2.73e-07
L10 N09 N10 4.86e-11
R10 N09 N10 2.63e-02
C11 N10 N11 2.15e-11
L11 N10 N11 2.51e-11
R11 N10 N11 4.63e+00
C12 N11 Port2 2.70e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 2.29e+01
.ENDS GCJ188R71E224MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/25[V]
* Murata P/N :GCJ188R71E272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E272KA01 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.57e-01
C04 N03 N04 4.07e-07
R04 N03 N04 6.74e+03
C05 N04 N05 8.37e-07
R05 N04 N05 4.77e+02
C06 N05 N06 6.66e-07
R06 N05 N06 1.58e+02
C07 N06 N07 5.75e-07
R07 N06 N07 4.16e+01
C08 N07 N08 3.73e-07
R08 N07 N08 7.92e+00
C09 N08 N09 2.32e-07
R09 N08 N09 1.29e+00
C10 N09 N10 1.25e-07
R10 N09 N10 2.61e-01
C11 N10 N11 5.84e-08
R11 N10 N11 8.11e-02
L12 N11 N12 4.17e-11
R12 N11 N12 2.02e-01
C13 N12 N13 2.63e-08
L13 N12 N13 9.19e-12
R13 N12 N13 6.16e-02
C14 N13 N14 3.53e-09
L14 N13 N14 2.74e-11
R14 N13 N14 1.60e-01
C15 N14 N15 1.68e-11
L15 N14 N15 1.17e-10
R15 N14 N15 2.53e+00
C16 N15 Port2 2.02e-12
L16 N15 Port2 1.89e-10
R16 N15 Port2 3.22e+01
.ENDS GCJ188R71E272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCJ188R71E273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E273KA01 Port1 Port2
C01 Port1 N01 2.65e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 5.92e-02
C04 N03 N04 1.60e-06
R04 N03 N04 3.05e+00
C05 N04 N05 2.10e-06
R05 N04 N05 3.86e-01
C06 N05 N06 1.52e-06
R06 N05 N06 6.79e-02
L07 N06 N07 5.66e-11
R07 N06 N07 1.27e-01
C08 N07 N08 1.79e-08
L08 N07 N08 5.71e-11
R08 N07 N08 5.89e-02
C09 N08 N09 4.55e-11
L09 N08 N09 1.29e-10
R09 N08 N09 1.70e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.57e-10
R10 N09 Port2 4.75e+01
.ENDS GCJ188R71E273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCJ188R71E273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E273MA01 Port1 Port2
C01 Port1 N01 2.65e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 5.92e-02
C04 N03 N04 1.60e-06
R04 N03 N04 3.05e+00
C05 N04 N05 2.10e-06
R05 N04 N05 3.86e-01
C06 N05 N06 1.52e-06
R06 N05 N06 6.79e-02
L07 N06 N07 5.66e-11
R07 N06 N07 1.27e-01
C08 N07 N08 1.79e-08
L08 N07 N08 5.71e-11
R08 N07 N08 5.89e-02
C09 N08 N09 4.55e-11
L09 N08 N09 1.29e-10
R09 N08 N09 1.70e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.57e-10
R10 N09 Port2 4.75e+01
.ENDS GCJ188R71E273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/25[V]
* Murata P/N :GCJ188R71E332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E332KA01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.91e-01
C04 N03 N04 2.83e-07
R04 N03 N04 2.30e+04
C05 N04 N05 5.79e-07
R05 N04 N05 1.16e+03
C06 N05 N06 4.68e-07
R06 N05 N06 1.45e+02
C07 N06 N07 3.97e-07
R07 N06 N07 1.67e+01
C08 N07 N08 3.13e-07
R08 N07 N08 2.11e+00
C09 N08 N09 1.40e-07
R09 N08 N09 3.95e-01
C10 N09 N10 1.42e-07
R10 N09 N10 6.92e-02
C11 N10 N11 7.01e-09
L11 N10 N11 1.69e-11
R11 N10 N11 5.37e-02
C12 N11 N12 9.33e-09
L12 N11 N12 7.96e-12
R12 N11 N12 8.10e-02
C13 N12 N13 3.61e-11
L13 N12 N13 9.10e-11
R13 N12 N13 1.97e+00
C14 N13 Port2 1.20e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 2.40e+01
.ENDS GCJ188R71E332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCJ188R71E333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E333KA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 1.41e-01
C04 N03 N04 2.59e-06
R04 N03 N04 4.35e+00
C05 N04 N05 3.05e-06
R05 N04 N05 5.23e-01
C06 N05 N06 3.48e-06
R06 N05 N06 8.38e-02
C07 N06 N07 2.11e-06
R07 N06 N07 4.27e-02
L08 N07 N08 9.97e-11
R08 N07 N08 1.66e-01
C09 N08 N09 3.64e-08
L09 N08 N09 5.29e-11
R09 N08 N09 4.73e-02
C10 N09 N10 6.98e-11
L10 N09 N10 7.73e-11
R10 N09 N10 1.25e+00
C11 N10 Port2 2.00e-12
L11 N10 Port2 1.56e-10
R11 N10 Port2 1.62e+01
.ENDS GCJ188R71E333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCJ188R71E333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 1.41e-01
C04 N03 N04 2.59e-06
R04 N03 N04 4.35e+00
C05 N04 N05 3.05e-06
R05 N04 N05 5.23e-01
C06 N05 N06 3.48e-06
R06 N05 N06 8.38e-02
C07 N06 N07 2.11e-06
R07 N06 N07 4.27e-02
L08 N07 N08 9.97e-11
R08 N07 N08 1.66e-01
C09 N08 N09 3.64e-08
L09 N08 N09 5.29e-11
R09 N08 N09 4.73e-02
C10 N09 N10 6.98e-11
L10 N09 N10 7.73e-11
R10 N09 N10 1.25e+00
C11 N10 Port2 2.00e-12
L11 N10 Port2 1.56e-10
R11 N10 Port2 1.62e+01
.ENDS GCJ188R71E333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/25[V]
* Murata P/N :GCJ188R71E392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E392KA01 Port1 Port2
C01 Port1 N01 4.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 4.25e-01
C04 N03 N04 6.88e-07
R04 N03 N04 5.37e+03
C05 N04 N05 7.99e-07
R05 N04 N05 7.25e+02
C06 N05 N06 8.64e-07
R06 N05 N06 1.41e+02
C07 N06 N07 5.65e-07
R07 N06 N07 2.40e+01
C08 N07 N08 4.94e-07
R08 N07 N08 3.00e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.00e-01
C10 N09 N10 1.31e-07
R10 N09 N10 1.64e-01
L11 N10 N11 6.55e-11
R11 N10 N11 2.65e-01
C12 N11 N12 2.27e-08
L12 N11 N12 6.34e-12
R12 N11 N12 5.03e-02
C13 N12 N13 3.52e-08
L13 N12 N13 3.01e-12
R13 N12 N13 1.88e-02
C14 N13 N14 6.63e-11
L14 N13 N14 3.77e-11
R14 N13 N14 8.95e-01
C15 N14 Port2 1.79e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 3.08e+01
.ENDS GCJ188R71E392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCJ188R71E393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E393KA01 Port1 Port2
C01 Port1 N01 3.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 8.02e-02
C04 N03 N04 2.79e-06
R04 N03 N04 3.49e+00
C05 N04 N05 3.65e-06
R05 N04 N05 3.47e-01
C06 N05 N06 4.76e-06
R06 N05 N06 5.85e-02
C07 N06 N07 2.36e-06
R07 N06 N07 2.94e-02
L08 N07 N08 1.11e-10
R08 N07 N08 1.29e-01
C09 N08 N09 2.04e-07
L09 N08 N09 2.13e-11
R09 N08 N09 2.01e-02
C10 N09 N10 8.29e-08
L10 N09 N10 2.14e-11
R10 N09 N10 3.48e-02
C11 N10 N11 5.88e-11
L11 N10 N11 9.08e-11
R11 N10 N11 1.38e+00
C12 N11 Port2 1.05e-12
L12 N11 Port2 2.27e-10
R12 N11 Port2 4.27e+01
.ENDS GCJ188R71E393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCJ188R71E393MA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E393MA01 Port1 Port2
C01 Port1 N01 3.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 8.02e-02
C04 N03 N04 2.79e-06
R04 N03 N04 3.49e+00
C05 N04 N05 3.65e-06
R05 N04 N05 3.47e-01
C06 N05 N06 4.76e-06
R06 N05 N06 5.85e-02
C07 N06 N07 2.36e-06
R07 N06 N07 2.94e-02
L08 N07 N08 1.11e-10
R08 N07 N08 1.29e-01
C09 N08 N09 2.04e-07
L09 N08 N09 2.13e-11
R09 N08 N09 2.01e-02
C10 N09 N10 8.29e-08
L10 N09 N10 2.14e-11
R10 N09 N10 3.48e-02
C11 N10 N11 5.88e-11
L11 N10 N11 9.08e-11
R11 N10 N11 1.38e+00
C12 N11 Port2 1.05e-12
L12 N11 Port2 2.27e-10
R12 N11 Port2 4.27e+01
.ENDS GCJ188R71E393MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GCJ188R71E472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E472KA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R71E472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GCJ188R71E472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E472MA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R71E472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCJ188R71E473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E473KA01 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GCJ188R71E473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCJ188R71E473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E473MA01 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GCJ188R71E473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/25[V]
* Murata P/N :GCJ188R71E562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E562KA01 Port1 Port2
C01 Port1 N01 5.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.32e-01
C04 N03 N04 6.71e-07
R04 N03 N04 1.04e+04
C05 N04 N05 9.09e-07
R05 N04 N05 7.36e+02
C06 N05 N06 9.05e-07
R06 N05 N06 7.36e+01
C07 N06 N07 7.59e-07
R07 N06 N07 9.26e+00
C08 N07 N08 6.08e-07
R08 N07 N08 1.17e+00
C09 N08 N09 2.91e-07
R09 N08 N09 2.16e-01
C10 N09 N10 4.93e-06
R10 N09 N10 6.58e-02
C11 N10 N11 5.09e-07
R11 N10 N11 2.50e-02
C12 N11 N12 8.18e-09
L12 N11 N12 2.01e-11
R12 N11 N12 7.68e-02
C13 N12 N13 6.68e-09
L13 N12 N13 1.66e-11
R13 N12 N13 9.91e-02
C14 N13 N14 2.04e-11
L14 N13 N14 2.68e-10
R14 N13 N14 4.11e+00
C15 N14 Port2 3.07e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 1.01e+01
.ENDS GCJ188R71E562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GCJ188R71E682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E682KA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.11e-01
C04 N03 N04 8.16e-07
R04 N03 N04 7.69e+03
C05 N04 N05 1.07e-06
R05 N04 N05 5.97e+02
C06 N05 N06 1.00e-06
R06 N05 N06 6.40e+01
C07 N06 N07 8.49e-07
R07 N06 N07 7.51e+00
C08 N07 N08 6.49e-07
R08 N07 N08 1.02e+00
C09 N08 N09 3.34e-07
R09 N08 N09 2.01e-01
C10 N09 N10 5.49e-07
R10 N09 N10 1.51e-02
C11 N10 N11 2.37e-08
L11 N10 N11 8.73e-12
R11 N10 N11 5.07e-02
C12 N11 N12 4.65e-09
L12 N11 N12 2.71e-11
R12 N11 N12 1.36e-01
C13 N12 N13 3.22e-11
L13 N12 N13 1.64e-10
R13 N12 N13 2.40e+00
C14 N13 Port2 1.90e-12
L14 N13 Port2 1.64e-10
R14 N13 Port2 2.25e+01
.ENDS GCJ188R71E682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ188R71E683KA12
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E683KA12 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188R71E683KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ188R71E683MA12
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E683MA12 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188R71E683MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/25[V]
* Murata P/N :GCJ188R71E822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E822KA01 Port1 Port2
C01 Port1 N01 8.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 1.19e-01
C04 N03 N04 9.76e-07
R04 N03 N04 6.52e+03
C05 N04 N05 1.35e-06
R05 N04 N05 4.94e+02
C06 N05 N06 1.21e-06
R06 N05 N06 5.55e+01
C07 N06 N07 1.15e-06
R07 N06 N07 5.81e+00
C08 N07 N08 7.65e-07
R08 N07 N08 8.56e-01
C09 N08 N09 3.61e-07
R09 N08 N09 1.35e-01
C10 N09 N10 7.22e-06
R10 N09 N10 5.13e-02
C11 N10 N11 3.16e-08
L11 N10 N11 9.29e-12
R11 N10 N11 4.31e-02
C12 N11 N12 4.51e-09
L12 N11 N12 3.77e-11
R12 N11 N12 9.04e-02
C13 N12 N13 2.21e-11
L13 N12 N13 1.99e-10
R13 N12 N13 3.25e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 1.43e+01
.ENDS GCJ188R71E822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ188R71H102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R71H102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ188R71H102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R71H102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188R71H103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H103KA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188R71H103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H103MA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R71H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ188R71H104KA12
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H104KA12 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188R71H104KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ188R71H104MA12
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H104MA12 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 2.08e-05
R04 N03 N04 1.83e-01
C05 N04 N05 9.70e-06
R05 N04 N05 1.24e-01
C06 N05 N06 8.93e-06
R06 N05 N06 2.45e-02
C07 N06 N07 1.89e-06
R07 N06 N07 8.29e-03
L08 N07 N08 2.43e-10
R08 N07 N08 9.74e-02
L09 N08 N09 2.13e-11
R09 N08 N09 8.75e-02
C10 N09 N10 8.35e-07
L10 N09 N10 1.62e-11
R10 N09 N10 2.24e-02
C11 N10 N11 3.50e-07
L11 N10 N11 1.95e-11
R11 N10 N11 2.67e-02
C12 N11 Port2 3.81e-12
L12 N11 Port2 9.28e-11
R12 N11 Port2 1.25e+01
.ENDS GCJ188R71H104MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GCJ188R71H123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H123KA01 Port1 Port2
C01 Port1 N01 1.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.93e-01
C04 N03 N04 1.96e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.18e-06
R05 N04 N05 3.06e+02
C06 N05 N06 2.12e-06
R06 N05 N06 7.18e+01
C07 N06 N07 1.74e-06
R07 N06 N07 7.87e+00
C08 N07 N08 1.40e-06
R08 N07 N08 9.08e-01
C09 N08 N09 1.48e-06
R09 N08 N09 1.40e-01
C10 N09 N10 8.30e-07
R10 N09 N10 4.94e-02
L11 N10 N11 3.59e-11
R11 N10 N11 3.06e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.86e-01
C13 N12 N13 1.60e-07
L13 N12 N13 4.29e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.72e-07
L14 N13 N14 1.97e-12
R14 N13 N14 1.15e-02
C15 N14 Port2 1.84e-12
L15 N14 Port2 1.44e-10
R15 N14 Port2 2.43e+01
.ENDS GCJ188R71H123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCJ188R71H152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R71H152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCJ188R71H152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H152MA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R71H152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ188R71H153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R71H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ188R71H153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R71H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ188R71H154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H154KA01 Port1 Port2
C01 Port1 N01 1.51e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 9.07e-11
R03 N02 N03 4.05e-02
C04 N03 N04 2.01e-05
R04 N03 N04 7.94e+02
C05 N04 N05 2.90e-05
R05 N04 N05 4.57e+01
C06 N05 N06 3.07e-05
R06 N05 N06 4.07e+00
C07 N06 N07 2.77e-05
R07 N06 N07 4.16e-01
C08 N07 N08 1.61e-05
R08 N07 N08 4.84e-02
L09 N08 N09 1.66e-11
R09 N08 N09 9.43e-02
L10 N09 N10 1.32e-10
R10 N09 N10 6.78e-02
C11 N10 N11 4.42e-07
L11 N10 N11 3.53e-11
R11 N10 N11 1.29e-02
C12 N11 N12 2.51e-07
L12 N11 N12 3.01e-11
R12 N11 N12 2.11e-02
C13 N12 N13 7.59e-12
L13 N12 N13 1.03e-10
R13 N12 N13 1.51e+01
C14 N13 Port2 1.31e-12
L14 N13 Port2 1.96e-10
R14 N13 Port2 1.45e+02
.ENDS GCJ188R71H154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GCJ188R71H182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H182KA01 Port1 Port2
C01 Port1 N01 1.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.11e-01
C04 N03 N04 1.93e-07
R04 N03 N04 3.74e+04
C05 N04 N05 2.90e-07
R05 N04 N05 2.31e+03
C06 N05 N06 2.88e-07
R06 N05 N06 2.31e+02
C07 N06 N07 2.31e-07
R07 N06 N07 3.04e+01
C08 N07 N08 1.63e-07
R08 N07 N08 4.04e+00
C09 N08 N09 9.58e-08
R09 N08 N09 7.24e-01
C10 N09 N10 2.82e-08
R10 N09 N10 1.96e-01
C11 N10 N11 3.54e-09
L11 N10 N11 1.14e-11
R11 N10 N11 1.52e-01
C12 N11 N12 2.96e-11
L12 N11 N12 1.22e-10
R12 N11 N12 2.48e+00
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.15e-10
R13 N12 Port2 2.00e+01
.ENDS GCJ188R71H182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ188R71H222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H222KA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R71H222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ188R71H222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H222MA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R71H222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ188R71H223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H223KA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R71H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ188R71H223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H223MA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R71H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188R71H224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H224KA01 Port1 Port2
C01 Port1 N01 2.13e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 2.42e-10
R03 N02 N03 1.89e-02
C04 N03 N04 3.97e-05
R04 N03 N04 1.02e-01
C05 N04 N05 4.34e-05
R05 N04 N05 2.37e-02
C06 N05 N06 2.49e-05
R06 N05 N06 9.52e-03
L07 N06 N07 2.74e-11
R07 N06 N07 7.67e-02
L08 N07 N08 2.01e-10
R08 N07 N08 5.28e-02
C09 N08 N09 3.25e-06
L09 N08 N09 9.18e-12
R09 N08 N09 7.10e-03
C10 N09 N10 8.01e-07
L10 N09 N10 1.72e-11
R10 N09 N10 1.39e-02
C11 N10 Port2 6.48e-12
L11 N10 Port2 7.97e-11
R11 N10 Port2 9.49e+00
.ENDS GCJ188R71H224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188R71H224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H224MA01 Port1 Port2
C01 Port1 N01 2.13e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 2.42e-10
R03 N02 N03 1.89e-02
C04 N03 N04 3.97e-05
R04 N03 N04 1.02e-01
C05 N04 N05 4.34e-05
R05 N04 N05 2.37e-02
C06 N05 N06 2.49e-05
R06 N05 N06 9.52e-03
L07 N06 N07 2.74e-11
R07 N06 N07 7.67e-02
L08 N07 N08 2.01e-10
R08 N07 N08 5.28e-02
C09 N08 N09 3.25e-06
L09 N08 N09 9.18e-12
R09 N08 N09 7.10e-03
C10 N09 N10 8.01e-07
L10 N09 N10 1.72e-11
R10 N09 N10 1.39e-02
C11 N10 Port2 6.48e-12
L11 N10 Port2 7.97e-11
R11 N10 Port2 9.49e+00
.ENDS GCJ188R71H224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCJ188R71H272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H272KA01 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.57e-01
C04 N03 N04 4.07e-07
R04 N03 N04 6.74e+03
C05 N04 N05 8.37e-07
R05 N04 N05 4.77e+02
C06 N05 N06 6.66e-07
R06 N05 N06 1.58e+02
C07 N06 N07 5.75e-07
R07 N06 N07 4.16e+01
C08 N07 N08 3.73e-07
R08 N07 N08 7.92e+00
C09 N08 N09 2.32e-07
R09 N08 N09 1.29e+00
C10 N09 N10 1.25e-07
R10 N09 N10 2.61e-01
C11 N10 N11 5.84e-08
R11 N10 N11 8.11e-02
L12 N11 N12 4.17e-11
R12 N11 N12 2.02e-01
C13 N12 N13 2.63e-08
L13 N12 N13 9.19e-12
R13 N12 N13 6.16e-02
C14 N13 N14 3.53e-09
L14 N13 N14 2.74e-11
R14 N13 N14 1.60e-01
C15 N14 N15 1.68e-11
L15 N14 N15 1.17e-10
R15 N14 N15 2.53e+00
C16 N15 Port2 2.02e-12
L16 N15 Port2 1.89e-10
R16 N15 Port2 3.22e+01
.ENDS GCJ188R71H272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCJ188R71H332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H332KA01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.91e-01
C04 N03 N04 2.83e-07
R04 N03 N04 2.30e+04
C05 N04 N05 5.79e-07
R05 N04 N05 1.16e+03
C06 N05 N06 4.68e-07
R06 N05 N06 1.45e+02
C07 N06 N07 3.97e-07
R07 N06 N07 1.67e+01
C08 N07 N08 3.13e-07
R08 N07 N08 2.11e+00
C09 N08 N09 1.40e-07
R09 N08 N09 3.95e-01
C10 N09 N10 1.42e-07
R10 N09 N10 6.92e-02
C11 N10 N11 7.01e-09
L11 N10 N11 1.69e-11
R11 N10 N11 5.37e-02
C12 N11 N12 9.33e-09
L12 N11 N12 7.96e-12
R12 N11 N12 8.10e-02
C13 N12 N13 3.61e-11
L13 N12 N13 9.10e-11
R13 N12 N13 1.97e+00
C14 N13 Port2 1.20e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 2.40e+01
.ENDS GCJ188R71H332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GCJ188R71H392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H392KA01 Port1 Port2
C01 Port1 N01 4.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 4.25e-01
C04 N03 N04 6.88e-07
R04 N03 N04 5.37e+03
C05 N04 N05 7.99e-07
R05 N04 N05 7.25e+02
C06 N05 N06 8.64e-07
R06 N05 N06 1.41e+02
C07 N06 N07 5.65e-07
R07 N06 N07 2.40e+01
C08 N07 N08 4.94e-07
R08 N07 N08 3.00e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.00e-01
C10 N09 N10 1.31e-07
R10 N09 N10 1.64e-01
L11 N10 N11 6.55e-11
R11 N10 N11 2.65e-01
C12 N11 N12 2.27e-08
L12 N11 N12 6.34e-12
R12 N11 N12 5.03e-02
C13 N12 N13 3.52e-08
L13 N12 N13 3.01e-12
R13 N12 N13 1.88e-02
C14 N13 N14 6.63e-11
L14 N13 N14 3.77e-11
R14 N13 N14 8.95e-01
C15 N14 Port2 1.79e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 3.08e+01
.ENDS GCJ188R71H392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCJ188R71H393KA12
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H393KA12 Port1 Port2
C01 Port1 N01 3.97e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 2.73e-02
C04 N03 N04 4.76e-06
R04 N03 N04 1.51e+03
C05 N04 N05 5.69e-06
R05 N04 N05 1.18e+02
C06 N05 N06 5.71e-06
R06 N05 N06 1.18e+01
C07 N06 N07 4.62e-06
R07 N06 N07 1.45e+00
C08 N07 N08 3.60e-06
R08 N07 N08 1.87e-01
C09 N08 N09 2.55e-06
R09 N08 N09 2.96e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.20e-01
C11 N10 N11 2.15e-07
L11 N10 N11 2.11e-11
R11 N10 N11 2.80e-02
C12 N11 N12 6.67e-08
L12 N11 N12 2.91e-11
R12 N11 N12 4.14e-02
C13 N12 N13 3.99e-12
L13 N12 N13 1.15e-10
R13 N12 N13 1.44e+01
C14 N13 Port2 4.03e-12
L14 N13 Port2 6.46e-11
R14 N13 Port2 2.01e+01
.ENDS GCJ188R71H393KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188R71H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H472KA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R71H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188R71H472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H472MA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R71H472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ188R71H473KA12
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H473KA12 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.13e-01
C04 N03 N04 2.90e-06
R04 N03 N04 2.05e+00
C05 N04 N05 5.66e-06
R05 N04 N05 1.22e-01
C06 N05 N06 4.11e-06
R06 N05 N06 4.69e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.43e-01
C08 N07 N08 3.95e-07
L08 N07 N08 1.42e-11
R08 N07 N08 2.83e-02
C09 N08 N09 8.56e-08
L09 N08 N09 3.06e-11
R09 N08 N09 4.42e-02
C10 N09 Port2 4.43e-12
L10 N09 Port2 8.24e-11
R10 N09 Port2 7.26e+00
.ENDS GCJ188R71H473KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ188R71H473MA12
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H473MA12 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.13e-01
C04 N03 N04 2.90e-06
R04 N03 N04 2.05e+00
C05 N04 N05 5.66e-06
R05 N04 N05 1.22e-01
C06 N05 N06 4.11e-06
R06 N05 N06 4.69e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.43e-01
C08 N07 N08 3.95e-07
L08 N07 N08 1.42e-11
R08 N07 N08 2.83e-02
C09 N08 N09 8.56e-08
L09 N08 N09 3.06e-11
R09 N08 N09 4.42e-02
C10 N09 Port2 4.43e-12
L10 N09 Port2 8.24e-11
R10 N09 Port2 7.26e+00
.ENDS GCJ188R71H473MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCJ188R71H562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H562KA01 Port1 Port2
C01 Port1 N01 5.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.32e-01
C04 N03 N04 6.71e-07
R04 N03 N04 1.04e+04
C05 N04 N05 9.09e-07
R05 N04 N05 7.36e+02
C06 N05 N06 9.05e-07
R06 N05 N06 7.36e+01
C07 N06 N07 7.59e-07
R07 N06 N07 9.26e+00
C08 N07 N08 6.08e-07
R08 N07 N08 1.17e+00
C09 N08 N09 2.91e-07
R09 N08 N09 2.16e-01
C10 N09 N10 4.93e-06
R10 N09 N10 6.58e-02
C11 N10 N11 5.09e-07
R11 N10 N11 2.50e-02
C12 N11 N12 8.18e-09
L12 N11 N12 2.01e-11
R12 N11 N12 7.68e-02
C13 N12 N13 6.68e-09
L13 N12 N13 1.66e-11
R13 N12 N13 9.91e-02
C14 N13 N14 2.04e-11
L14 N13 N14 2.68e-10
R14 N13 N14 4.11e+00
C15 N14 Port2 3.07e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 1.01e+01
.ENDS GCJ188R71H562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCJ188R71H682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H682KA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.11e-01
C04 N03 N04 8.16e-07
R04 N03 N04 7.69e+03
C05 N04 N05 1.07e-06
R05 N04 N05 5.97e+02
C06 N05 N06 1.00e-06
R06 N05 N06 6.40e+01
C07 N06 N07 8.49e-07
R07 N06 N07 7.51e+00
C08 N07 N08 6.49e-07
R08 N07 N08 1.02e+00
C09 N08 N09 3.34e-07
R09 N08 N09 2.01e-01
C10 N09 N10 5.49e-07
R10 N09 N10 1.51e-02
C11 N10 N11 2.37e-08
L11 N10 N11 8.73e-12
R11 N10 N11 5.07e-02
C12 N11 N12 4.65e-09
L12 N11 N12 2.71e-11
R12 N11 N12 1.36e-01
C13 N12 N13 3.22e-11
L13 N12 N13 1.64e-10
R13 N12 N13 2.40e+00
C14 N13 Port2 1.90e-12
L14 N13 Port2 1.64e-10
R14 N13 Port2 2.25e+01
.ENDS GCJ188R71H682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ188R71H683KA12
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H683KA12 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188R71H683KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ188R71H683MA12
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H683MA12 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 8.13e-11
R03 N02 N03 2.88e-02
C04 N03 N04 3.58e-06
R04 N03 N04 1.77e+00
C05 N04 N05 6.41e-06
R05 N04 N05 1.17e-01
C06 N05 N06 3.57e-06
R06 N05 N06 2.28e-02
L07 N06 N07 1.87e-11
R07 N06 N07 9.79e-02
L08 N07 N08 1.54e-10
R08 N07 N08 9.23e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.82e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.39e-07
L10 N09 N10 2.91e-11
R10 N09 N10 3.70e-02
C11 N10 N11 1.25e-11
L11 N10 N11 4.61e-11
R11 N10 N11 8.64e+00
C12 N11 Port2 9.87e-13
L12 N11 Port2 2.34e-10
R12 N11 Port2 7.27e+01
.ENDS GCJ188R71H683MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GCJ188R71H822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H822KA01 Port1 Port2
C01 Port1 N01 8.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 1.19e-01
C04 N03 N04 9.76e-07
R04 N03 N04 6.52e+03
C05 N04 N05 1.35e-06
R05 N04 N05 4.94e+02
C06 N05 N06 1.21e-06
R06 N05 N06 5.55e+01
C07 N06 N07 1.15e-06
R07 N06 N07 5.81e+00
C08 N07 N08 7.65e-07
R08 N07 N08 8.56e-01
C09 N08 N09 3.61e-07
R09 N08 N09 1.35e-01
C10 N09 N10 7.22e-06
R10 N09 N10 5.13e-02
C11 N10 N11 3.16e-08
L11 N10 N11 9.29e-12
R11 N10 N11 4.31e-02
C12 N11 N12 4.51e-09
L12 N11 N12 3.77e-11
R12 N11 N12 9.04e-02
C13 N12 N13 2.21e-11
L13 N12 N13 1.99e-10
R13 N12 N13 3.25e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 1.43e+01
.ENDS GCJ188R71H822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ188R72A102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R72A102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ188R72A102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 2.71e-08
R04 N03 N04 2.85e+02
C05 N04 N05 1.65e-08
R05 N04 N05 1.83e+02
C06 N05 N06 1.05e-07
R06 N05 N06 1.74e+00
C07 N06 N07 5.95e-08
R07 N06 N07 6.63e-01
C08 N07 N08 1.50e-08
R08 N07 N08 2.46e-01
C09 N08 N09 1.31e-11
L09 N08 N09 2.63e-10
R09 N08 N09 5.07e+00
C10 N09 Port2 1.24e-12
L10 N09 Port2 2.34e-10
R10 N09 Port2 1.57e+01
.ENDS GCJ188R72A102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ188R72A103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A103KA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ188R72A103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A103MA01 Port1 Port2
C01 Port1 N01 9.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 8.82e-07
R04 N03 N04 3.49e+00
C05 N04 N05 1.19e-06
R05 N04 N05 1.22e+00
C06 N05 N06 8.87e-07
R06 N05 N06 2.60e-01
C07 N06 N07 7.60e-07
R07 N06 N07 9.39e-02
L08 N07 N08 7.75e-11
R08 N07 N08 1.62e-01
C09 N08 N09 2.11e-08
L09 N08 N09 1.82e-11
R09 N08 N09 6.16e-02
C10 N09 N10 5.62e-11
L10 N09 N10 8.21e-11
R10 N09 N10 1.58e+00
C11 N10 Port2 1.43e-12
L11 N10 Port2 1.70e-10
R11 N10 Port2 2.09e+01
.ENDS GCJ188R72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ188R72A104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A104KA01 Port1 Port2
C01 Port1 N01 9.91e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.39e-10
R03 N02 N03 3.51e-02
C04 N03 N04 5.63e-06
R04 N03 N04 6.57e-01
C05 N04 N05 6.91e-06
R05 N04 N05 3.15e-02
L06 N05 N06 1.36e-10
R06 N05 N06 8.09e-02
L07 N06 N07 1.12e-11
R07 N06 N07 6.27e-02
C08 N07 N08 5.56e-07
L08 N07 N08 2.55e-11
R08 N07 N08 1.86e-02
C09 N08 N09 2.05e-07
L09 N08 N09 1.97e-11
R09 N08 N09 1.69e-02
C10 N09 Port2 1.99e-12
L10 N09 Port2 1.61e-10
R10 N09 Port2 1.95e+01
.ENDS GCJ188R72A104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ188R72A104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A104MA01 Port1 Port2
C01 Port1 N01 9.91e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.39e-10
R03 N02 N03 3.51e-02
C04 N03 N04 5.63e-06
R04 N03 N04 6.57e-01
C05 N04 N05 6.91e-06
R05 N04 N05 3.15e-02
L06 N05 N06 1.36e-10
R06 N05 N06 8.09e-02
L07 N06 N07 1.12e-11
R07 N06 N07 6.27e-02
C08 N07 N08 5.56e-07
L08 N07 N08 2.55e-11
R08 N07 N08 1.86e-02
C09 N08 N09 2.05e-07
L09 N08 N09 1.97e-11
R09 N08 N09 1.69e-02
C10 N09 Port2 1.99e-12
L10 N09 Port2 1.61e-10
R10 N09 Port2 1.95e+01
.ENDS GCJ188R72A104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCJ188R72A123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A123KA01 Port1 Port2
C01 Port1 N01 1.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.93e-01
C04 N03 N04 1.96e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.18e-06
R05 N04 N05 3.06e+02
C06 N05 N06 2.12e-06
R06 N05 N06 7.18e+01
C07 N06 N07 1.74e-06
R07 N06 N07 7.87e+00
C08 N07 N08 1.40e-06
R08 N07 N08 9.08e-01
C09 N08 N09 1.48e-06
R09 N08 N09 1.40e-01
C10 N09 N10 8.30e-07
R10 N09 N10 4.94e-02
L11 N10 N11 3.59e-11
R11 N10 N11 3.06e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.86e-01
C13 N12 N13 1.60e-07
L13 N12 N13 4.29e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.72e-07
L14 N13 N14 1.97e-12
R14 N13 N14 1.15e-02
C15 N14 Port2 1.84e-12
L15 N14 Port2 1.44e-10
R15 N14 Port2 2.43e+01
.ENDS GCJ188R72A123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ188R72A152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R72A152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ188R72A152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A152MA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 4.53e-08
R04 N03 N04 4.19e+01
C05 N04 N05 7.90e-08
R05 N04 N05 3.93e+01
C06 N05 N06 8.37e-08
R06 N05 N06 1.36e+00
C07 N06 N07 3.22e-08
R07 N06 N07 2.85e-01
C08 N07 N08 8.50e-10
L08 N07 N08 1.83e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-11
L09 N08 N09 2.36e-10
R09 N08 N09 4.57e+00
C10 N09 Port2 1.46e-12
L10 N09 Port2 2.19e-10
R10 N09 Port2 3.72e+01
.ENDS GCJ188R72A152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ188R72A153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R72A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ188R72A153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 4.99e-07
R04 N03 N04 3.89e+01
C05 N04 N05 1.10e-06
R05 N04 N05 1.26e+00
C06 N05 N06 1.09e-06
R06 N05 N06 1.62e-01
C07 N06 N07 6.30e-07
R07 N06 N07 3.50e-02
L08 N07 N08 8.08e-11
R08 N07 N08 1.32e-01
C09 N08 N09 6.88e-08
L09 N08 N09 2.11e-11
R09 N08 N09 2.81e-02
C10 N09 N10 2.33e-08
L10 N09 N10 2.71e-11
R10 N09 N10 5.00e-02
C11 N10 N11 5.17e-11
L11 N10 N11 7.78e-11
R11 N10 N11 9.66e-01
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.72e-10
R12 N11 Port2 5.50e+01
.ENDS GCJ188R72A153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCJ188R72A182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A182KA01 Port1 Port2
C01 Port1 N01 1.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.11e-01
C04 N03 N04 1.93e-07
R04 N03 N04 3.74e+04
C05 N04 N05 2.90e-07
R05 N04 N05 2.31e+03
C06 N05 N06 2.88e-07
R06 N05 N06 2.31e+02
C07 N06 N07 2.31e-07
R07 N06 N07 3.04e+01
C08 N07 N08 1.63e-07
R08 N07 N08 4.04e+00
C09 N08 N09 9.58e-08
R09 N08 N09 7.24e-01
C10 N09 N10 2.82e-08
R10 N09 N10 1.96e-01
C11 N10 N11 3.54e-09
L11 N10 N11 1.14e-11
R11 N10 N11 1.52e-01
C12 N11 N12 2.96e-11
L12 N11 N12 1.22e-10
R12 N11 N12 2.48e+00
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.15e-10
R13 N12 Port2 2.00e+01
.ENDS GCJ188R72A182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ188R72A222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A222KA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R72A222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ188R72A222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A222MA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 5.54e-08
R04 N03 N04 6.29e+01
C05 N04 N05 1.76e-07
R05 N04 N05 3.02e+00
C06 N05 N06 1.65e-07
R06 N05 N06 4.21e-01
C07 N06 N07 6.18e-08
R07 N06 N07 1.98e-01
C08 N07 N08 1.50e-08
L08 N07 N08 1.04e-11
R08 N07 N08 4.43e-02
C09 N08 N09 2.27e-09
L09 N08 N09 2.81e-11
R09 N08 N09 1.83e-01
C10 N09 N10 1.81e-11
L10 N09 N10 1.43e-10
R10 N09 N10 2.99e+00
C11 N10 Port2 2.16e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.55e+01
.ENDS GCJ188R72A222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ188R72A223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A223KA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R72A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ188R72A223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A223MA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.19e-06
R04 N03 N04 1.71e+00
C05 N04 N05 2.18e-06
R05 N04 N05 5.17e-01
C06 N05 N06 1.09e-06
R06 N05 N06 1.24e-01
L07 N06 N07 7.32e-11
R07 N06 N07 2.00e-01
C08 N07 N08 2.03e-08
L08 N07 N08 4.33e-11
R08 N07 N08 5.70e-02
C09 N08 N09 1.19e-10
L09 N08 N09 3.68e-11
R09 N08 N09 8.03e-01
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.35e-10
R10 N09 Port2 1.42e+01
.ENDS GCJ188R72A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCJ188R72A272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A272KA01 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.57e-01
C04 N03 N04 4.07e-07
R04 N03 N04 6.74e+03
C05 N04 N05 8.37e-07
R05 N04 N05 4.77e+02
C06 N05 N06 6.66e-07
R06 N05 N06 1.58e+02
C07 N06 N07 5.75e-07
R07 N06 N07 4.16e+01
C08 N07 N08 3.73e-07
R08 N07 N08 7.92e+00
C09 N08 N09 2.32e-07
R09 N08 N09 1.29e+00
C10 N09 N10 1.25e-07
R10 N09 N10 2.61e-01
C11 N10 N11 5.84e-08
R11 N10 N11 8.11e-02
L12 N11 N12 4.17e-11
R12 N11 N12 2.02e-01
C13 N12 N13 2.63e-08
L13 N12 N13 9.19e-12
R13 N12 N13 6.16e-02
C14 N13 N14 3.53e-09
L14 N13 N14 2.74e-11
R14 N13 N14 1.60e-01
C15 N14 N15 1.68e-11
L15 N14 N15 1.17e-10
R15 N14 N15 2.53e+00
C16 N15 Port2 2.02e-12
L16 N15 Port2 1.89e-10
R16 N15 Port2 3.22e+01
.ENDS GCJ188R72A272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCJ188R72A332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A332KA01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.91e-01
C04 N03 N04 2.83e-07
R04 N03 N04 2.30e+04
C05 N04 N05 5.79e-07
R05 N04 N05 1.16e+03
C06 N05 N06 4.68e-07
R06 N05 N06 1.45e+02
C07 N06 N07 3.97e-07
R07 N06 N07 1.67e+01
C08 N07 N08 3.13e-07
R08 N07 N08 2.11e+00
C09 N08 N09 1.40e-07
R09 N08 N09 3.95e-01
C10 N09 N10 1.42e-07
R10 N09 N10 6.92e-02
C11 N10 N11 7.01e-09
L11 N10 N11 1.69e-11
R11 N10 N11 5.37e-02
C12 N11 N12 9.33e-09
L12 N11 N12 7.96e-12
R12 N11 N12 8.10e-02
C13 N12 N13 3.61e-11
L13 N12 N13 9.10e-11
R13 N12 N13 1.97e+00
C14 N13 Port2 1.20e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 2.40e+01
.ENDS GCJ188R72A332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ188R72A392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A392KA01 Port1 Port2
C01 Port1 N01 4.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 4.25e-01
C04 N03 N04 6.88e-07
R04 N03 N04 5.37e+03
C05 N04 N05 7.99e-07
R05 N04 N05 7.25e+02
C06 N05 N06 8.64e-07
R06 N05 N06 1.41e+02
C07 N06 N07 5.65e-07
R07 N06 N07 2.40e+01
C08 N07 N08 4.94e-07
R08 N07 N08 3.00e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.00e-01
C10 N09 N10 1.31e-07
R10 N09 N10 1.64e-01
L11 N10 N11 6.55e-11
R11 N10 N11 2.65e-01
C12 N11 N12 2.27e-08
L12 N11 N12 6.34e-12
R12 N11 N12 5.03e-02
C13 N12 N13 3.52e-08
L13 N12 N13 3.01e-12
R13 N12 N13 1.88e-02
C14 N13 N14 6.63e-11
L14 N13 N14 3.77e-11
R14 N13 N14 8.95e-01
C15 N14 Port2 1.79e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 3.08e+01
.ENDS GCJ188R72A392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ188R72A472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A472KA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R72A472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ188R72A472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A472MA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 2.07e-07
R04 N03 N04 9.36e+00
C05 N04 N05 3.35e-07
R05 N04 N05 5.53e-01
C06 N05 N06 1.56e-07
R06 N05 N06 1.19e-01
L07 N06 N07 1.05e-10
R07 N06 N07 3.63e-01
C08 N07 N08 2.78e-08
L08 N07 N08 1.69e-11
R08 N07 N08 6.93e-02
C09 N08 N09 9.09e-09
L09 N08 N09 2.16e-11
R09 N08 N09 1.17e-01
C10 N09 N10 5.33e-11
L10 N09 N10 4.75e-11
R10 N09 N10 9.94e-01
C11 N10 Port2 2.21e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 9.40e+00
.ENDS GCJ188R72A472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCJ188R72A562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A562KA01 Port1 Port2
C01 Port1 N01 5.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.32e-01
C04 N03 N04 6.71e-07
R04 N03 N04 1.04e+04
C05 N04 N05 9.09e-07
R05 N04 N05 7.36e+02
C06 N05 N06 9.05e-07
R06 N05 N06 7.36e+01
C07 N06 N07 7.59e-07
R07 N06 N07 9.26e+00
C08 N07 N08 6.08e-07
R08 N07 N08 1.17e+00
C09 N08 N09 2.91e-07
R09 N08 N09 2.16e-01
C10 N09 N10 4.93e-06
R10 N09 N10 6.58e-02
C11 N10 N11 5.09e-07
R11 N10 N11 2.50e-02
C12 N11 N12 8.18e-09
L12 N11 N12 2.01e-11
R12 N11 N12 7.68e-02
C13 N12 N13 6.68e-09
L13 N12 N13 1.66e-11
R13 N12 N13 9.91e-02
C14 N13 N14 2.04e-11
L14 N13 N14 2.68e-10
R14 N13 N14 4.11e+00
C15 N14 Port2 3.07e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 1.01e+01
.ENDS GCJ188R72A562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ188R72A682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A682KA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.11e-01
C04 N03 N04 8.16e-07
R04 N03 N04 7.69e+03
C05 N04 N05 1.07e-06
R05 N04 N05 5.97e+02
C06 N05 N06 1.00e-06
R06 N05 N06 6.40e+01
C07 N06 N07 8.49e-07
R07 N06 N07 7.51e+00
C08 N07 N08 6.49e-07
R08 N07 N08 1.02e+00
C09 N08 N09 3.34e-07
R09 N08 N09 2.01e-01
C10 N09 N10 5.49e-07
R10 N09 N10 1.51e-02
C11 N10 N11 2.37e-08
L11 N10 N11 8.73e-12
R11 N10 N11 5.07e-02
C12 N11 N12 4.65e-09
L12 N11 N12 2.71e-11
R12 N11 N12 1.36e-01
C13 N12 N13 3.22e-11
L13 N12 N13 1.64e-10
R13 N12 N13 2.40e+00
C14 N13 Port2 1.90e-12
L14 N13 Port2 1.64e-10
R14 N13 Port2 2.25e+01
.ENDS GCJ188R72A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCJ188R72A822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A822KA01 Port1 Port2
C01 Port1 N01 8.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 1.19e-01
C04 N03 N04 9.76e-07
R04 N03 N04 6.52e+03
C05 N04 N05 1.35e-06
R05 N04 N05 4.94e+02
C06 N05 N06 1.21e-06
R06 N05 N06 5.55e+01
C07 N06 N07 1.15e-06
R07 N06 N07 5.81e+00
C08 N07 N08 7.65e-07
R08 N07 N08 8.56e-01
C09 N08 N09 3.61e-07
R09 N08 N09 1.35e-01
C10 N09 N10 7.22e-06
R10 N09 N10 5.13e-02
C11 N10 N11 3.16e-08
L11 N10 N11 9.29e-12
R11 N10 N11 4.31e-02
C12 N11 N12 4.51e-09
L12 N11 N12 3.77e-11
R12 N11 N12 9.04e-02
C13 N12 N13 2.21e-11
L13 N12 N13 1.99e-10
R13 N12 N13 3.25e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 1.43e+01
.ENDS GCJ188R72A822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ188R91E334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E334KA01 Port1 Port2
C01 Port1 N01 2.66e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 7.03e-11
R03 N02 N03 3.06e-02
C04 N03 N04 5.73e-06
R04 N03 N04 2.21e+00
C05 N04 N05 8.88e-06
R05 N04 N05 1.79e-01
C06 N05 N06 5.57e-06
R06 N05 N06 3.20e-02
L07 N06 N07 2.99e-11
R07 N06 N07 1.43e-01
L08 N07 N08 1.56e-10
R08 N07 N08 4.84e-02
C09 N08 N09 3.05e-06
L09 N08 N09 1.09e-11
R09 N08 N09 7.22e-03
C10 N09 N10 5.11e-07
L10 N09 N10 2.98e-11
R10 N09 N10 1.62e-02
C11 N10 N11 3.76e-12
L11 N10 N11 1.22e-10
R11 N10 N11 3.36e+01
C12 N11 Port2 6.33e-13
L12 N11 Port2 1.64e-10
R12 N11 Port2 3.37e+02
.ENDS GCJ188R91E334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ188R91E334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E334MA01 Port1 Port2
C01 Port1 N01 2.66e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 7.03e-11
R03 N02 N03 3.06e-02
C04 N03 N04 5.73e-06
R04 N03 N04 2.21e+00
C05 N04 N05 8.88e-06
R05 N04 N05 1.79e-01
C06 N05 N06 5.57e-06
R06 N05 N06 3.20e-02
L07 N06 N07 2.99e-11
R07 N06 N07 1.43e-01
L08 N07 N08 1.56e-10
R08 N07 N08 4.84e-02
C09 N08 N09 3.05e-06
L09 N08 N09 1.09e-11
R09 N08 N09 7.22e-03
C10 N09 N10 5.11e-07
L10 N09 N10 2.98e-11
R10 N09 N10 1.62e-02
C11 N10 N11 3.76e-12
L11 N10 N11 1.22e-10
R11 N10 N11 3.36e+01
C12 N11 Port2 6.33e-13
L12 N11 Port2 1.64e-10
R12 N11 Port2 3.37e+02
.ENDS GCJ188R91E334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ188R91E394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E394KA01 Port1 Port2
C01 Port1 N01 3.31e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.94e-10
R03 N02 N03 1.21e-02
C04 N03 N04 1.86e-05
R04 N03 N04 2.14e+02
C05 N04 N05 2.05e-05
R05 N04 N05 3.73e+01
C06 N05 N06 1.57e-05
R06 N05 N06 5.77e+00
C07 N06 N07 1.77e-05
R07 N06 N07 6.94e-01
C08 N07 N08 1.67e-05
R08 N07 N08 1.66e-01
C09 N08 N09 8.55e-06
R09 N08 N09 4.89e-02
C10 N09 N10 9.42e-06
R10 N09 N10 7.18e-03
L11 N10 N11 3.08e-11
R11 N10 N11 8.41e-02
L12 N11 N12 1.62e-10
R12 N11 N12 4.52e-02
C13 N12 N13 1.78e-06
L13 N12 N13 2.43e-11
R13 N12 N13 1.16e-02
C14 N13 N14 7.21e-07
L14 N13 N14 2.91e-11
R14 N13 N14 1.78e-02
C15 N14 Port2 3.20e-12
L15 N14 Port2 1.37e-10
R15 N14 Port2 2.81e+01
.ENDS GCJ188R91E394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ188R91E474KA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E474KA01 Port1 Port2
C01 Port1 N01 3.79e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.91e-10
R03 N02 N03 1.35e-02
C04 N03 N04 1.13e-05
R04 N03 N04 3.42e-01
C05 N04 N05 1.57e-05
R05 N04 N05 4.95e-02
C06 N05 N06 7.20e-06
R06 N05 N06 9.54e-03
C07 N06 N07 2.98e-05
R07 N06 N07 6.74e-03
L08 N07 N08 8.65e-12
R08 N07 N08 1.37e-01
L09 N08 N09 4.12e-11
R09 N08 N09 1.04e-01
L10 N09 N10 2.27e-10
R10 N09 N10 5.00e-02
C11 N10 N11 2.45e-06
L11 N10 N11 2.19e-11
R11 N10 N11 1.24e-02
C12 N11 N12 1.35e-06
L12 N11 N12 1.93e-11
R12 N11 N12 1.40e-02
C13 N12 Port2 2.19e-12
L13 N12 Port2 8.11e-11
R13 N12 Port2 2.70e+01
.ENDS GCJ188R91E474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ188R91E474MA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E474MA01 Port1 Port2
C01 Port1 N01 3.79e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.91e-10
R03 N02 N03 1.35e-02
C04 N03 N04 1.13e-05
R04 N03 N04 3.42e-01
C05 N04 N05 1.57e-05
R05 N04 N05 4.95e-02
C06 N05 N06 7.20e-06
R06 N05 N06 9.54e-03
C07 N06 N07 2.98e-05
R07 N06 N07 6.74e-03
L08 N07 N08 8.65e-12
R08 N07 N08 1.37e-01
L09 N08 N09 4.12e-11
R09 N08 N09 1.04e-01
L10 N09 N10 2.27e-10
R10 N09 N10 5.00e-02
C11 N10 N11 2.45e-06
L11 N10 N11 2.19e-11
R11 N10 N11 1.24e-02
C12 N11 N12 1.35e-06
L12 N11 N12 1.93e-11
R12 N11 N12 1.40e-02
C13 N12 Port2 2.19e-12
L13 N12 Port2 8.11e-11
R13 N12 Port2 2.70e+01
.ENDS GCJ188R91E474MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188R91H103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H103KA01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 9.18e-02
C04 N03 N04 1.95e-07
R04 N03 N04 1.03e+01
C05 N04 N05 2.74e-07
R05 N04 N05 8.64e-01
C06 N05 N06 2.16e-07
R06 N05 N06 1.37e-01
C07 N06 N07 5.06e-07
R07 N06 N07 1.09e-02
L08 N07 N08 9.31e-11
R08 N07 N08 2.40e-01
L09 N08 N09 1.09e-11
R09 N08 N09 1.36e-01
C10 N09 N10 5.49e-08
L10 N09 N10 1.57e-11
R10 N09 N10 7.23e-02
C11 N10 N11 1.54e-08
L11 N10 N11 2.55e-11
R11 N10 N11 1.40e-01
C12 N11 Port2 3.37e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 2.63e+01
.ENDS GCJ188R91H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ188R91H103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H103MA01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 9.18e-02
C04 N03 N04 1.95e-07
R04 N03 N04 1.03e+01
C05 N04 N05 2.74e-07
R05 N04 N05 8.64e-01
C06 N05 N06 2.16e-07
R06 N05 N06 1.37e-01
C07 N06 N07 5.06e-07
R07 N06 N07 1.09e-02
L08 N07 N08 9.31e-11
R08 N07 N08 2.40e-01
L09 N08 N09 1.09e-11
R09 N08 N09 1.36e-01
C10 N09 N10 5.49e-08
L10 N09 N10 1.57e-11
R10 N09 N10 7.23e-02
C11 N10 N11 1.54e-08
L11 N10 N11 2.55e-11
R11 N10 N11 1.40e-01
C12 N11 Port2 3.37e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 2.63e+01
.ENDS GCJ188R91H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ188R91H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H104KA01 Port1 Port2
C01 Port1 N01 8.31e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 2.23e-10
R03 N02 N03 1.92e-01
C04 N03 N04 1.92e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.13e-06
R05 N04 N05 1.10e-01
C06 N05 N06 4.18e-06
R06 N05 N06 3.81e-02
L07 N06 N07 1.94e-11
R07 N06 N07 1.28e-01
L08 N07 N08 1.30e-10
R08 N07 N08 8.73e-02
C09 N08 N09 1.06e-05
L09 N08 N09 6.92e-13
R09 N08 N09 6.73e-04
C10 N09 N10 7.00e-07
L10 N09 N10 4.70e-12
R10 N09 N10 1.03e-02
C11 N10 Port2 2.23e-12
L11 N10 Port2 2.45e-10
R11 N10 Port2 4.50e+01
.ENDS GCJ188R91H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ188R91H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H104MA01 Port1 Port2
C01 Port1 N01 8.31e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 2.23e-10
R03 N02 N03 1.92e-01
C04 N03 N04 1.92e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.13e-06
R05 N04 N05 1.10e-01
C06 N05 N06 4.18e-06
R06 N05 N06 3.81e-02
L07 N06 N07 1.94e-11
R07 N06 N07 1.28e-01
L08 N07 N08 1.30e-10
R08 N07 N08 8.73e-02
C09 N08 N09 1.06e-05
L09 N08 N09 6.92e-13
R09 N08 N09 6.73e-04
C10 N09 N10 7.00e-07
L10 N09 N10 4.70e-12
R10 N09 N10 1.03e-02
C11 N10 Port2 2.23e-12
L11 N10 Port2 2.45e-10
R11 N10 Port2 4.50e+01
.ENDS GCJ188R91H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.20e-01[uF]/50[V]
* Murata P/N :GCJ188R91H124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H124KA01 Port1 Port2
C01 Port1 N01 1.13e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.19e-10
R03 N02 N03 2.18e-02
C04 N03 N04 4.95e-06
R04 N03 N04 1.70e+03
C05 N04 N05 5.52e-06
R05 N04 N05 1.48e+02
C06 N05 N06 4.44e-06
R06 N05 N06 1.82e+01
C07 N06 N07 3.91e-06
R07 N06 N07 2.09e+00
C08 N07 N08 2.64e-06
R08 N07 N08 2.72e-01
C09 N08 N09 2.45e-06
R09 N08 N09 2.83e-02
C10 N09 N10 5.05e-05
R10 N09 N10 2.39e-04
L11 N10 N11 9.44e-11
R11 N10 N11 8.57e-02
L12 N11 N12 1.17e-11
R12 N11 N12 8.38e-02
C13 N12 N13 1.61e-06
L13 N12 N13 6.68e-12
R13 N12 N13 7.51e-03
C14 N13 N14 9.51e-08
L14 N13 N14 4.61e-11
R14 N13 N14 3.36e-02
C15 N14 Port2 2.64e-12
L15 N14 Port2 1.95e-10
R15 N14 Port2 3.88e+01
.ENDS GCJ188R91H124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ188R91H154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H154KA01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.90e-10
R03 N02 N03 1.83e-02
C04 N03 N04 7.44e-06
R04 N03 N04 5.35e+02
C05 N04 N05 8.78e-06
R05 N04 N05 8.87e+01
C06 N05 N06 7.54e-06
R06 N05 N06 1.31e+01
C07 N06 N07 5.74e-06
R07 N06 N07 2.87e+00
C08 N07 N08 4.80e-06
R08 N07 N08 4.10e-01
C09 N08 N09 4.18e-06
R09 N08 N09 4.67e-02
C10 N09 N10 5.91e-06
R10 N09 N10 5.80e-03
L11 N10 N11 2.58e-11
R11 N10 N11 1.22e-01
L12 N11 N12 1.11e-10
R12 N11 N12 6.74e-02
C13 N12 N13 1.01e-06
L13 N12 N13 1.50e-11
R13 N12 N13 1.15e-02
C14 N13 N14 1.88e-07
L14 N13 N14 3.44e-11
R14 N13 N14 2.84e-02
C15 N14 Port2 2.63e-12
L15 N14 Port2 2.00e-10
R15 N14 Port2 4.38e+01
.ENDS GCJ188R91H154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-01[uF]/50[V]
* Murata P/N :GCJ188R91H184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H184KA01 Port1 Port2
C01 Port1 N01 1.63e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 1.93e-10
R03 N02 N03 1.63e-02
C04 N03 N04 6.77e-06
R04 N03 N04 1.06e+03
C05 N04 N05 7.91e-06
R05 N04 N05 8.45e+01
C06 N05 N06 6.55e-06
R06 N05 N06 1.02e+01
C07 N06 N07 5.60e-06
R07 N06 N07 1.17e+00
C08 N07 N08 4.29e-06
R08 N07 N08 1.56e-01
C09 N08 N09 3.51e-06
R09 N08 N09 2.05e-02
L10 N09 N10 2.01e-11
R10 N09 N10 1.11e-01
L11 N10 N11 1.19e-10
R11 N10 N11 6.60e-02
C12 N11 N12 1.53e-06
L12 N11 N12 1.19e-11
R12 N11 N12 1.07e-02
C13 N12 N13 2.17e-07
L13 N12 N13 3.78e-11
R13 N12 N13 2.86e-02
C14 N13 Port2 2.80e-12
L14 N13 Port2 1.56e-10
R14 N13 Port2 3.45e+01
.ENDS GCJ188R91H184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188R91H224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H224KA01 Port1 Port2
C01 Port1 N01 1.93e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.99e-10
R03 N02 N03 2.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 8.16e-01
C05 N04 N05 2.61e-05
R05 N04 N05 4.84e-01
C06 N05 N06 8.63e-06
R06 N05 N06 9.08e-02
C07 N06 N07 4.06e-06
R07 N06 N07 3.22e-02
L08 N07 N08 2.82e-11
R08 N07 N08 2.01e-01
L09 N08 N09 1.35e-10
R09 N08 N09 6.91e-02
C10 N09 N10 1.16e-06
L10 N09 N10 2.10e-11
R10 N09 N10 1.47e-02
C11 N10 N11 2.55e-07
L11 N10 N11 4.21e-11
R11 N10 N11 2.69e-02
C12 N11 Port2 3.46e-12
L12 N11 Port2 1.08e-10
R12 N11 Port2 3.44e+01
.ENDS GCJ188R91H224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188R91H224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H224MA01 Port1 Port2
C01 Port1 N01 1.93e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.99e-10
R03 N02 N03 2.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 8.16e-01
C05 N04 N05 2.61e-05
R05 N04 N05 4.84e-01
C06 N05 N06 8.63e-06
R06 N05 N06 9.08e-02
C07 N06 N07 4.06e-06
R07 N06 N07 3.22e-02
L08 N07 N08 2.82e-11
R08 N07 N08 2.01e-01
L09 N08 N09 1.35e-10
R09 N08 N09 6.91e-02
C10 N09 N10 1.16e-06
L10 N09 N10 2.10e-11
R10 N09 N10 1.47e-02
C11 N10 N11 2.55e-07
L11 N10 N11 4.21e-11
R11 N10 N11 2.69e-02
C12 N11 Port2 3.46e-12
L12 N11 Port2 1.08e-10
R12 N11 Port2 3.44e+01
.ENDS GCJ188R91H224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188R91H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H472KA01 Port1 Port2
C01 Port1 N01 4.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.85e-10
R03 N02 N03 7.35e-02
C04 N03 N04 1.38e-07
R04 N03 N04 3.38e+01
C05 N04 N05 1.45e-07
R05 N04 N05 1.03e+01
C06 N05 N06 2.16e-07
R06 N05 N06 1.83e+00
C07 N06 N07 1.30e-07
R07 N06 N07 6.97e-01
C08 N07 N08 8.38e-08
R08 N07 N08 1.50e-01
L09 N08 N09 7.09e-11
R09 N08 N09 4.63e-01
C10 N09 N10 2.95e-08
L10 N09 N10 1.33e-11
R10 N09 N10 8.74e-02
C11 N10 N11 5.39e-09
L11 N10 N11 2.82e-11
R11 N10 N11 1.71e-01
C12 N11 Port2 3.20e-12
L12 N11 Port2 1.16e-10
R12 N11 Port2 3.26e+01
.ENDS GCJ188R91H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ188R92A102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A102KA01 Port1 Port2
C01 Port1 N01 9.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 1.35e-01
C04 N03 N04 1.99e-08
R04 N03 N04 2.53e+02
C05 N04 N05 1.18e-08
R05 N04 N05 2.01e+02
C06 N05 N06 3.01e-08
R06 N05 N06 6.81e+00
C07 N06 N07 3.22e-08
R07 N06 N07 1.54e+00
C08 N07 N08 2.75e-08
R08 N07 N08 4.72e-01
C09 N08 N09 2.18e-08
R09 N08 N09 1.38e-01
L10 N09 N10 8.47e-11
R10 N09 N10 2.10e+00
C11 N10 N11 6.82e-09
L11 N10 N11 8.90e-12
R11 N10 N11 1.45e-01
C12 N11 N12 1.00e-09
L12 N11 N12 2.35e-11
R12 N11 N12 4.23e-01
C13 N12 N13 4.39e-12
L13 N12 N13 1.28e-10
R13 N12 N13 4.09e+01
C14 N13 Port2 2.63e-12
L14 N13 Port2 1.15e-10
R14 N13 Port2 8.08e+01
.ENDS GCJ188R92A102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ188R92A102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A102MA01 Port1 Port2
C01 Port1 N01 9.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 1.35e-01
C04 N03 N04 1.99e-08
R04 N03 N04 2.53e+02
C05 N04 N05 1.18e-08
R05 N04 N05 2.01e+02
C06 N05 N06 3.01e-08
R06 N05 N06 6.81e+00
C07 N06 N07 3.22e-08
R07 N06 N07 1.54e+00
C08 N07 N08 2.75e-08
R08 N07 N08 4.72e-01
C09 N08 N09 2.18e-08
R09 N08 N09 1.38e-01
L10 N09 N10 8.47e-11
R10 N09 N10 2.10e+00
C11 N10 N11 6.82e-09
L11 N10 N11 8.90e-12
R11 N10 N11 1.45e-01
C12 N11 N12 1.00e-09
L12 N11 N12 2.35e-11
R12 N11 N12 4.23e-01
C13 N12 N13 4.39e-12
L13 N12 N13 1.28e-10
R13 N12 N13 4.09e+01
C14 N13 Port2 2.63e-12
L14 N13 Port2 1.15e-10
R14 N13 Port2 8.08e+01
.ENDS GCJ188R92A102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ188R92A103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A103KA01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 9.18e-02
C04 N03 N04 1.95e-07
R04 N03 N04 1.03e+01
C05 N04 N05 2.74e-07
R05 N04 N05 8.64e-01
C06 N05 N06 2.16e-07
R06 N05 N06 1.37e-01
C07 N06 N07 5.06e-07
R07 N06 N07 1.09e-02
L08 N07 N08 9.31e-11
R08 N07 N08 2.40e-01
L09 N08 N09 1.09e-11
R09 N08 N09 1.36e-01
C10 N09 N10 5.49e-08
L10 N09 N10 1.57e-11
R10 N09 N10 7.23e-02
C11 N10 N11 1.54e-08
L11 N10 N11 2.55e-11
R11 N10 N11 1.40e-01
C12 N11 Port2 3.37e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 2.63e+01
.ENDS GCJ188R92A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ188R92A103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A103MA01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 9.18e-02
C04 N03 N04 1.95e-07
R04 N03 N04 1.03e+01
C05 N04 N05 2.74e-07
R05 N04 N05 8.64e-01
C06 N05 N06 2.16e-07
R06 N05 N06 1.37e-01
C07 N06 N07 5.06e-07
R07 N06 N07 1.09e-02
L08 N07 N08 9.31e-11
R08 N07 N08 2.40e-01
L09 N08 N09 1.09e-11
R09 N08 N09 1.36e-01
C10 N09 N10 5.49e-08
L10 N09 N10 1.57e-11
R10 N09 N10 7.23e-02
C11 N10 N11 1.54e-08
L11 N10 N11 2.55e-11
R11 N10 N11 1.40e-01
C12 N11 Port2 3.37e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 2.63e+01
.ENDS GCJ188R92A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCJ188R92A123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A123KA01 Port1 Port2
C01 Port1 N01 1.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 3.60e-02
C04 N03 N04 6.09e-07
R04 N03 N04 1.08e+04
C05 N04 N05 6.20e-07
R05 N04 N05 1.08e+03
C06 N05 N06 5.06e-07
R06 N05 N06 1.24e+02
C07 N06 N07 4.76e-07
R07 N06 N07 1.30e+01
C08 N07 N08 3.47e-07
R08 N07 N08 1.80e+00
C09 N08 N09 2.47e-07
R09 N08 N09 2.25e-01
C10 N09 N10 2.89e-07
R10 N09 N10 1.87e-02
L11 N10 N11 9.30e-11
R11 N10 N11 1.85e-01
L12 N11 N12 1.17e-11
R12 N11 N12 1.24e-01
C13 N12 N13 5.93e-08
L13 N12 N13 1.93e-11
R13 N12 N13 8.40e-02
C14 N13 N14 2.00e-08
L14 N13 N14 2.59e-11
R14 N13 N14 1.21e-01
C15 N14 Port2 2.23e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 4.42e+01
.ENDS GCJ188R92A123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ188R92A152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A152KA01 Port1 Port2
C01 Port1 N01 1.43e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.17e-01
C04 N03 N04 5.77e-08
R04 N03 N04 1.44e+05
C05 N04 N05 1.01e-07
R05 N04 N05 8.11e+03
C06 N05 N06 6.86e-08
R06 N05 N06 1.35e+03
C07 N06 N07 8.72e-08
R07 N06 N07 1.20e+02
C08 N07 N08 8.28e-08
R08 N07 N08 3.15e+01
C09 N08 N09 4.94e-08
R09 N08 N09 8.99e+00
C10 N09 N10 3.20e-08
R10 N09 N10 1.55e+00
C11 N10 N11 2.52e-08
R11 N10 N11 1.83e-01
C12 N11 N12 3.06e-07
R12 N11 N12 4.90e-02
L13 N12 N13 7.30e-11
R13 N12 N13 8.91e-01
C14 N13 N14 2.06e-08
L14 N13 N14 3.88e-12
R14 N13 N14 6.27e-02
C15 N14 N15 1.52e-09
L15 N14 N15 1.85e-11
R15 N14 N15 2.24e-01
C16 N15 N16 4.29e-12
L16 N15 N16 1.47e-10
R16 N15 N16 4.01e+01
C17 N16 Port2 4.51e-12
L17 N16 Port2 6.72e-11
R17 N16 Port2 2.92e+01
.ENDS GCJ188R92A152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ188R92A153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A153KA01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.26e-10
R03 N02 N03 4.37e-02
C04 N03 N04 6.35e-07
R04 N03 N04 1.14e+04
C05 N04 N05 7.42e-07
R05 N04 N05 9.44e+02
C06 N05 N06 6.49e-07
R06 N05 N06 1.06e+02
C07 N06 N07 5.32e-07
R07 N06 N07 1.27e+01
C08 N07 N08 4.09e-07
R08 N07 N08 1.60e+00
C09 N08 N09 2.94e-07
R09 N08 N09 2.07e-01
C10 N09 N10 6.20e-07
R10 N09 N10 1.04e-02
L11 N10 N11 1.75e-11
R11 N10 N11 1.59e-01
L12 N11 N12 6.31e-11
R12 N11 N12 1.50e-01
C13 N12 N13 1.22e-07
L13 N12 N13 9.70e-12
R13 N12 N13 3.58e-02
C14 N13 N14 1.55e-08
L14 N13 N14 3.02e-11
R14 N13 N14 8.52e-02
C15 N14 Port2 2.93e-12
L15 N14 Port2 1.70e-10
R15 N14 Port2 5.13e+01
.ENDS GCJ188R92A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCJ188R92A182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A182KA01 Port1 Port2
C01 Port1 N01 1.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.66e-10
R03 N02 N03 9.91e-02
C04 N03 N04 9.13e-08
R04 N03 N04 4.36e+04
C05 N04 N05 1.29e-07
R05 N04 N05 3.88e+03
C06 N05 N06 1.03e-07
R06 N05 N06 5.24e+02
C07 N06 N07 8.70e-08
R07 N06 N07 7.23e+01
C08 N07 N08 6.44e-08
R08 N07 N08 1.06e+01
C09 N08 N09 5.35e-08
R09 N08 N09 1.49e+00
C10 N09 N10 3.42e-08
R10 N09 N10 2.70e-01
L11 N10 N11 7.17e-11
R11 N10 N11 5.53e-01
C12 N11 N12 1.84e-08
L12 N11 N12 6.23e-12
R12 N11 N12 7.77e-02
C13 N12 N13 2.55e-09
L13 N12 N13 1.69e-11
R13 N12 N13 2.00e-01
C14 N13 Port2 1.98e-12
L14 N13 Port2 2.47e-10
R14 N13 Port2 6.08e+01
.ENDS GCJ188R92A182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCJ188R92A183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A183KA01 Port1 Port2
C01 Port1 N01 1.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 3.60e-02
C04 N03 N04 9.78e-07
R04 N03 N04 4.07e+03
C05 N04 N05 1.19e-06
R05 N04 N05 5.24e+02
C06 N05 N06 8.54e-07
R06 N05 N06 7.93e+01
C07 N06 N07 7.44e-07
R07 N06 N07 9.11e+00
C08 N07 N08 5.34e-07
R08 N07 N08 1.48e+00
C09 N08 N09 4.15e-07
R09 N08 N09 1.91e-01
C10 N09 N10 5.97e-07
R10 N09 N10 1.55e-02
L11 N10 N11 8.53e-11
R11 N10 N11 1.82e-01
C12 N11 N12 7.63e-08
L12 N11 N12 2.04e-11
R12 N11 N12 5.85e-02
C13 N12 N13 3.03e-08
L13 N12 N13 2.14e-11
R13 N12 N13 8.98e-02
C14 N13 Port2 1.33e-12
L14 N13 Port2 2.40e-10
R14 N13 Port2 9.26e+01
.ENDS GCJ188R92A183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ188R92A223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A223KA01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.96e-10
R03 N02 N03 3.56e-02
C04 N03 N04 3.45e-07
R04 N03 N04 2.73e+01
C05 N04 N05 8.24e-07
R05 N04 N05 1.76e+00
C06 N05 N06 5.45e-07
R06 N05 N06 4.28e-01
C07 N06 N07 4.38e-07
R07 N06 N07 5.99e-02
L08 N07 N08 2.54e-11
R08 N07 N08 4.16e-01
L09 N08 N09 8.08e-11
R09 N08 N09 1.60e-01
C10 N09 N10 7.20e-08
L10 N09 N10 2.75e-11
R10 N09 N10 6.39e-02
C11 N10 N11 2.76e-08
L11 N10 N11 2.99e-11
R11 N10 N11 9.67e-02
C12 N11 Port2 9.55e-12
L12 N11 Port2 3.16e-11
R12 N11 Port2 1.36e+01
.ENDS GCJ188R92A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ188R92A223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A223MA01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.96e-10
R03 N02 N03 3.56e-02
C04 N03 N04 3.45e-07
R04 N03 N04 2.73e+01
C05 N04 N05 8.24e-07
R05 N04 N05 1.76e+00
C06 N05 N06 5.45e-07
R06 N05 N06 4.28e-01
C07 N06 N07 4.38e-07
R07 N06 N07 5.99e-02
L08 N07 N08 2.54e-11
R08 N07 N08 4.16e-01
L09 N08 N09 8.08e-11
R09 N08 N09 1.60e-01
C10 N09 N10 7.20e-08
L10 N09 N10 2.75e-11
R10 N09 N10 6.39e-02
C11 N10 N11 2.76e-08
L11 N10 N11 2.99e-11
R11 N10 N11 9.67e-02
C12 N11 Port2 9.55e-12
L12 N11 Port2 3.16e-11
R12 N11 Port2 1.36e+01
.ENDS GCJ188R92A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCJ188R92A272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A272KA01 Port1 Port2
C01 Port1 N01 2.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 6.47e-02
C04 N03 N04 1.34e-07
R04 N03 N04 3.84e+04
C05 N04 N05 1.64e-07
R05 N04 N05 3.35e+03
C06 N05 N06 1.52e-07
R06 N05 N06 3.84e+02
C07 N06 N07 1.24e-07
R07 N06 N07 5.68e+01
C08 N07 N08 8.90e-08
R08 N07 N08 7.18e+00
C09 N08 N09 5.90e-08
R09 N08 N09 8.83e-01
C10 N09 N10 4.94e-08
R10 N09 N10 1.23e-01
L11 N10 N11 9.06e-11
R11 N10 N11 4.27e-01
C12 N11 N12 1.60e-08
L12 N11 N12 1.46e-11
R12 N11 N12 1.46e-01
C13 N12 N13 5.21e-09
L13 N12 N13 1.83e-11
R13 N12 N13 2.12e-01
C14 N13 Port2 1.99e-12
L14 N13 Port2 1.82e-10
R14 N13 Port2 4.13e+01
.ENDS GCJ188R92A272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCJ188R92A273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A273KA01 Port1 Port2
C01 Port1 N01 2.70e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 2.83e-02
C04 N03 N04 1.26e-06
R04 N03 N04 6.34e+03
C05 N04 N05 1.44e-06
R05 N04 N05 5.65e+02
C06 N05 N06 1.26e-06
R06 N05 N06 6.20e+01
C07 N06 N07 1.01e-06
R07 N06 N07 7.80e+00
C08 N07 N08 7.88e-07
R08 N07 N08 9.44e-01
C09 N08 N09 5.41e-07
R09 N08 N09 1.42e-01
C10 N09 N10 7.32e-07
R10 N09 N10 1.47e-02
L11 N10 N11 2.59e-11
R11 N10 N11 2.48e-01
L12 N11 N12 1.08e-10
R12 N11 N12 1.38e-01
C13 N12 N13 9.44e-08
L13 N12 N13 3.06e-11
R13 N12 N13 7.25e-02
C14 N13 N14 3.81e-08
L14 N13 N14 3.33e-11
R14 N13 N14 8.49e-02
C15 N14 Port2 4.46e-12
L15 N14 Port2 7.27e-11
R15 N14 Port2 2.24e+01
.ENDS GCJ188R92A273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCJ188R92A332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A332KA01 Port1 Port2
C01 Port1 N01 3.40e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.88e-10
R03 N02 N03 6.11e-02
C04 N03 N04 1.65e-07
R04 N03 N04 4.13e+04
C05 N04 N05 1.98e-07
R05 N04 N05 4.13e+03
C06 N05 N06 1.62e-07
R06 N05 N06 4.96e+02
C07 N06 N07 1.85e-07
R07 N06 N07 4.63e+01
C08 N07 N08 2.35e-07
R08 N07 N08 1.11e+01
C09 N08 N09 1.18e-07
R09 N08 N09 4.41e+00
C10 N09 N10 7.82e-08
R10 N09 N10 6.69e-01
C11 N10 N11 8.51e-07
R11 N10 N11 2.04e-01
C12 N11 N12 6.35e-08
R12 N11 N12 1.10e-01
L13 N12 N13 3.04e-11
R13 N12 N13 8.44e-01
L14 N13 N14 8.80e-11
R14 N13 N14 4.18e-01
C15 N14 N15 1.61e-08
L15 N14 N15 1.91e-11
R15 N14 N15 1.80e-01
C16 N15 N16 5.79e-09
L16 N15 N16 2.28e-11
R16 N15 N16 2.25e-01
C17 N16 Port2 4.04e-12
L17 N16 Port2 8.35e-11
R17 N16 Port2 3.43e+01
.ENDS GCJ188R92A332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCJ188R92A333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A333KA01 Port1 Port2
C01 Port1 N01 3.17e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 4.45e-02
C04 N03 N04 3.40e-07
R04 N03 N04 2.09e+01
C05 N04 N05 9.59e-07
R05 N04 N05 3.43e-01
C06 N05 N06 5.27e-06
R06 N05 N06 1.45e-01
C07 N06 N07 6.23e-07
R07 N06 N07 6.56e-02
L08 N07 N08 6.79e-11
R08 N07 N08 2.07e-01
C09 N08 N09 5.76e-07
L09 N08 N09 4.29e-12
R09 N08 N09 7.83e-03
C10 N09 N10 1.69e-08
L10 N09 N10 4.80e-11
R10 N09 N10 5.93e-02
C11 N10 N11 5.47e-12
L11 N10 N11 1.23e-10
R11 N10 N11 3.64e+01
C12 N11 Port2 3.13e-12
L12 N11 Port2 1.16e-10
R12 N11 Port2 1.74e+01
.ENDS GCJ188R92A333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCJ188R92A333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A333MA01 Port1 Port2
C01 Port1 N01 3.17e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 4.45e-02
C04 N03 N04 3.40e-07
R04 N03 N04 2.09e+01
C05 N04 N05 9.59e-07
R05 N04 N05 3.43e-01
C06 N05 N06 5.27e-06
R06 N05 N06 1.45e-01
C07 N06 N07 6.23e-07
R07 N06 N07 6.56e-02
L08 N07 N08 6.79e-11
R08 N07 N08 2.07e-01
C09 N08 N09 5.76e-07
L09 N08 N09 4.29e-12
R09 N08 N09 7.83e-03
C10 N09 N10 1.69e-08
L10 N09 N10 4.80e-11
R10 N09 N10 5.93e-02
C11 N10 N11 5.47e-12
L11 N10 N11 1.23e-10
R11 N10 N11 3.64e+01
C12 N11 Port2 3.13e-12
L12 N11 Port2 1.16e-10
R12 N11 Port2 1.74e+01
.ENDS GCJ188R92A333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ188R92A392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A392KA01 Port1 Port2
C01 Port1 N01 4.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 6.97e-02
C04 N03 N04 2.32e-07
R04 N03 N04 2.62e+04
C05 N04 N05 2.59e-07
R05 N04 N05 3.15e+03
C06 N05 N06 2.00e-07
R06 N05 N06 3.70e+02
C07 N06 N07 2.72e-07
R07 N06 N07 3.01e+01
C08 N07 N08 3.08e-07
R08 N07 N08 8.47e+00
C09 N08 N09 1.64e-07
R09 N08 N09 4.33e+00
C10 N09 N10 9.91e-08
R10 N09 N10 7.85e-01
C11 N10 N11 8.15e-08
R11 N10 N11 1.02e-01
L12 N11 N12 2.84e-11
R12 N11 N12 9.04e-01
L13 N12 N13 7.63e-11
R13 N12 N13 3.08e-01
C14 N13 N14 3.86e-08
L14 N13 N14 8.38e-12
R14 N13 N14 7.34e-02
C15 N14 N15 6.09e-09
L15 N14 N15 1.99e-11
R15 N14 N15 1.43e-01
C16 N15 Port2 2.56e-12
L16 N15 Port2 1.71e-10
R16 N15 Port2 3.87e+01
.ENDS GCJ188R92A392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCJ188R92A393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A393KA01 Port1 Port2
C01 Port1 N01 3.80e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.51e-10
R03 N02 N03 3.05e-02
C04 N03 N04 1.98e-06
R04 N03 N04 2.78e+03
C05 N04 N05 2.16e-06
R05 N04 N05 2.54e+02
C06 N05 N06 1.79e-06
R06 N05 N06 3.05e+01
C07 N06 N07 1.45e-06
R07 N06 N07 3.75e+00
C08 N07 N08 1.20e-06
R08 N07 N08 4.50e-01
C09 N08 N09 9.06e-07
R09 N08 N09 6.30e-02
L10 N09 N10 7.75e-11
R10 N09 N10 1.13e-01
L11 N10 N11 1.69e-11
R11 N10 N11 1.12e-01
C12 N11 N12 3.83e-07
L12 N11 N12 8.33e-12
R12 N11 N12 1.76e-02
C13 N12 N13 4.24e-08
L13 N12 N13 2.98e-11
R13 N12 N13 5.04e-02
C14 N13 Port2 3.24e-12
L14 N13 Port2 1.55e-10
R14 N13 Port2 3.84e+01
.ENDS GCJ188R92A393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ188R92A472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A472KA01 Port1 Port2
C01 Port1 N01 4.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.85e-10
R03 N02 N03 7.35e-02
C04 N03 N04 1.38e-07
R04 N03 N04 3.38e+01
C05 N04 N05 1.45e-07
R05 N04 N05 1.03e+01
C06 N05 N06 2.16e-07
R06 N05 N06 1.83e+00
C07 N06 N07 1.30e-07
R07 N06 N07 6.97e-01
C08 N07 N08 8.38e-08
R08 N07 N08 1.50e-01
L09 N08 N09 7.09e-11
R09 N08 N09 4.63e-01
C10 N09 N10 2.95e-08
L10 N09 N10 1.33e-11
R10 N09 N10 8.74e-02
C11 N10 N11 5.39e-09
L11 N10 N11 2.82e-11
R11 N10 N11 1.71e-01
C12 N11 Port2 3.20e-12
L12 N11 Port2 1.16e-10
R12 N11 Port2 3.26e+01
.ENDS GCJ188R92A472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ188R92A472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A472MA01 Port1 Port2
C01 Port1 N01 4.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.85e-10
R03 N02 N03 7.35e-02
C04 N03 N04 1.38e-07
R04 N03 N04 3.38e+01
C05 N04 N05 1.45e-07
R05 N04 N05 1.03e+01
C06 N05 N06 2.16e-07
R06 N05 N06 1.83e+00
C07 N06 N07 1.30e-07
R07 N06 N07 6.97e-01
C08 N07 N08 8.38e-08
R08 N07 N08 1.50e-01
L09 N08 N09 7.09e-11
R09 N08 N09 4.63e-01
C10 N09 N10 2.95e-08
L10 N09 N10 1.33e-11
R10 N09 N10 8.74e-02
C11 N10 N11 5.39e-09
L11 N10 N11 2.82e-11
R11 N10 N11 1.71e-01
C12 N11 Port2 3.20e-12
L12 N11 Port2 1.16e-10
R12 N11 Port2 3.26e+01
.ENDS GCJ188R92A472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCJ188R92A473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A473KA01 Port1 Port2
C01 Port1 N01 4.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-10
R03 N02 N03 3.62e-02
C04 N03 N04 1.00e-06
R04 N03 N04 7.96e+00
C05 N04 N05 1.70e-06
R05 N04 N05 6.73e-01
C06 N05 N06 1.56e-06
R06 N05 N06 1.27e-01
C07 N06 N07 1.19e-06
R07 N06 N07 3.73e-02
L08 N07 N08 1.53e-11
R08 N07 N08 1.33e-01
L09 N08 N09 9.26e-11
R09 N08 N09 1.12e-01
C10 N09 N10 2.65e-07
L10 N09 N10 1.60e-11
R10 N09 N10 2.45e-02
C11 N10 N11 6.04e-08
L11 N10 N11 2.83e-11
R11 N10 N11 4.87e-02
C12 N11 N12 3.04e-12
L12 N11 N12 1.60e-10
R12 N11 N12 4.15e+01
C13 N12 Port2 9.38e-12
L13 N12 Port2 2.46e-11
R13 N12 Port2 4.97e+00
.ENDS GCJ188R92A473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCJ188R92A473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A473MA01 Port1 Port2
C01 Port1 N01 4.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-10
R03 N02 N03 3.62e-02
C04 N03 N04 1.00e-06
R04 N03 N04 7.96e+00
C05 N04 N05 1.70e-06
R05 N04 N05 6.73e-01
C06 N05 N06 1.56e-06
R06 N05 N06 1.27e-01
C07 N06 N07 1.19e-06
R07 N06 N07 3.73e-02
L08 N07 N08 1.53e-11
R08 N07 N08 1.33e-01
L09 N08 N09 9.26e-11
R09 N08 N09 1.12e-01
C10 N09 N10 2.65e-07
L10 N09 N10 1.60e-11
R10 N09 N10 2.45e-02
C11 N10 N11 6.04e-08
L11 N10 N11 2.83e-11
R11 N10 N11 4.87e-02
C12 N11 N12 3.04e-12
L12 N11 N12 1.60e-10
R12 N11 N12 4.15e+01
C13 N12 Port2 9.38e-12
L13 N12 Port2 2.46e-11
R13 N12 Port2 4.97e+00
.ENDS GCJ188R92A473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCJ188R92A562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A562KA01 Port1 Port2
C01 Port1 N01 5.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 5.91e-02
C04 N03 N04 3.48e-07
R04 N03 N04 9.42e+03
C05 N04 N05 3.95e-07
R05 N04 N05 1.36e+03
C06 N05 N06 3.08e-07
R06 N05 N06 1.75e+02
C07 N06 N07 2.61e-07
R07 N06 N07 2.60e+01
C08 N07 N08 1.99e-07
R08 N07 N08 3.97e+00
C09 N08 N09 1.36e-07
R09 N08 N09 6.04e-01
C10 N09 N10 1.23e-07
R10 N09 N10 6.99e-02
L11 N10 N11 7.62e-11
R11 N10 N11 3.57e-01
C12 N11 N12 2.88e-08
L12 N11 N12 1.59e-11
R12 N11 N12 1.01e-01
C13 N12 N13 5.31e-09
L13 N12 N13 3.49e-11
R13 N12 N13 1.59e-01
C14 N13 Port2 2.15e-12
L14 N13 Port2 1.60e-10
R14 N13 Port2 5.48e+01
.ENDS GCJ188R92A562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ188R92A682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A682KA01 Port1 Port2
C01 Port1 N01 6.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.34e-11
R03 N02 N03 4.42e-02
C04 N03 N04 2.78e-07
R04 N03 N04 2.69e+04
C05 N04 N05 4.13e-07
R05 N04 N05 1.62e+03
C06 N05 N06 3.16e-07
R06 N05 N06 2.40e+02
C07 N06 N07 2.66e-07
R07 N06 N07 2.69e+01
C08 N07 N08 2.15e-07
R08 N07 N08 3.18e+00
C09 N08 N09 1.47e-07
R09 N08 N09 4.76e-01
C10 N09 N10 1.13e-07
R10 N09 N10 6.19e-02
L11 N10 N11 3.60e-11
R11 N10 N11 6.76e-01
L12 N11 N12 8.72e-11
R12 N11 N12 2.75e-01
C13 N12 N13 2.75e-08
L13 N12 N13 2.27e-11
R13 N12 N13 1.41e-01
C14 N13 N14 9.87e-09
L14 N13 N14 2.76e-11
R14 N13 N14 1.54e-01
C15 N14 Port2 1.47e-12
L15 N14 Port2 1.91e-10
R15 N14 Port2 1.25e+02
.ENDS GCJ188R92A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCJ188R92A683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A683KA01 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.79e-10
R03 N02 N03 4.22e-02
C04 N03 N04 3.46e-06
R04 N03 N04 2.08e+03
C05 N04 N05 4.11e-06
R05 N04 N05 1.99e+02
C06 N05 N06 3.24e-06
R06 N05 N06 2.50e+01
C07 N06 N07 2.88e-06
R07 N06 N07 2.87e+00
C08 N07 N08 1.96e-06
R08 N07 N08 4.95e-01
C09 N08 N09 1.23e-06
R09 N08 N09 6.12e-02
L10 N09 N10 2.18e-11
R10 N09 N10 1.48e-01
L11 N10 N11 1.17e-10
R11 N10 N11 1.00e-01
C12 N11 N12 3.12e-07
L12 N11 N12 2.32e-11
R12 N11 N12 2.59e-02
C13 N12 N13 1.05e-07
L13 N12 N13 3.05e-11
R13 N12 N13 4.27e-02
C14 N13 Port2 2.91e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 3.41e+01
.ENDS GCJ188R92A683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GCJ216R71E102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R71E102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GCJ216R71E102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R71E102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCJ216R71E103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E103KA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R71E103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCJ216R71E103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E103MA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R71E103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/25[V]
* Murata P/N :GCJ216R71E222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E222KA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R71E222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/25[V]
* Murata P/N :GCJ216R71E222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E222MA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R71E222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/25[V]
* Murata P/N :GCJ216R71E332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E332KA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R71E332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/25[V]
* Murata P/N :GCJ216R71E332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E332MA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R71E332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GCJ216R71E471KA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E471KA01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GCJ216R71E471KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GCJ216R71E471MA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E471MA01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GCJ216R71E471MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GCJ216R71E472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E472KA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R71E472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GCJ216R71E472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E472MA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R71E472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GCJ216R71E561KA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E561KA01 Port1 Port2
C01 Port1 N01 5.61e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-11
R03 N02 N03 3.24e-01
C04 N03 N04 7.64e-09
R04 N03 N04 1.88e+02
C05 N04 N05 3.65e-08
R05 N04 N05 2.72e+00
C06 N05 N06 1.86e-08
R06 N05 N06 7.03e-01
C07 N06 N07 3.51e-09
R07 N06 N07 4.10e-01
C08 N07 N08 1.25e-09
L08 N07 N08 1.94e-11
R08 N07 N08 1.93e-01
C09 N08 N09 4.18e-10
L09 N08 N09 2.10e-11
R09 N08 N09 3.83e-01
C10 N09 N10 1.24e-11
L10 N09 N10 6.38e-11
R10 N09 N10 6.44e+00
C11 N10 Port2 6.04e-13
L11 N10 Port2 3.05e-10
R11 N10 Port2 2.95e+01
.ENDS GCJ216R71E561KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GCJ216R71E561MA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E561MA01 Port1 Port2
C01 Port1 N01 5.61e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-11
R03 N02 N03 3.24e-01
C04 N03 N04 7.64e-09
R04 N03 N04 1.88e+02
C05 N04 N05 3.65e-08
R05 N04 N05 2.72e+00
C06 N05 N06 1.86e-08
R06 N05 N06 7.03e-01
C07 N06 N07 3.51e-09
R07 N06 N07 4.10e-01
C08 N07 N08 1.25e-09
L08 N07 N08 1.94e-11
R08 N07 N08 1.93e-01
C09 N08 N09 4.18e-10
L09 N08 N09 2.10e-11
R09 N08 N09 3.83e-01
C10 N09 N10 1.24e-11
L10 N09 N10 6.38e-11
R10 N09 N10 6.44e+00
C11 N10 Port2 6.04e-13
L11 N10 Port2 3.05e-10
R11 N10 Port2 2.95e+01
.ENDS GCJ216R71E561MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GCJ216R71E682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E682KA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R71E682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GCJ216R71E682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E682MA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R71E682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GCJ216R71E821KA01
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E821KA01 Port1 Port2
C01 Port1 N01 8.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 6.95e-01
C04 N03 N04 1.58e-07
R04 N03 N04 1.39e+04
C05 N04 N05 1.41e-07
R05 N04 N05 5.54e+03
C06 N05 N06 1.49e-07
R06 N05 N06 7.65e+02
C07 N06 N07 1.38e-07
R07 N06 N07 1.11e+02
C08 N07 N08 1.16e-07
R08 N07 N08 1.92e+01
C09 N08 N09 7.18e-08
R09 N08 N09 4.19e+00
C10 N09 N10 3.54e-08
R10 N09 N10 9.98e-01
C11 N10 N11 6.83e-09
R11 N10 N11 3.77e-01
L12 N11 N12 1.09e-10
R12 N11 N12 1.10e+00
C13 N12 N13 3.71e-09
L13 N12 N13 1.35e-11
R13 N12 N13 1.80e-01
C14 N13 N14 8.87e-10
L14 N13 N14 1.96e-11
R14 N13 N14 2.83e-01
C15 N14 Port2 3.52e-12
L15 N14 Port2 1.04e-10
R15 N14 Port2 1.52e+01
.ENDS GCJ216R71E821KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ216R71H102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R71H102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ216R71H102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R71H102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ216R71H103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H103KA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R71H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCJ216R71H103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H103MA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R71H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ216R71H153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H153KA01 Port1 Port2
C01 Port1 N01 1.53e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.58e-01
C04 N03 N04 5.93e-07
R04 N03 N04 1.69e+01
C05 N04 N05 1.49e-06
R05 N04 N05 1.07e+00
C06 N05 N06 1.08e-06
R06 N05 N06 2.04e-01
C07 N06 N07 1.13e-06
R07 N06 N07 5.04e-02
L08 N07 N08 4.79e-11
R08 N07 N08 1.93e-01
C09 N08 N09 1.44e-07
L09 N08 N09 5.74e-12
R09 N08 N09 1.01e-02
C10 N09 N10 3.34e-09
L10 N09 N10 6.88e-11
R10 N09 N10 1.75e-01
C11 N10 N11 5.38e-11
L11 N10 N11 1.44e-10
R11 N10 N11 1.79e+00
C12 N11 Port2 1.37e-12
L12 N11 Port2 1.81e-10
R12 N11 Port2 2.52e+01
.ENDS GCJ216R71H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ216R71H153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H153MA01 Port1 Port2
C01 Port1 N01 1.53e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.58e-01
C04 N03 N04 5.93e-07
R04 N03 N04 1.69e+01
C05 N04 N05 1.49e-06
R05 N04 N05 1.07e+00
C06 N05 N06 1.08e-06
R06 N05 N06 2.04e-01
C07 N06 N07 1.13e-06
R07 N06 N07 5.04e-02
L08 N07 N08 4.79e-11
R08 N07 N08 1.93e-01
C09 N08 N09 1.44e-07
L09 N08 N09 5.74e-12
R09 N08 N09 1.01e-02
C10 N09 N10 3.34e-09
L10 N09 N10 6.88e-11
R10 N09 N10 1.75e-01
C11 N10 N11 5.38e-11
L11 N10 N11 1.44e-10
R11 N10 N11 1.79e+00
C12 N11 Port2 1.37e-12
L12 N11 Port2 1.81e-10
R12 N11 Port2 2.52e+01
.ENDS GCJ216R71H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ216R71H222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H222KA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R71H222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ216R71H222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H222MA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R71H222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ216R71H223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H223KA01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GCJ216R71H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCJ216R71H223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H223MA01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GCJ216R71H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GCJ216R71H331KA01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H331KA01 Port1 Port2
C01 Port1 N01 3.29e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.03e-11
R03 N02 N03 1.33e+00
C04 N03 N04 2.42e-08
R04 N03 N04 6.57e+01
C05 N04 N05 9.91e-09
R05 N04 N05 3.82e+01
C06 N05 N06 1.66e-08
R06 N05 N06 3.06e+00
C07 N06 N07 6.16e-09
R07 N06 N07 6.58e-01
C08 N07 N08 2.77e-09
R08 N07 N08 4.10e-01
C09 N08 N09 4.86e-10
L09 N08 N09 1.19e-11
R09 N08 N09 3.63e-01
C10 N09 N10 7.93e-12
L10 N09 N10 1.09e-10
R10 N09 N10 8.58e+00
C11 N10 N11 8.53e-12
L11 N10 N11 6.22e-11
R11 N10 N11 9.65e+00
C12 N11 Port2 1.33e-12
L12 N11 Port2 1.96e-10
R12 N11 Port2 2.70e+01
.ENDS GCJ216R71H331KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GCJ216R71H331MA01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H331MA01 Port1 Port2
C01 Port1 N01 3.29e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.03e-11
R03 N02 N03 1.33e+00
C04 N03 N04 2.42e-08
R04 N03 N04 6.57e+01
C05 N04 N05 9.91e-09
R05 N04 N05 3.82e+01
C06 N05 N06 1.66e-08
R06 N05 N06 3.06e+00
C07 N06 N07 6.16e-09
R07 N06 N07 6.58e-01
C08 N07 N08 2.77e-09
R08 N07 N08 4.10e-01
C09 N08 N09 4.86e-10
L09 N08 N09 1.19e-11
R09 N08 N09 3.63e-01
C10 N09 N10 7.93e-12
L10 N09 N10 1.09e-10
R10 N09 N10 8.58e+00
C11 N10 N11 8.53e-12
L11 N10 N11 6.22e-11
R11 N10 N11 9.65e+00
C12 N11 Port2 1.33e-12
L12 N11 Port2 1.96e-10
R12 N11 Port2 2.70e+01
.ENDS GCJ216R71H331MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCJ216R71H332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H332KA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R71H332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCJ216R71H332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H332MA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R71H332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GCJ216R71H471KA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H471KA01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GCJ216R71H471KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GCJ216R71H471MA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H471MA01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 1.17e-08
R04 N03 N04 4.16e+01
C05 N04 N05 4.22e-08
R05 N04 N05 2.44e+00
C06 N05 N06 1.74e-08
R06 N05 N06 8.20e-01
C07 N06 N07 6.93e-09
R07 N06 N07 3.91e-01
C08 N07 N08 3.86e-09
R08 N07 N08 1.34e-01
L09 N08 N09 1.37e-10
R09 N08 N09 5.12e+00
C10 N09 N10 1.56e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.75e-01
C11 N10 N11 6.67e-10
L11 N10 N11 1.08e-11
R11 N10 N11 2.42e-01
C12 N11 N12 5.13e-12
L12 N11 N12 1.46e-10
R12 N11 N12 1.32e+01
C13 N12 Port2 4.14e-12
L13 N12 Port2 6.59e-11
R13 N12 Port2 2.14e+01
.ENDS GCJ216R71H471MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ216R71H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H472KA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R71H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ216R71H472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H472MA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R71H472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GCJ216R71H561KA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H561KA01 Port1 Port2
C01 Port1 N01 5.61e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-11
R03 N02 N03 3.24e-01
C04 N03 N04 7.64e-09
R04 N03 N04 1.88e+02
C05 N04 N05 3.65e-08
R05 N04 N05 2.72e+00
C06 N05 N06 1.86e-08
R06 N05 N06 7.03e-01
C07 N06 N07 3.51e-09
R07 N06 N07 4.10e-01
C08 N07 N08 1.25e-09
L08 N07 N08 1.94e-11
R08 N07 N08 1.93e-01
C09 N08 N09 4.18e-10
L09 N08 N09 2.10e-11
R09 N08 N09 3.83e-01
C10 N09 N10 1.24e-11
L10 N09 N10 6.38e-11
R10 N09 N10 6.44e+00
C11 N10 Port2 6.04e-13
L11 N10 Port2 3.05e-10
R11 N10 Port2 2.95e+01
.ENDS GCJ216R71H561KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GCJ216R71H561MA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H561MA01 Port1 Port2
C01 Port1 N01 5.61e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-11
R03 N02 N03 3.24e-01
C04 N03 N04 7.64e-09
R04 N03 N04 1.88e+02
C05 N04 N05 3.65e-08
R05 N04 N05 2.72e+00
C06 N05 N06 1.86e-08
R06 N05 N06 7.03e-01
C07 N06 N07 3.51e-09
R07 N06 N07 4.10e-01
C08 N07 N08 1.25e-09
L08 N07 N08 1.94e-11
R08 N07 N08 1.93e-01
C09 N08 N09 4.18e-10
L09 N08 N09 2.10e-11
R09 N08 N09 3.83e-01
C10 N09 N10 1.24e-11
L10 N09 N10 6.38e-11
R10 N09 N10 6.44e+00
C11 N10 Port2 6.04e-13
L11 N10 Port2 3.05e-10
R11 N10 Port2 2.95e+01
.ENDS GCJ216R71H561MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCJ216R71H682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H682KA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R71H682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCJ216R71H682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H682MA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R71H682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GCJ216R71H821KA01
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H821KA01 Port1 Port2
C01 Port1 N01 8.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 6.95e-01
C04 N03 N04 1.58e-07
R04 N03 N04 1.39e+04
C05 N04 N05 1.41e-07
R05 N04 N05 5.54e+03
C06 N05 N06 1.49e-07
R06 N05 N06 7.65e+02
C07 N06 N07 1.38e-07
R07 N06 N07 1.11e+02
C08 N07 N08 1.16e-07
R08 N07 N08 1.92e+01
C09 N08 N09 7.18e-08
R09 N08 N09 4.19e+00
C10 N09 N10 3.54e-08
R10 N09 N10 9.98e-01
C11 N10 N11 6.83e-09
R11 N10 N11 3.77e-01
L12 N11 N12 1.09e-10
R12 N11 N12 1.10e+00
C13 N12 N13 3.71e-09
L13 N12 N13 1.35e-11
R13 N12 N13 1.80e-01
C14 N13 N14 8.87e-10
L14 N13 N14 1.96e-11
R14 N13 N14 2.83e-01
C15 N14 Port2 3.52e-12
L15 N14 Port2 1.04e-10
R15 N14 Port2 1.52e+01
.ENDS GCJ216R71H821KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ216R72A102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R72A102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ216R72A102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A102MA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.19e-08
R04 N03 N04 2.12e+02
C05 N04 N05 3.62e-07
R05 N04 N05 9.33e+00
C06 N05 N06 6.91e-08
R06 N05 N06 1.73e+00
C07 N06 N07 6.10e-08
R07 N06 N07 3.72e-01
C08 N07 N08 1.21e-08
R08 N07 N08 2.84e-01
C09 N08 N09 4.85e-10
L09 N08 N09 3.18e-11
R09 N08 N09 3.70e-01
C10 N09 N10 3.71e-11
L10 N09 N10 1.01e-10
R10 N09 N10 2.56e+00
C11 N10 Port2 1.69e-12
L11 N10 Port2 3.39e-10
R11 N10 Port2 2.39e+01
.ENDS GCJ216R72A102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ216R72A103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A103KA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ216R72A103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A103MA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 3.40e-07
R04 N03 N04 1.10e+01
C05 N04 N05 7.22e-07
R05 N04 N05 3.68e-01
C06 N05 N06 6.92e-07
R06 N05 N06 9.05e-02
L07 N06 N07 5.99e-11
R07 N06 N07 2.35e-01
C08 N07 N08 5.31e-09
L08 N07 N08 5.39e-11
R08 N07 N08 1.32e-01
C09 N08 N09 5.90e-11
L09 N08 N09 1.19e-10
R09 N08 N09 1.70e+00
C10 N09 N10 4.91e-12
L10 N09 N10 1.20e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 9.23e-13
L11 N10 Port2 2.44e-10
R11 N10 Port2 3.17e+01
.ENDS GCJ216R72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCJ216R72A122KA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A122KA01 Port1 Port2
C01 Port1 N01 1.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 1.08e+00
C04 N03 N04 1.06e-07
R04 N03 N04 1.43e+04
C05 N04 N05 3.27e-07
R05 N04 N05 5.82e+02
C06 N05 N06 3.13e-07
R06 N05 N06 1.60e+02
C07 N06 N07 2.10e-07
R07 N06 N07 4.03e+01
C08 N07 N08 3.60e-07
R08 N07 N08 4.96e+00
C09 N08 N09 1.46e-07
R09 N08 N09 3.74e+00
C10 N09 N10 9.67e-08
R10 N09 N10 8.82e-01
C11 N10 N11 1.97e-08
R11 N10 N11 3.09e-01
C12 N11 N12 2.60e-09
L12 N11 N12 1.44e-11
R12 N11 N12 6.96e-02
C13 N12 N13 1.02e-09
L13 N12 N13 2.52e-11
R13 N12 N13 2.33e-01
C14 N13 N14 5.00e-11
L14 N13 N14 7.55e-11
R14 N13 N14 1.88e+00
C15 N14 Port2 1.90e-12
L15 N14 Port2 2.76e-10
R15 N14 Port2 1.94e+01
.ENDS GCJ216R72A122KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCJ216R72A123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A123KA01 Port1 Port2
C01 Port1 N01 1.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 6.35e-02
C04 N03 N04 1.51e-06
R04 N03 N04 2.39e+03
C05 N04 N05 2.46e-06
R05 N04 N05 1.47e+02
C06 N05 N06 2.17e-06
R06 N05 N06 2.62e+01
C07 N06 N07 1.71e-06
R07 N06 N07 3.79e+00
C08 N07 N08 1.42e-06
R08 N07 N08 5.51e-01
C09 N08 N09 6.57e-07
R09 N08 N09 1.20e-01
L10 N09 N10 8.75e-11
R10 N09 N10 3.57e-01
C11 N10 N11 7.55e-08
L11 N10 N11 1.68e-11
R11 N10 N11 2.61e-02
C12 N11 N12 9.41e-09
L12 N11 N12 4.42e-11
R12 N11 N12 1.14e-01
C13 N12 N13 6.63e-11
L13 N12 N13 9.53e-11
R13 N12 N13 1.15e+00
C14 N13 N14 5.55e-12
L14 N13 N14 1.26e-10
R14 N13 N14 1.34e+01
C15 N14 Port2 4.02e-12
L15 N14 Port2 8.41e-11
R15 N14 Port2 1.81e+01
.ENDS GCJ216R72A123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ216R72A152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.09e-01
C04 N03 N04 1.37e-07
R04 N03 N04 2.24e+04
C05 N04 N05 2.47e-07
R05 N04 N05 1.82e+03
C06 N05 N06 2.33e-07
R06 N05 N06 1.99e+02
C07 N06 N07 1.86e-07
R07 N06 N07 2.51e+01
C08 N07 N08 1.31e-07
R08 N07 N08 3.30e+00
C09 N08 N09 8.04e-08
R09 N08 N09 5.37e-01
C10 N09 N10 3.03e-08
R10 N09 N10 2.14e-01
C11 N10 N11 5.84e-08
L11 N10 N11 2.31e-12
R11 N10 N11 1.36e-02
C12 N11 N12 9.17e-10
L12 N11 N12 3.32e-11
R12 N11 N12 2.54e-01
C13 N12 N13 4.32e-11
L13 N12 N13 8.43e-11
R13 N12 N13 1.56e+00
C14 N13 Port2 1.97e-12
L14 N13 Port2 2.32e-10
R14 N13 Port2 1.57e+01
.ENDS GCJ216R72A152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ216R72A153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A153KA01 Port1 Port2
C01 Port1 N01 1.53e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.58e-01
C04 N03 N04 5.93e-07
R04 N03 N04 1.69e+01
C05 N04 N05 1.49e-06
R05 N04 N05 1.07e+00
C06 N05 N06 1.08e-06
R06 N05 N06 2.04e-01
C07 N06 N07 1.13e-06
R07 N06 N07 5.04e-02
L08 N07 N08 4.79e-11
R08 N07 N08 1.93e-01
C09 N08 N09 1.44e-07
L09 N08 N09 5.74e-12
R09 N08 N09 1.01e-02
C10 N09 N10 3.34e-09
L10 N09 N10 6.88e-11
R10 N09 N10 1.75e-01
C11 N10 N11 5.38e-11
L11 N10 N11 1.44e-10
R11 N10 N11 1.79e+00
C12 N11 Port2 1.37e-12
L12 N11 Port2 1.81e-10
R12 N11 Port2 2.52e+01
.ENDS GCJ216R72A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ216R72A153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A153MA01 Port1 Port2
C01 Port1 N01 1.53e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.58e-01
C04 N03 N04 5.93e-07
R04 N03 N04 1.69e+01
C05 N04 N05 1.49e-06
R05 N04 N05 1.07e+00
C06 N05 N06 1.08e-06
R06 N05 N06 2.04e-01
C07 N06 N07 1.13e-06
R07 N06 N07 5.04e-02
L08 N07 N08 4.79e-11
R08 N07 N08 1.93e-01
C09 N08 N09 1.44e-07
L09 N08 N09 5.74e-12
R09 N08 N09 1.01e-02
C10 N09 N10 3.34e-09
L10 N09 N10 6.88e-11
R10 N09 N10 1.75e-01
C11 N10 N11 5.38e-11
L11 N10 N11 1.44e-10
R11 N10 N11 1.79e+00
C12 N11 Port2 1.37e-12
L12 N11 Port2 1.81e-10
R12 N11 Port2 2.52e+01
.ENDS GCJ216R72A153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCJ216R72A182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A182KA01 Port1 Port2
C01 Port1 N01 1.83e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 2.38e-01
C04 N03 N04 1.45e-07
R04 N03 N04 2.04e+04
C05 N04 N05 4.35e-07
R05 N04 N05 7.92e+02
C06 N05 N06 3.84e-07
R06 N05 N06 2.04e+02
C07 N06 N07 4.17e-07
R07 N06 N07 4.25e+01
C08 N07 N08 2.71e-07
R08 N07 N08 1.28e+01
C09 N08 N09 2.34e-07
R09 N08 N09 2.91e+00
C10 N09 N10 1.45e-07
R10 N09 N10 7.93e-01
C11 N10 N11 1.11e-07
R11 N10 N11 2.18e-01
C12 N11 N12 2.88e-08
R12 N11 N12 1.22e-01
C13 N12 N13 1.52e-09
L13 N12 N13 1.64e-11
R13 N12 N13 1.93e-01
C14 N13 N14 2.76e-11
L14 N13 N14 1.50e-10
R14 N13 N14 2.66e+00
C15 N14 Port2 2.19e-12
L15 N14 Port2 2.26e-10
R15 N14 Port2 1.84e+01
.ENDS GCJ216R72A182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCJ216R72A183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A183KA01 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 4.61e-02
C04 N03 N04 2.52e-06
R04 N03 N04 1.36e+03
C05 N04 N05 3.59e-06
R05 N04 N05 1.03e+02
C06 N05 N06 3.08e-06
R06 N05 N06 1.68e+01
C07 N06 N07 2.69e-06
R07 N06 N07 2.02e+00
C08 N07 N08 1.89e-06
R08 N07 N08 3.34e-01
C09 N08 N09 9.78e-07
R09 N08 N09 6.49e-02
L10 N09 N10 2.96e-11
R10 N09 N10 7.06e-02
C11 N10 N11 7.40e-08
L11 N10 N11 1.66e-11
R11 N10 N11 2.81e-02
C12 N11 N12 9.68e-09
L12 N11 N12 3.88e-11
R12 N11 N12 9.67e-02
C13 N12 N13 6.03e-11
L13 N12 N13 1.32e-10
R13 N12 N13 1.38e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.63e-10
R14 N13 Port2 1.96e+01
.ENDS GCJ216R72A183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ216R72A222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A222KA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R72A222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ216R72A222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A222MA01 Port1 Port2
C01 Port1 N01 2.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.61e-08
R04 N03 N04 2.19e+02
C05 N04 N05 1.53e-07
R05 N04 N05 1.74e+00
C06 N05 N06 1.39e-07
R06 N05 N06 2.81e-01
C07 N06 N07 4.63e-08
R07 N06 N07 1.18e-01
C08 N07 N08 6.11e-07
R08 N07 N08 3.96e-02
C09 N08 N09 1.24e-08
L09 N08 N09 1.03e-11
R09 N08 N09 5.34e-02
C10 N09 N10 7.70e-10
L10 N09 N10 5.00e-11
R10 N09 N10 3.40e-01
C11 N10 N11 3.11e-11
L11 N10 N11 1.06e-10
R11 N10 N11 1.72e+00
C12 N11 Port2 2.29e-12
L12 N11 Port2 2.04e-10
R12 N11 Port2 2.44e+01
.ENDS GCJ216R72A222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ216R72A223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A223KA01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GCJ216R72A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ216R72A223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A223MA01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.13e-06
R04 N03 N04 2.72e+00
C05 N04 N05 1.74e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.60e-06
R06 N05 N06 4.45e-02
L07 N06 N07 9.02e-11
R07 N06 N07 1.44e-01
C08 N07 N08 1.22e-07
L08 N07 N08 1.34e-11
R08 N07 N08 2.67e-02
C09 N08 N09 1.16e-08
L09 N08 N09 4.01e-11
R09 N08 N09 7.33e-02
C10 N09 N10 8.46e-11
L10 N09 N10 8.19e-11
R10 N09 N10 1.03e+00
C11 N10 Port2 2.55e-12
L11 N10 Port2 1.55e-10
R11 N10 Port2 1.70e+01
.ENDS GCJ216R72A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCJ216R72A272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A272KA01 Port1 Port2
C01 Port1 N01 2.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.75e-11
R03 N02 N03 6.11e-01
C04 N03 N04 3.11e-07
R04 N03 N04 8.84e+03
C05 N04 N05 5.07e-07
R05 N04 N05 7.88e+02
C06 N05 N06 5.23e-07
R06 N05 N06 1.11e+02
C07 N06 N07 7.11e-07
R07 N06 N07 1.72e+01
C08 N07 N08 4.01e-07
R08 N07 N08 5.98e+00
C09 N08 N09 4.37e-07
R09 N08 N09 1.34e+00
C10 N09 N10 1.87e-07
R10 N09 N10 6.13e-01
C11 N10 N11 7.62e-08
R11 N10 N11 2.29e-01
L12 N11 N12 4.40e-11
R12 N11 N12 2.74e-01
C13 N12 N13 1.67e-08
L13 N12 N13 1.03e-11
R13 N12 N13 4.74e-02
C14 N13 N14 1.68e-09
L14 N13 N14 3.58e-11
R14 N13 N14 2.14e-01
C15 N14 N15 1.15e-10
L15 N14 N15 3.51e-11
R15 N14 N15 7.48e-01
C16 N15 Port2 1.32e-12
L16 N15 Port2 2.36e-10
R16 N15 Port2 2.74e+01
.ENDS GCJ216R72A272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCJ216R72A332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A332KA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R72A332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCJ216R72A332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A332MA01 Port1 Port2
C01 Port1 N01 3.44e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.54e-07
R04 N03 N04 3.34e+01
C05 N04 N05 2.23e-07
R05 N04 N05 7.65e+00
C06 N05 N06 2.73e-07
R06 N05 N06 7.72e-01
C07 N06 N07 2.73e-07
R07 N06 N07 1.60e-01
C08 N07 N08 8.58e-08
R08 N07 N08 9.13e-02
C09 N08 N09 2.43e-08
L09 N08 N09 8.62e-12
R09 N08 N09 6.82e-02
C10 N09 N10 1.46e-09
L10 N09 N10 4.29e-11
R10 N09 N10 2.46e-01
C11 N10 N11 4.11e-11
L11 N10 N11 1.08e-10
R11 N10 N11 1.44e+00
C12 N11 N12 8.19e-12
L12 N11 N12 5.65e-11
R12 N11 N12 9.00e+00
C13 N12 Port2 1.88e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 3.56e+01
.ENDS GCJ216R72A332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ216R72A392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A392KA01 Port1 Port2
C01 Port1 N01 4.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.55e-11
R03 N02 N03 3.83e-01
C04 N03 N04 4.85e-07
R04 N03 N04 8.21e+03
C05 N04 N05 6.60e-07
R05 N04 N05 6.52e+02
C06 N05 N06 5.89e-07
R06 N05 N06 9.86e+01
C07 N06 N07 5.35e-07
R07 N06 N07 9.64e+00
C08 N07 N08 5.82e-07
R08 N07 N08 1.69e+00
C09 N08 N09 3.18e-07
R09 N08 N09 4.85e-01
C10 N09 N10 1.21e-07
R10 N09 N10 1.11e-01
L11 N10 N11 1.13e-10
R11 N10 N11 5.78e-01
C12 N11 N12 4.80e-08
L12 N11 N12 5.57e-12
R12 N11 N12 4.40e-02
C13 N12 N13 7.35e-09
L13 N12 N13 1.25e-11
R13 N12 N13 1.11e-01
C14 N13 N14 4.19e-10
L14 N13 N14 1.07e-11
R14 N13 N14 3.42e-01
C15 N14 Port2 9.32e-13
L15 N14 Port2 2.61e-10
R15 N14 Port2 3.30e+01
.ENDS GCJ216R72A392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ216R72A472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A472KA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R72A472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ216R72A472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A472MA01 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.36e-07
R04 N03 N04 2.85e+01
C05 N04 N05 3.90e-07
R05 N04 N05 9.78e-01
C06 N05 N06 1.92e-07
R06 N05 N06 2.49e-01
L07 N06 N07 1.02e-10
R07 N06 N07 8.46e-01
C08 N07 N08 2.36e-08
L08 N07 N08 1.15e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.87e-09
L09 N08 N09 3.24e-11
R09 N08 N09 1.68e-01
C10 N09 N10 1.34e-10
L10 N09 N10 3.31e-11
R10 N09 N10 4.50e-01
C11 N10 Port2 2.93e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.93e+01
.ENDS GCJ216R72A472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCJ216R72A562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A562KA01 Port1 Port2
C01 Port1 N01 5.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.70e-01
C04 N03 N04 6.72e-07
R04 N03 N04 1.04e+04
C05 N04 N05 8.90e-07
R05 N04 N05 6.11e+02
C06 N05 N06 8.53e-07
R06 N05 N06 5.97e+01
C07 N06 N07 7.22e-07
R07 N06 N07 6.40e+00
C08 N07 N08 5.43e-07
R08 N07 N08 8.62e-01
C09 N08 N09 2.01e-07
R09 N08 N09 2.22e-01
C10 N09 N10 1.69e-08
L10 N09 N10 2.38e-11
R10 N09 N10 8.03e-02
C11 N10 N11 3.46e-09
L11 N10 N11 3.77e-11
R11 N10 N11 1.74e-01
C12 N11 N12 5.33e-11
L12 N11 N12 8.47e-11
R12 N11 N12 1.02e+00
C13 N12 Port2 1.65e-12
L13 N12 Port2 1.87e-10
R13 N12 Port2 2.45e+01
.ENDS GCJ216R72A562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ216R72A682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A682KA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R72A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ216R72A682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A682MA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 3.26e-07
R04 N03 N04 2.98e+01
C05 N04 N05 4.24e-07
R05 N04 N05 3.84e+00
C06 N05 N06 5.63e-07
R06 N05 N06 3.35e-01
C07 N06 N07 3.44e-07
R07 N06 N07 1.21e-01
C08 N07 N08 2.61e-09
L08 N07 N08 5.29e-11
R08 N07 N08 1.61e-01
C09 N08 N09 2.77e-11
L09 N08 N09 2.43e-10
R09 N08 N09 3.16e+00
C10 N09 N10 1.17e-10
L10 N09 N10 7.56e-12
R10 N09 N10 1.39e+00
C11 N10 N11 4.77e-12
L11 N10 N11 1.14e-10
R11 N10 N11 1.39e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 1.43e-10
R12 N11 Port2 2.28e+01
.ENDS GCJ216R72A682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCJ216R72A822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A822KA01 Port1 Port2
C01 Port1 N01 8.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 3.51e-01
C04 N03 N04 7.18e-07
R04 N03 N04 5.03e+03
C05 N04 N05 1.67e-06
R05 N04 N05 4.00e+02
C06 N05 N06 1.23e-06
R06 N05 N06 5.03e+01
C07 N06 N07 1.06e-06
R07 N06 N07 6.63e+00
C08 N07 N08 7.42e-07
R08 N07 N08 7.66e-01
C09 N08 N09 2.64e-07
R09 N08 N09 2.10e-01
C10 N09 N10 3.74e-09
L10 N09 N10 6.90e-11
R10 N09 N10 1.76e-01
C11 N10 N11 3.09e-09
L11 N10 N11 3.28e-11
R11 N10 N11 1.37e-01
C12 N11 N12 4.02e-11
L12 N11 N12 1.62e-10
R12 N11 N12 2.45e+00
C13 N12 Port2 1.58e-12
L13 N12 Port2 2.86e-10
R13 N12 Port2 2.19e+01
.ENDS GCJ216R72A822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ219R71C105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71C105KA01 Port1 Port2
C01 Port1 N01 9.49e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 6.27e-11
R03 N02 N03 1.80e-02
C04 N03 N04 9.29e-05
R04 N03 N04 3.08e+01
C05 N04 N05 1.17e-04
R05 N04 N05 3.17e+00
C06 N05 N06 1.15e-04
R06 N05 N06 3.96e-01
C07 N06 N07 1.01e-04
R07 N06 N07 7.65e-02
C08 N07 N08 5.86e-05
R08 N07 N08 1.71e-02
L09 N08 N09 3.96e-11
R09 N08 N09 8.54e-02
L10 N09 N10 2.25e-10
R10 N09 N10 4.01e-02
C11 N10 N11 4.90e-06
L11 N10 N11 3.03e-11
R11 N10 N11 8.00e-03
C12 N11 N12 1.54e-06
L12 N11 N12 4.20e-11
R12 N11 N12 1.28e-02
C13 N12 N13 1.43e-11
L13 N12 N13 5.94e-11
R13 N12 N13 6.47e+00
C14 N13 Port2 1.02e-12
L14 N13 Port2 1.65e-10
R14 N13 Port2 6.84e+01
.ENDS GCJ219R71C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ219R71C105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71C105MA01 Port1 Port2
C01 Port1 N01 9.49e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 6.27e-11
R03 N02 N03 1.80e-02
C04 N03 N04 9.29e-05
R04 N03 N04 3.08e+01
C05 N04 N05 1.17e-04
R05 N04 N05 3.17e+00
C06 N05 N06 1.15e-04
R06 N05 N06 3.96e-01
C07 N06 N07 1.01e-04
R07 N06 N07 7.65e-02
C08 N07 N08 5.86e-05
R08 N07 N08 1.71e-02
L09 N08 N09 3.96e-11
R09 N08 N09 8.54e-02
L10 N09 N10 2.25e-10
R10 N09 N10 4.01e-02
C11 N10 N11 4.90e-06
L11 N10 N11 3.03e-11
R11 N10 N11 8.00e-03
C12 N11 N12 1.54e-06
L12 N11 N12 4.20e-11
R12 N11 N12 1.28e-02
C13 N12 N13 1.43e-11
L13 N12 N13 5.94e-11
R13 N12 N13 6.47e+00
C14 N13 Port2 1.02e-12
L14 N13 Port2 1.65e-10
R14 N13 Port2 6.84e+01
.ENDS GCJ219R71C105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCJ219R71E223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E223KA01 Port1 Port2
C01 Port1 N01 2.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.02e-11
R03 N02 N03 7.37e-02
C04 N03 N04 1.53e-06
R04 N03 N04 1.14e+00
C05 N04 N05 7.60e-06
R05 N04 N05 7.41e-01
C06 N05 N06 1.17e-05
R06 N05 N06 3.24e-01
C07 N06 N07 1.64e-06
R07 N06 N07 1.20e-01
C08 N07 N08 2.05e-06
R08 N07 N08 2.36e-02
L09 N08 N09 1.04e-10
R09 N08 N09 1.52e-01
C10 N09 N10 1.30e-07
L10 N09 N10 1.63e-11
R10 N09 N10 3.07e-02
C11 N10 N11 2.69e-08
L11 N10 N11 3.05e-11
R11 N10 N11 7.87e-02
C12 N11 N12 7.14e-12
L12 N11 N12 1.49e-10
R12 N11 N12 1.80e+01
C13 N12 Port2 1.06e-12
L13 N12 Port2 2.41e-10
R13 N12 Port2 4.09e+01
.ENDS GCJ219R71E223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCJ219R71E223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E223MA01 Port1 Port2
C01 Port1 N01 2.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.02e-11
R03 N02 N03 7.37e-02
C04 N03 N04 1.53e-06
R04 N03 N04 1.14e+00
C05 N04 N05 7.60e-06
R05 N04 N05 7.41e-01
C06 N05 N06 1.17e-05
R06 N05 N06 3.24e-01
C07 N06 N07 1.64e-06
R07 N06 N07 1.20e-01
C08 N07 N08 2.05e-06
R08 N07 N08 2.36e-02
L09 N08 N09 1.04e-10
R09 N08 N09 1.52e-01
C10 N09 N10 1.30e-07
L10 N09 N10 1.63e-11
R10 N09 N10 3.07e-02
C11 N10 N11 2.69e-08
L11 N10 N11 3.05e-11
R11 N10 N11 7.87e-02
C12 N11 N12 7.14e-12
L12 N11 N12 1.49e-10
R12 N11 N12 1.80e+01
C13 N12 Port2 1.06e-12
L13 N12 Port2 2.41e-10
R13 N12 Port2 4.09e+01
.ENDS GCJ219R71E223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ219R71E474KA12
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E474KA12 Port1 Port2
C01 Port1 N01 4.71e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.79e-10
R03 N02 N03 1.93e-02
C04 N03 N04 7.11e-05
R04 N03 N04 1.17e-01
C05 N04 N05 7.69e-05
R05 N04 N05 2.09e-02
C06 N05 N06 3.42e-05
R06 N05 N06 1.20e-02
L07 N06 N07 2.51e-11
R07 N06 N07 4.92e-02
L08 N07 N08 2.37e-10
R08 N07 N08 4.57e-02
C09 N08 N09 3.83e-06
L09 N08 N09 1.77e-11
R09 N08 N09 9.47e-03
C10 N09 N10 1.03e-06
L10 N09 N10 2.83e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.80e-11
L11 N10 N11 3.94e-11
R11 N10 N11 5.80e+00
C12 N11 Port2 1.87e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 1.41e+01
.ENDS GCJ219R71E474KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ219R71E474MA12
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E474MA12 Port1 Port2
C01 Port1 N01 4.71e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.79e-10
R03 N02 N03 1.93e-02
C04 N03 N04 7.11e-05
R04 N03 N04 1.17e-01
C05 N04 N05 7.69e-05
R05 N04 N05 2.09e-02
C06 N05 N06 3.42e-05
R06 N05 N06 1.20e-02
L07 N06 N07 2.51e-11
R07 N06 N07 4.92e-02
L08 N07 N08 2.37e-10
R08 N07 N08 4.57e-02
C09 N08 N09 3.83e-06
L09 N08 N09 1.77e-11
R09 N08 N09 9.47e-03
C10 N09 N10 1.03e-06
L10 N09 N10 2.83e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.80e-11
L11 N10 N11 3.94e-11
R11 N10 N11 5.80e+00
C12 N11 Port2 1.87e-12
L12 N11 Port2 1.24e-10
R12 N11 Port2 1.41e+01
.ENDS GCJ219R71E474MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCJ219R71H273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H273KA01 Port1 Port2
C01 Port1 N01 2.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.52e-11
R03 N02 N03 4.62e-02
C04 N03 N04 1.67e-06
R04 N03 N04 7.59e+00
C05 N04 N05 2.41e-06
R05 N04 N05 6.40e-01
C06 N05 N06 2.12e-06
R06 N05 N06 9.14e-02
C07 N06 N07 3.10e-06
R07 N06 N07 1.52e-02
L08 N07 N08 7.06e-11
R08 N07 N08 1.06e-01
C09 N08 N09 2.04e-07
L09 N08 N09 1.06e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.34e-08
L10 N09 N10 3.35e-11
R10 N09 N10 6.27e-02
C11 N10 N11 4.63e-11
L11 N10 N11 1.75e-10
R11 N10 N11 2.38e+00
C12 N11 Port2 1.15e-12
L12 N11 Port2 2.08e-10
R12 N11 Port2 3.40e+01
.ENDS GCJ219R71H273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCJ219R71H273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H273MA01 Port1 Port2
C01 Port1 N01 2.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.52e-11
R03 N02 N03 4.62e-02
C04 N03 N04 1.67e-06
R04 N03 N04 7.59e+00
C05 N04 N05 2.41e-06
R05 N04 N05 6.40e-01
C06 N05 N06 2.12e-06
R06 N05 N06 9.14e-02
C07 N06 N07 3.10e-06
R07 N06 N07 1.52e-02
L08 N07 N08 7.06e-11
R08 N07 N08 1.06e-01
C09 N08 N09 2.04e-07
L09 N08 N09 1.06e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.34e-08
L10 N09 N10 3.35e-11
R10 N09 N10 6.27e-02
C11 N10 N11 4.63e-11
L11 N10 N11 1.75e-10
R11 N10 N11 2.38e+00
C12 N11 Port2 1.15e-12
L12 N11 Port2 2.08e-10
R12 N11 Port2 3.40e+01
.ENDS GCJ219R71H273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCJ219R71H333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H333KA01 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 9.07e-02
C04 N03 N04 1.73e-06
R04 N03 N04 7.33e+00
C05 N04 N05 2.73e-06
R05 N04 N05 5.82e-01
C06 N05 N06 1.81e-06
R06 N05 N06 1.01e-01
C07 N06 N07 1.35e-07
L07 N06 N07 2.39e-11
R07 N06 N07 4.23e-02
C08 N07 N08 2.99e-08
L08 N07 N08 3.89e-11
R08 N07 N08 7.92e-02
C09 N08 N09 2.99e-09
L09 N08 N09 7.18e-11
R09 N08 N09 1.36e-01
C10 N09 N10 4.33e-11
L10 N09 N10 1.56e-10
R10 N09 N10 1.90e+00
C11 N10 Port2 2.35e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 2.81e+01
.ENDS GCJ219R71H333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCJ219R71H333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H333MA01 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 9.07e-02
C04 N03 N04 1.73e-06
R04 N03 N04 7.33e+00
C05 N04 N05 2.73e-06
R05 N04 N05 5.82e-01
C06 N05 N06 1.81e-06
R06 N05 N06 1.01e-01
C07 N06 N07 1.35e-07
L07 N06 N07 2.39e-11
R07 N06 N07 4.23e-02
C08 N07 N08 2.99e-08
L08 N07 N08 3.89e-11
R08 N07 N08 7.92e-02
C09 N08 N09 2.99e-09
L09 N08 N09 7.18e-11
R09 N08 N09 1.36e-01
C10 N09 N10 4.33e-11
L10 N09 N10 1.56e-10
R10 N09 N10 1.90e+00
C11 N10 Port2 2.35e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 2.81e+01
.ENDS GCJ219R71H333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GCJ219R71H334KA12
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H334KA12 Port1 Port2
C01 Port1 N01 3.29e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.63e-10
R03 N02 N03 1.79e-02
C04 N03 N04 1.82e-05
R04 N03 N04 8.45e-01
C05 N04 N05 2.83e-05
R05 N04 N05 4.43e-02
C06 N05 N06 1.86e-05
R06 N05 N06 1.06e-02
L07 N06 N07 2.15e-11
R07 N06 N07 8.13e-02
L08 N07 N08 1.85e-10
R08 N07 N08 5.97e-02
C09 N08 N09 1.36e-06
L09 N08 N09 3.23e-11
R09 N08 N09 1.79e-02
C10 N09 N10 4.67e-07
L10 N09 N10 3.99e-11
R10 N09 N10 2.35e-02
C11 N10 N11 2.99e-11
L11 N10 N11 3.32e-11
R11 N10 N11 5.53e+00
C12 N11 Port2 2.35e-12
L12 N11 Port2 1.23e-10
R12 N11 Port2 1.82e+01
.ENDS GCJ219R71H334KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GCJ219R71H334MA12
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H334MA12 Port1 Port2
C01 Port1 N01 3.29e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.63e-10
R03 N02 N03 1.79e-02
C04 N03 N04 1.82e-05
R04 N03 N04 8.45e-01
C05 N04 N05 2.83e-05
R05 N04 N05 4.43e-02
C06 N05 N06 1.86e-05
R06 N05 N06 1.06e-02
L07 N06 N07 2.15e-11
R07 N06 N07 8.13e-02
L08 N07 N08 1.85e-10
R08 N07 N08 5.97e-02
C09 N08 N09 1.36e-06
L09 N08 N09 3.23e-11
R09 N08 N09 1.79e-02
C10 N09 N10 4.67e-07
L10 N09 N10 3.99e-11
R10 N09 N10 2.35e-02
C11 N10 N11 2.99e-11
L11 N10 N11 3.32e-11
R11 N10 N11 5.53e+00
C12 N11 Port2 2.35e-12
L12 N11 Port2 1.23e-10
R12 N11 Port2 1.82e+01
.ENDS GCJ219R71H334MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCJ219R71H393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H393KA01 Port1 Port2
C01 Port1 N01 3.96e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 7.29e-02
C04 N03 N04 5.60e-06
R04 N03 N04 7.86e+02
C05 N04 N05 6.11e-06
R05 N04 N05 1.22e+02
C06 N05 N06 5.10e-06
R06 N05 N06 1.22e+01
C07 N06 N07 7.79e-06
R07 N06 N07 9.02e-01
C08 N07 N08 6.10e-06
R08 N07 N08 3.51e-01
C09 N08 N09 2.30e-06
R09 N08 N09 1.14e-01
C10 N09 N10 4.48e-06
R10 N09 N10 8.31e-03
L11 N10 N11 1.57e-10
R11 N10 N11 1.89e-01
C12 N11 N12 2.05e-07
L12 N11 N12 1.91e-11
R12 N11 N12 3.12e-02
C13 N12 N13 6.36e-08
L13 N12 N13 2.37e-11
R13 N12 N13 5.05e-02
C14 N13 N14 1.06e-10
L14 N13 N14 6.70e-11
R14 N13 N14 1.06e+00
C15 N14 Port2 1.26e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 2.03e+01
.ENDS GCJ219R71H393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCJ219R72A221KA01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A221KA01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GCJ219R72A221KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCJ219R72A221MA01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A221MA01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GCJ219R72A221MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GCJ219R72A271KA01
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A271KA01 Port1 Port2
C01 Port1 N01 2.73e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 5.14e-01
C04 N03 N04 3.51e-08
R04 N03 N04 8.45e+04
C05 N04 N05 2.71e-08
R05 N04 N05 2.03e+04
C06 N05 N06 3.84e-08
R06 N05 N06 1.09e+03
C07 N06 N07 3.45e-08
R07 N06 N07 1.37e+02
C08 N07 N08 2.19e-08
R08 N07 N08 1.86e+01
C09 N08 N09 1.17e-08
R09 N08 N09 3.30e+00
C10 N09 N10 2.91e-09
R10 N09 N10 1.15e+00
C11 N10 N11 2.20e-09
R11 N10 N11 2.10e-01
C12 N11 N12 4.26e-10
L12 N11 N12 1.67e-11
R12 N11 N12 6.38e-01
C13 N12 N13 5.59e-12
L13 N12 N13 2.47e-10
R13 N12 N13 1.19e+01
C14 N13 Port2 3.77e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 1.26e+01
.ENDS GCJ219R72A271KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCJ219R72A273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A273KA01 Port1 Port2
C01 Port1 N01 2.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.52e-11
R03 N02 N03 4.62e-02
C04 N03 N04 1.67e-06
R04 N03 N04 7.59e+00
C05 N04 N05 2.41e-06
R05 N04 N05 6.40e-01
C06 N05 N06 2.12e-06
R06 N05 N06 9.14e-02
C07 N06 N07 3.10e-06
R07 N06 N07 1.52e-02
L08 N07 N08 7.06e-11
R08 N07 N08 1.06e-01
C09 N08 N09 2.04e-07
L09 N08 N09 1.06e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.34e-08
L10 N09 N10 3.35e-11
R10 N09 N10 6.27e-02
C11 N10 N11 4.63e-11
L11 N10 N11 1.75e-10
R11 N10 N11 2.38e+00
C12 N11 Port2 1.15e-12
L12 N11 Port2 2.08e-10
R12 N11 Port2 3.40e+01
.ENDS GCJ219R72A273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCJ219R72A273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A273MA01 Port1 Port2
C01 Port1 N01 2.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.52e-11
R03 N02 N03 4.62e-02
C04 N03 N04 1.67e-06
R04 N03 N04 7.59e+00
C05 N04 N05 2.41e-06
R05 N04 N05 6.40e-01
C06 N05 N06 2.12e-06
R06 N05 N06 9.14e-02
C07 N06 N07 3.10e-06
R07 N06 N07 1.52e-02
L08 N07 N08 7.06e-11
R08 N07 N08 1.06e-01
C09 N08 N09 2.04e-07
L09 N08 N09 1.06e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.34e-08
L10 N09 N10 3.35e-11
R10 N09 N10 6.27e-02
C11 N10 N11 4.63e-11
L11 N10 N11 1.75e-10
R11 N10 N11 2.38e+00
C12 N11 Port2 1.15e-12
L12 N11 Port2 2.08e-10
R12 N11 Port2 3.40e+01
.ENDS GCJ219R72A273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCJ219R72A331KA01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A331KA01 Port1 Port2
C01 Port1 N01 3.58e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.87e-11
R03 N02 N03 4.73e-01
C04 N03 N04 2.71e-08
R04 N03 N04 1.86e+05
C05 N04 N05 4.16e-08
R05 N04 N05 2.39e+04
C06 N05 N06 5.45e-08
R06 N05 N06 1.62e+03
C07 N06 N07 4.61e-08
R07 N06 N07 1.86e+02
C08 N07 N08 7.73e-08
R08 N07 N08 1.87e+01
C09 N08 N09 2.78e-08
R09 N08 N09 8.73e+00
C10 N09 N10 9.64e-09
R10 N09 N10 1.81e+00
C11 N10 N11 1.86e-09
R11 N10 N11 5.93e-01
C12 N11 N12 3.46e-09
L12 N11 N12 6.96e-12
R12 N11 N12 2.05e-01
C13 N12 N13 5.71e-10
L13 N12 N13 1.94e-11
R13 N12 N13 5.29e-01
C14 N13 N14 4.21e-12
L14 N13 N14 2.34e-10
R14 N13 N14 1.15e+01
C15 N14 Port2 1.39e-12
L15 N14 Port2 2.01e-10
R15 N14 Port2 1.77e+01
.ENDS GCJ219R72A331KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCJ219R72A333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A333KA01 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 9.07e-02
C04 N03 N04 1.73e-06
R04 N03 N04 7.33e+00
C05 N04 N05 2.73e-06
R05 N04 N05 5.82e-01
C06 N05 N06 1.81e-06
R06 N05 N06 1.01e-01
C07 N06 N07 1.35e-07
L07 N06 N07 2.39e-11
R07 N06 N07 4.23e-02
C08 N07 N08 2.99e-08
L08 N07 N08 3.89e-11
R08 N07 N08 7.92e-02
C09 N08 N09 2.99e-09
L09 N08 N09 7.18e-11
R09 N08 N09 1.36e-01
C10 N09 N10 4.33e-11
L10 N09 N10 1.56e-10
R10 N09 N10 1.90e+00
C11 N10 Port2 2.35e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 2.81e+01
.ENDS GCJ219R72A333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCJ219R72A333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A333MA01 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 9.07e-02
C04 N03 N04 1.73e-06
R04 N03 N04 7.33e+00
C05 N04 N05 2.73e-06
R05 N04 N05 5.82e-01
C06 N05 N06 1.81e-06
R06 N05 N06 1.01e-01
C07 N06 N07 1.35e-07
L07 N06 N07 2.39e-11
R07 N06 N07 4.23e-02
C08 N07 N08 2.99e-08
L08 N07 N08 3.89e-11
R08 N07 N08 7.92e-02
C09 N08 N09 2.99e-09
L09 N08 N09 7.18e-11
R09 N08 N09 1.36e-01
C10 N09 N10 4.33e-11
L10 N09 N10 1.56e-10
R10 N09 N10 1.90e+00
C11 N10 Port2 2.35e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 2.81e+01
.ENDS GCJ219R72A333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GCJ219R72A391KA01
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A391KA01 Port1 Port2
C01 Port1 N01 4.10e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 4.31e-01
C04 N03 N04 4.29e-08
R04 N03 N04 5.86e+04
C05 N04 N05 6.25e-08
R05 N04 N05 7.20e+03
C06 N05 N06 6.27e-08
R06 N05 N06 5.47e+02
C07 N06 N07 1.48e-07
R07 N06 N07 7.37e+01
C08 N07 N08 5.34e-08
R08 N07 N08 5.22e+01
C09 N08 N09 2.89e-08
R09 N08 N09 9.03e+00
C10 N09 N10 1.36e-08
R10 N09 N10 1.85e+00
C11 N10 N11 2.91e-09
R11 N10 N11 5.73e-01
C12 N11 N12 1.36e-09
L12 N11 N12 1.79e-11
R12 N11 N12 3.60e-01
C13 N12 N13 6.11e-10
L13 N12 N13 2.02e-11
R13 N12 N13 4.34e-01
C14 N13 N14 4.65e-12
L14 N13 N14 2.32e-10
R14 N13 N14 1.17e+01
C15 N14 Port2 3.71e-12
L15 N14 Port2 1.01e-10
R15 N14 Port2 1.36e+01
.ENDS GCJ219R72A391KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCJ219R72A393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A393KA01 Port1 Port2
C01 Port1 N01 3.96e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 7.29e-02
C04 N03 N04 5.60e-06
R04 N03 N04 7.86e+02
C05 N04 N05 6.11e-06
R05 N04 N05 1.22e+02
C06 N05 N06 5.10e-06
R06 N05 N06 1.22e+01
C07 N06 N07 7.79e-06
R07 N06 N07 9.02e-01
C08 N07 N08 6.10e-06
R08 N07 N08 3.51e-01
C09 N08 N09 2.30e-06
R09 N08 N09 1.14e-01
C10 N09 N10 4.48e-06
R10 N09 N10 8.31e-03
L11 N10 N11 1.57e-10
R11 N10 N11 1.89e-01
C12 N11 N12 2.05e-07
L12 N11 N12 1.91e-11
R12 N11 N12 3.12e-02
C13 N12 N13 6.36e-08
L13 N12 N13 2.37e-11
R13 N12 N13 5.05e-02
C14 N13 N14 1.06e-10
L14 N13 N14 6.70e-11
R14 N13 N14 1.06e+00
C15 N14 Port2 1.26e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 2.03e+01
.ENDS GCJ219R72A393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCJ219R72A471KA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A471KA01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GCJ219R72A471KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCJ219R72A471MA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A471MA01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GCJ219R72A471MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GCJ219R72A561KA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A561KA01 Port1 Port2
C01 Port1 N01 5.84e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.95e-11
R03 N02 N03 3.92e-01
C04 N03 N04 7.11e-08
R04 N03 N04 2.99e+04
C05 N04 N05 1.25e-07
R05 N04 N05 2.43e+03
C06 N05 N06 8.01e-08
R06 N05 N06 3.59e+02
C07 N06 N07 6.30e-08
R07 N06 N07 4.32e+01
C08 N07 N08 4.85e-08
R08 N07 N08 4.63e+00
C09 N08 N09 1.64e-08
R09 N08 N09 1.53e+00
C10 N09 N10 4.47e-09
R10 N09 N10 3.92e-01
C11 N10 N11 2.12e-09
L11 N10 N11 1.61e-11
R11 N10 N11 1.38e-01
C12 N11 N12 8.32e-10
L12 N11 N12 1.04e-11
R12 N11 N12 2.17e-01
C13 N12 N13 3.33e-12
L13 N12 N13 2.79e-10
R13 N12 N13 1.86e+01
C14 N13 Port2 3.52e-12
L14 N13 Port2 1.36e-10
R14 N13 Port2 1.82e+01
.ENDS GCJ219R72A561KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCJ219R72A681KA01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A681KA01 Port1 Port2
C01 Port1 N01 6.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.09e-11
R03 N02 N03 2.51e-01
C04 N03 N04 3.40e-08
R04 N03 N04 1.59e+01
C05 N04 N05 4.77e-08
R05 N04 N05 3.41e+00
C06 N05 N06 2.29e-08
R06 N05 N06 6.85e-01
C07 N06 N07 7.81e-09
R07 N06 N07 2.47e-01
C08 N07 N08 6.70e-09
R08 N07 N08 9.79e-02
C09 N08 N09 2.98e-09
L09 N08 N09 1.72e-11
R09 N08 N09 1.76e-01
C10 N09 N10 4.62e-10
L10 N09 N10 4.05e-11
R10 N09 N10 4.72e-01
C11 N10 N11 7.36e-12
L11 N10 N11 1.26e-10
R11 N10 N11 1.17e+01
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 2.35e+01
.ENDS GCJ219R72A681KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCJ219R72A681MA01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A681MA01 Port1 Port2
C01 Port1 N01 6.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.09e-11
R03 N02 N03 2.51e-01
C04 N03 N04 3.40e-08
R04 N03 N04 1.59e+01
C05 N04 N05 4.77e-08
R05 N04 N05 3.41e+00
C06 N05 N06 2.29e-08
R06 N05 N06 6.85e-01
C07 N06 N07 7.81e-09
R07 N06 N07 2.47e-01
C08 N07 N08 6.70e-09
R08 N07 N08 9.79e-02
C09 N08 N09 2.98e-09
L09 N08 N09 1.72e-11
R09 N08 N09 1.76e-01
C10 N09 N10 4.62e-10
L10 N09 N10 4.05e-11
R10 N09 N10 4.72e-01
C11 N10 N11 7.36e-12
L11 N10 N11 1.26e-10
R11 N10 N11 1.17e+01
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 2.35e+01
.ENDS GCJ219R72A681MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GCJ219R72A821KA01
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A821KA01 Port1 Port2
C01 Port1 N01 8.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.29e-11
R03 N02 N03 2.79e-01
C04 N03 N04 1.14e-07
R04 N03 N04 3.86e+04
C05 N04 N05 1.53e-07
R05 N04 N05 5.32e+03
C06 N05 N06 2.14e-07
R06 N05 N06 6.40e+02
C07 N06 N07 1.35e-07
R07 N06 N07 2.38e+02
C08 N07 N08 9.48e-08
R08 N07 N08 3.36e+01
C09 N08 N09 5.72e-08
R09 N08 N09 5.17e+00
C10 N09 N10 2.82e-08
R10 N09 N10 8.23e-01
C11 N10 N11 7.59e-09
R11 N10 N11 2.87e-01
C12 N11 N12 1.10e-08
L12 N11 N12 5.59e-12
R12 N11 N12 1.04e-01
C13 N12 N13 4.35e-10
L13 N12 N13 4.80e-11
R13 N12 N13 3.96e-01
C14 N13 N14 4.96e-12
L14 N13 N14 1.92e-10
R14 N13 N14 1.40e+01
C15 N14 Port2 1.68e-12
L15 N14 Port2 1.88e-10
R15 N14 Port2 2.05e+01
.ENDS GCJ219R72A821KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E102KXJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E102KXJ1 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 3.31e-01
C04 N03 N04 1.21e-08
R04 N03 N04 2.09e+02
C05 N04 N05 4.59e-08
R05 N04 N05 1.38e+00
C06 N05 N06 1.59e-08
R06 N05 N06 2.88e-01
C07 N06 N07 3.95e-11
L07 N06 N07 1.89e-10
R07 N06 N07 3.31e+00
C08 N07 Port2 2.93e-12
L08 N07 Port2 2.33e-10
R08 N07 Port2 2.24e+01
.ENDS GCJ21AR72E102KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E152KXJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E152KXJ1 Port1 Port2
C01 Port1 N01 1.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 2.72e-01
C04 N03 N04 2.76e-08
R04 N03 N04 7.78e+01
C05 N04 N05 7.26e-08
R05 N04 N05 1.38e+00
C06 N05 N06 2.70e-08
R06 N05 N06 2.30e-01
C07 N06 N07 4.12e-11
L07 N06 N07 1.58e-10
R07 N06 N07 2.58e+00
C08 N07 Port2 2.42e-12
L08 N07 Port2 2.95e-10
R08 N07 Port2 2.77e+01
.ENDS GCJ21AR72E152KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E222KXJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E222KXJ1 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.05e-01
C04 N03 N04 4.91e-08
R04 N03 N04 4.27e+01
C05 N04 N05 1.07e-07
R05 N04 N05 9.34e-01
C06 N05 N06 4.48e-08
R06 N05 N06 1.78e-01
C07 N06 N07 1.17e-09
L07 N06 N07 5.34e-11
R07 N06 N07 2.82e-01
C08 N07 N08 5.71e-11
L08 N07 N08 1.04e-10
R08 N07 N08 2.09e+00
C09 N08 Port2 2.33e-12
L09 N08 Port2 2.44e-10
R09 N08 Port2 2.57e+01
.ENDS GCJ21AR72E222KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E332KXJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E332KXJ1 Port1 Port2
C01 Port1 N01 3.27e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 1.95e-01
C04 N03 N04 9.81e-08
R04 N03 N04 2.04e+01
C05 N04 N05 1.63e-07
R05 N04 N05 8.13e-01
C06 N05 N06 8.16e-08
R06 N05 N06 1.32e-01
C07 N06 N07 6.37e-11
L07 N06 N07 1.17e-10
R07 N06 N07 1.13e+00
C08 N07 Port2 2.48e-12
L08 N07 Port2 3.16e-10
R08 N07 Port2 2.90e+01
.ENDS GCJ21AR72E332KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E472KXJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E472KXJ1 Port1 Port2
C01 Port1 N01 4.46e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 1.54e-01
C04 N03 N04 1.55e-07
R04 N03 N04 1.59e+01
C05 N04 N05 2.46e-07
R05 N04 N05 6.47e-01
C06 N05 N06 1.35e-07
R06 N05 N06 9.35e-02
C07 N06 N07 1.71e-09
L07 N06 N07 7.28e-11
R07 N06 N07 2.16e-01
C08 N07 N08 1.32e-10
L08 N07 N08 5.92e-11
R08 N07 N08 6.68e-01
C09 N08 Port2 2.41e-12
L09 N08 Port2 2.83e-10
R09 N08 Port2 2.72e+01
.ENDS GCJ21AR72E472KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E682KXJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E682KXJ1 Port1 Port2
C01 Port1 N01 6.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 9.46e-02
C04 N03 N04 3.22e-07
R04 N03 N04 4.94e+00
C05 N04 N05 3.70e-07
R05 N04 N05 3.42e-01
C06 N05 N06 2.33e-07
R06 N05 N06 4.30e-02
L07 N06 N07 1.00e-10
R07 N06 N07 5.35e-01
C08 N07 N08 5.21e-09
L08 N07 N08 5.22e-11
R08 N07 N08 1.32e-01
C09 N08 Port2 2.67e-12
L09 N08 Port2 1.94e-10
R09 N08 Port2 2.69e+01
.ENDS GCJ21AR72E682KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ21BC72A105KE02
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BC72A105KE02 Port1 Port2
C01 Port1 N01 9.35e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.51e-10
R03 N02 N03 1.68e-02
C04 N03 N04 8.88e-05
R04 N03 N04 6.47e+01
C05 N04 N05 9.93e-05
R05 N04 N05 4.89e+00
C06 N05 N06 8.10e-05
R06 N05 N06 6.78e-01
C07 N06 N07 9.04e-05
R07 N06 N07 6.52e-02
C08 N07 N08 4.77e-05
R08 N07 N08 1.48e-02
L09 N08 N09 3.39e-11
R09 N08 N09 8.06e-02
L10 N09 N10 2.94e-10
R10 N09 N10 4.13e-02
C11 N10 N11 3.01e-06
L11 N10 N11 5.61e-11
R11 N10 N11 1.37e-02
C12 N11 N12 2.02e-06
L12 N11 N12 3.69e-11
R12 N11 N12 1.08e-02
C13 N12 N13 1.15e-11
L13 N12 N13 7.32e-11
R13 N12 N13 6.49e+00
C14 N13 Port2 5.80e-12
L14 N13 Port2 6.61e-11
R14 N13 Port2 1.09e+01
.ENDS GCJ21BC72A105KE02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ21BC72A105ME02
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BC72A105ME02 Port1 Port2
C01 Port1 N01 9.35e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.51e-10
R03 N02 N03 1.68e-02
C04 N03 N04 8.88e-05
R04 N03 N04 6.47e+01
C05 N04 N05 9.93e-05
R05 N04 N05 4.89e+00
C06 N05 N06 8.10e-05
R06 N05 N06 6.78e-01
C07 N06 N07 9.04e-05
R07 N06 N07 6.52e-02
C08 N07 N08 4.77e-05
R08 N07 N08 1.48e-02
L09 N08 N09 3.39e-11
R09 N08 N09 8.06e-02
L10 N09 N10 2.94e-10
R10 N09 N10 4.13e-02
C11 N10 N11 3.01e-06
L11 N10 N11 5.61e-11
R11 N10 N11 1.37e-02
C12 N11 N12 2.02e-06
L12 N11 N12 3.69e-11
R12 N11 N12 1.08e-02
C13 N12 N13 1.15e-11
L13 N12 N13 7.32e-11
R13 N12 N13 6.49e+00
C14 N13 Port2 5.80e-12
L14 N13 Port2 6.61e-11
R14 N13 Port2 1.09e+01
.ENDS GCJ21BC72A105ME02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ21BL81C105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C105KA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BL81C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ21BL81C105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C105MA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BL81C105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/5.60e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C564KA01
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C564KA01 Port1 Port2
C01 Port1 N01 5.49e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 8.65e-11
R03 N02 N03 9.21e-03
C04 N03 N04 8.55e-05
R04 N03 N04 6.49e+01
C05 N04 N05 6.45e-05
R05 N04 N05 1.26e+01
C06 N05 N06 6.88e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.76e-05
R07 N06 N07 1.26e-01
C08 N07 N08 3.93e-05
R08 N07 N08 2.30e-02
L09 N08 N09 2.18e-11
R09 N08 N09 6.28e-02
L10 N09 N10 2.13e-10
R10 N09 N10 5.08e-02
C11 N10 N11 2.20e-06
L11 N10 N11 3.87e-11
R11 N10 N11 1.62e-02
C12 N11 N12 9.81e-07
L12 N11 N12 3.61e-11
R12 N11 N12 1.95e-02
C13 N12 N13 1.42e-11
L13 N12 N13 7.25e-11
R13 N12 N13 8.69e+00
C14 N13 Port2 1.25e-12
L14 N13 Port2 2.14e-10
R14 N13 Port2 7.29e+01
.ENDS GCJ21BL81C564KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C684KA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BL81C684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C684MA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BL81C684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/8.20e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C824KA01
* Property : C = 8.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C824KA01 Port1 Port2
C01 Port1 N01 7.85e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 6.30e-11
R03 N02 N03 7.52e-03
C04 N03 N04 9.42e-05
R04 N03 N04 4.22e+01
C05 N04 N05 1.33e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.06e-04
R06 N05 N06 6.25e-01
C07 N06 N07 9.02e-05
R07 N06 N07 7.86e-02
C08 N07 N08 7.08e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.04e-11
R09 N08 N09 4.37e-02
L10 N09 N10 2.17e-10
R10 N09 N10 4.25e-02
C11 N10 N11 2.85e-06
L11 N10 N11 4.65e-11
R11 N10 N11 1.26e-02
C12 N11 N12 1.15e-06
L12 N11 N12 4.98e-11
R12 N11 N12 1.47e-02
C13 N12 N13 2.02e-11
L13 N12 N13 5.75e-11
R13 N12 N13 7.30e+00
C14 N13 Port2 1.14e-12
L14 N13 Port2 2.30e-10
R14 N13 Port2 4.53e+01
.ENDS GCJ21BL81C824KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ21BL81E105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E105KA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BL81E105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ21BL81E105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E105MA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BL81E105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E124KA01 Port1 Port2
C01 Port1 N01 1.28e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 3.61e-11
R03 N02 N03 1.52e-02
C04 N03 N04 1.75e-05
R04 N03 N04 3.17e+02
C05 N04 N05 1.82e-05
R05 N04 N05 4.38e+01
C06 N05 N06 1.65e-05
R06 N05 N06 4.91e+00
C07 N06 N07 1.63e-05
R07 N06 N07 5.15e-01
C08 N07 N08 1.17e-05
R08 N07 N08 8.30e-02
C09 N08 N09 7.64e-06
R09 N08 N09 1.05e-02
L10 N09 N10 1.37e-10
R10 N09 N10 7.79e-02
C11 N10 N11 4.62e-07
L11 N10 N11 3.55e-11
R11 N10 N11 2.38e-02
C12 N11 N12 1.88e-07
L12 N11 N12 3.20e-11
R12 N11 N12 2.91e-02
C13 N12 N13 1.85e-11
L13 N12 N13 8.48e-11
R13 N12 N13 1.09e+01
C14 N13 Port2 8.70e-13
L14 N13 Port2 3.28e-10
R14 N13 Port2 4.41e+01
.ENDS GCJ21BL81E124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E154KA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BL81E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E154MA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BL81E154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.80e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E184KA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BL81E184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.80e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E184MA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E184MA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BL81E184MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E224KA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BL81E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E224MA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BL81E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.70e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E274KA01
* Property : C = 2.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E274KA01 Port1 Port2
C01 Port1 N01 2.49e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.87e-10
R03 N02 N03 1.14e-02
C04 N03 N04 2.69e-05
R04 N03 N04 1.38e+02
C05 N04 N05 3.73e-05
R05 N04 N05 1.05e+01
C06 N05 N06 3.30e-05
R06 N05 N06 1.35e+00
C07 N06 N07 3.25e-05
R07 N06 N07 1.82e-01
C08 N07 N08 2.18e-05
R08 N07 N08 3.12e-02
C09 N08 N09 2.94e-05
R09 N08 N09 2.50e-03
L10 N09 N10 1.27e-10
R10 N09 N10 6.43e-02
L11 N10 N11 2.15e-12
R11 N10 N11 7.62e-03
C12 N11 N12 9.84e-07
L12 N11 N12 3.05e-11
R12 N11 N12 1.49e-02
C13 N12 N13 2.03e-07
L13 N12 N13 5.81e-11
R13 N12 N13 2.67e-02
C14 N13 N14 1.07e-11
L14 N13 N14 1.45e-10
R14 N13 N14 1.35e+01
C15 N14 Port2 3.19e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 2.17e+01
.ENDS GCJ21BL81E274KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E334KA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BL81E334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E334MA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BL81E334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E394KA01 Port1 Port2
C01 Port1 N01 3.89e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.02e-10
R03 N02 N03 1.02e-02
C04 N03 N04 5.63e-05
R04 N03 N04 6.09e+01
C05 N04 N05 6.40e-05
R05 N04 N05 7.84e+00
C06 N05 N06 5.41e-05
R06 N05 N06 1.03e+00
C07 N06 N07 4.50e-05
R07 N06 N07 1.21e-01
C08 N07 N08 2.75e-05
R08 N07 N08 1.47e-02
L09 N08 N09 2.33e-11
R09 N08 N09 6.19e-02
L10 N09 N10 1.85e-10
R10 N09 N10 5.26e-02
C11 N10 N11 1.85e-06
L11 N10 N11 3.08e-11
R11 N10 N11 1.77e-02
C12 N11 N12 4.89e-07
L12 N11 N12 5.28e-11
R12 N11 N12 2.33e-02
C13 N12 N13 1.38e-11
L13 N12 N13 8.02e-11
R13 N12 N13 9.52e+00
C14 N13 Port2 1.86e-12
L14 N13 Port2 1.75e-10
R14 N13 Port2 4.51e+01
.ENDS GCJ21BL81E394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E684KA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BL81E684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E684MA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BL81E684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/8.20e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E824KA01
* Property : C = 8.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E824KA01 Port1 Port2
C01 Port1 N01 7.85e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 6.30e-11
R03 N02 N03 7.52e-03
C04 N03 N04 9.42e-05
R04 N03 N04 4.22e+01
C05 N04 N05 1.33e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.06e-04
R06 N05 N06 6.25e-01
C07 N06 N07 9.02e-05
R07 N06 N07 7.86e-02
C08 N07 N08 7.08e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.04e-11
R09 N08 N09 4.37e-02
L10 N09 N10 2.17e-10
R10 N09 N10 4.25e-02
C11 N10 N11 2.85e-06
L11 N10 N11 4.65e-11
R11 N10 N11 1.26e-02
C12 N11 N12 1.15e-06
L12 N11 N12 4.98e-11
R12 N11 N12 1.47e-02
C13 N12 N13 2.02e-11
L13 N12 N13 5.75e-11
R13 N12 N13 7.30e+00
C14 N13 Port2 1.14e-12
L14 N13 Port2 2.30e-10
R14 N13 Port2 4.53e+01
.ENDS GCJ21BL81E824KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ21BL81H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H104KA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BL81H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ21BL81H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H104MA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BL81H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H273KA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 3.91e-02
C04 N03 N04 2.43e-06
R04 N03 N04 3.61e+03
C05 N04 N05 4.82e-06
R05 N04 N05 1.65e+02
C06 N05 N06 3.87e-06
R06 N05 N06 2.18e+01
C07 N06 N07 4.56e-06
R07 N06 N07 1.61e+00
C08 N07 N08 3.85e-05
R08 N07 N08 6.00e-01
C09 N08 N09 7.29e-06
R09 N08 N09 2.94e-01
C10 N09 N10 2.98e-06
R10 N09 N10 2.03e-01
C11 N10 N11 1.76e-06
R11 N10 N11 4.18e-02
C12 N11 N12 6.29e-06
R12 N11 N12 1.36e-03
L13 N12 N13 1.21e-10
R13 N12 N13 1.54e-01
C14 N13 N14 2.64e-07
L14 N13 N14 1.59e-11
R14 N13 N14 2.48e-02
C15 N14 N15 5.14e-08
L15 N14 N15 3.52e-11
R15 N14 N15 6.32e-02
C16 N15 N16 4.30e-11
L16 N15 N16 1.64e-10
R16 N15 N16 3.18e+00
C17 N16 Port2 1.73e-12
L17 N16 Port2 2.51e-10
R17 N16 Port2 1.29e+01
.ENDS GCJ21BL81H273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H393KA01 Port1 Port2
C01 Port1 N01 3.98e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.31e-02
C04 N03 N04 6.30e-06
R04 N03 N04 6.43e+02
C05 N04 N05 9.03e-06
R05 N04 N05 9.95e+01
C06 N05 N06 6.10e-06
R06 N05 N06 1.61e+01
C07 N06 N07 5.65e-06
R07 N06 N07 1.73e+00
C08 N07 N08 2.36e-05
R08 N07 N08 1.47e-01
C09 N08 N09 4.87e-06
R09 N08 N09 1.46e-01
C10 N09 N10 3.25e-06
R10 N09 N10 4.00e-02
C11 N10 N11 1.28e-05
R11 N10 N11 2.24e-03
L12 N11 N12 1.19e-10
R12 N11 N12 1.47e-01
C13 N12 N13 2.85e-07
L13 N12 N13 1.54e-11
R13 N12 N13 2.43e-02
C14 N13 N14 4.58e-08
L14 N13 N14 3.62e-11
R14 N13 N14 5.42e-02
C15 N14 N15 6.53e-11
L15 N14 N15 1.48e-10
R15 N14 N15 1.97e+00
C16 N15 Port2 4.20e-12
L16 N15 Port2 1.51e-10
R16 N15 Port2 1.31e+01
.ENDS GCJ21BL81H393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H473KA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BL81H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H473MA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BL81H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H563KA01 Port1 Port2
C01 Port1 N01 5.70e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.15e-10
R03 N02 N03 3.58e-02
C04 N03 N04 7.54e-06
R04 N03 N04 7.59e+02
C05 N04 N05 1.03e-05
R05 N04 N05 7.95e+01
C06 N05 N06 7.75e-06
R06 N05 N06 9.78e+00
C07 N06 N07 7.20e-06
R07 N06 N07 9.78e-01
C08 N07 N08 5.79e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.77e-06
R09 N08 N09 2.39e-02
L10 N09 N10 8.76e-11
R10 N09 N10 8.89e-02
C11 N10 N11 4.23e-07
L11 N10 N11 1.93e-11
R11 N10 N11 1.99e-02
C12 N11 N12 7.34e-08
L12 N11 N12 2.88e-11
R12 N11 N12 2.78e-02
C13 N12 N13 1.30e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 1.41e-12
L14 N13 Port2 2.59e-10
R14 N13 Port2 2.69e+01
.ENDS GCJ21BL81H563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H683KA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BL81H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H683MA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BL81H683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.41e-10
R03 N02 N03 2.29e-02
C04 N03 N04 1.09e-05
R04 N03 N04 6.44e+02
C05 N04 N05 1.36e-05
R05 N04 N05 6.01e+01
C06 N05 N06 1.18e-05
R06 N05 N06 6.90e+00
C07 N06 N07 1.07e-05
R07 N06 N07 7.56e-01
C08 N07 N08 8.74e-06
R08 N07 N08 9.04e-02
C09 N08 N09 8.05e-06
R09 N08 N09 1.69e-02
L10 N09 N10 1.27e-10
R10 N09 N10 8.60e-02
L11 N10 N11 7.88e-12
R11 N10 N11 3.18e-02
C12 N11 N12 4.70e-07
L12 N11 N12 2.56e-11
R12 N11 N12 2.82e-02
C13 N12 N13 1.14e-07
L13 N12 N13 3.75e-11
R13 N12 N13 3.58e-02
C14 N13 N14 9.33e-12
L14 N13 N14 1.12e-10
R14 N13 N14 1.21e+01
C15 N14 Port2 1.86e-12
L15 N14 Port2 1.74e-10
R15 N14 Port2 3.13e+01
.ENDS GCJ21BL81H823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.20e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA124KA01 Port1 Port2
C01 Port1 N01 1.28e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 3.61e-11
R03 N02 N03 1.52e-02
C04 N03 N04 1.75e-05
R04 N03 N04 3.17e+02
C05 N04 N05 1.82e-05
R05 N04 N05 4.38e+01
C06 N05 N06 1.65e-05
R06 N05 N06 4.91e+00
C07 N06 N07 1.63e-05
R07 N06 N07 5.15e-01
C08 N07 N08 1.17e-05
R08 N07 N08 8.30e-02
C09 N08 N09 7.64e-06
R09 N08 N09 1.05e-02
L10 N09 N10 1.37e-10
R10 N09 N10 7.79e-02
C11 N10 N11 4.62e-07
L11 N10 N11 3.55e-11
R11 N10 N11 2.38e-02
C12 N11 N12 1.88e-07
L12 N11 N12 3.20e-11
R12 N11 N12 2.91e-02
C13 N12 N13 1.85e-11
L13 N12 N13 8.48e-11
R13 N12 N13 1.09e+01
C14 N13 Port2 8.70e-13
L14 N13 Port2 3.28e-10
R14 N13 Port2 4.41e+01
.ENDS GCJ21BL8YA124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.50e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA154KA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BL8YA154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.50e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA154MA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BL8YA154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.80e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA184KA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BL8YA184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.80e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA184MA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA184MA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BL8YA184MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA224KA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BL8YA224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA224MA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BL8YA224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.30e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA334KA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BL8YA334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.30e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA334MA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BL8YA334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ21BR71A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71A106KE01 Port1 Port2
C01 Port1 N01 6.25e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 7.48e-11
R03 N02 N03 1.20e-02
C04 N03 N04 1.67e-04
R04 N03 N04 4.38e+01
C05 N04 N05 2.35e-04
R05 N04 N05 2.75e+00
C06 N05 N06 1.98e-04
R06 N05 N06 3.97e-01
C07 N06 N07 3.75e-04
R07 N06 N07 3.33e-02
C08 N07 N08 3.09e-04
R08 N07 N08 1.27e-02
C09 N08 N09 1.40e-04
R09 N08 N09 1.02e-02
L10 N09 N10 1.54e-11
R10 N09 N10 2.72e-01
L11 N10 N11 6.42e-11
R11 N10 N11 6.00e-02
L12 N11 N12 3.99e-10
R12 N11 N12 1.83e-02
C13 N12 N13 2.28e-05
L13 N12 N13 5.75e-11
R13 N12 N13 4.44e-03
C14 N13 N14 1.70e-05
L14 N13 N14 3.37e-11
R14 N13 N14 3.38e-03
C15 N14 N15 2.69e-11
L15 N14 N15 2.85e-11
R15 N14 N15 4.25e+00
C16 N15 Port2 1.07e-12
L16 N15 Port2 1.38e-10
R16 N15 Port2 9.06e+01
.ENDS GCJ21BR71A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ21BR71A106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71A106ME01 Port1 Port2
C01 Port1 N01 6.25e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 7.48e-11
R03 N02 N03 1.20e-02
C04 N03 N04 1.67e-04
R04 N03 N04 4.38e+01
C05 N04 N05 2.35e-04
R05 N04 N05 2.75e+00
C06 N05 N06 1.98e-04
R06 N05 N06 3.97e-01
C07 N06 N07 3.75e-04
R07 N06 N07 3.33e-02
C08 N07 N08 3.09e-04
R08 N07 N08 1.27e-02
C09 N08 N09 1.40e-04
R09 N08 N09 1.02e-02
L10 N09 N10 1.54e-11
R10 N09 N10 2.72e-01
L11 N10 N11 6.42e-11
R11 N10 N11 6.00e-02
L12 N11 N12 3.99e-10
R12 N11 N12 1.83e-02
C13 N12 N13 2.28e-05
L13 N12 N13 5.75e-11
R13 N12 N13 4.44e-03
C14 N13 N14 1.70e-05
L14 N13 N14 3.37e-11
R14 N13 N14 3.38e-03
C15 N14 N15 2.69e-11
L15 N14 N15 2.85e-11
R15 N14 N15 4.25e+00
C16 N15 Port2 1.07e-12
L16 N15 Port2 1.38e-10
R16 N15 Port2 9.06e+01
.ENDS GCJ21BR71A106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GCJ21BR71A225KA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71A225KA01 Port1 Port2
C01 Port1 N01 2.05e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.68e-11
R03 N02 N03 1.20e-02
C04 N03 N04 2.58e-04
R04 N03 N04 1.31e+01
C05 N04 N05 2.43e-04
R05 N04 N05 1.41e+00
C06 N05 N06 1.95e-04
R06 N05 N06 1.86e-01
C07 N06 N07 1.12e-04
R07 N06 N07 2.01e-02
L08 N07 N08 4.99e-11
R08 N07 N08 8.89e-02
L09 N08 N09 3.29e-10
R09 N08 N09 2.84e-02
C10 N09 N10 1.11e-05
L10 N09 N10 3.53e-11
R10 N09 N10 7.34e-03
C11 N10 N11 6.45e-06
L11 N10 N11 2.87e-11
R11 N10 N11 7.30e-03
C12 N11 N12 1.03e-11
L12 N11 N12 8.67e-11
R12 N11 N12 6.97e+00
C13 N12 Port2 5.55e-13
L13 N12 Port2 2.08e-10
R13 N12 Port2 1.73e+02
.ENDS GCJ21BR71A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GCJ21BR71A225MA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71A225MA01 Port1 Port2
C01 Port1 N01 2.05e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.68e-11
R03 N02 N03 1.20e-02
C04 N03 N04 2.58e-04
R04 N03 N04 1.31e+01
C05 N04 N05 2.43e-04
R05 N04 N05 1.41e+00
C06 N05 N06 1.95e-04
R06 N05 N06 1.86e-01
C07 N06 N07 1.12e-04
R07 N06 N07 2.01e-02
L08 N07 N08 4.99e-11
R08 N07 N08 8.89e-02
L09 N08 N09 3.29e-10
R09 N08 N09 2.84e-02
C10 N09 N10 1.11e-05
L10 N09 N10 3.53e-11
R10 N09 N10 7.34e-03
C11 N10 N11 6.45e-06
L11 N10 N11 2.87e-11
R11 N10 N11 7.30e-03
C12 N11 N12 1.03e-11
L12 N11 N12 8.67e-11
R12 N11 N12 6.97e+00
C13 N12 Port2 5.55e-13
L13 N12 Port2 2.08e-10
R13 N12 Port2 1.73e+02
.ENDS GCJ21BR71A225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C105KA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BR71C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C105MA01 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BR71C105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C225KA13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C225KA13 Port1 Port2
C01 Port1 N01 2.05e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.68e-11
R03 N02 N03 1.20e-02
C04 N03 N04 2.58e-04
R04 N03 N04 1.31e+01
C05 N04 N05 2.43e-04
R05 N04 N05 1.41e+00
C06 N05 N06 1.95e-04
R06 N05 N06 1.86e-01
C07 N06 N07 1.12e-04
R07 N06 N07 2.01e-02
L08 N07 N08 4.99e-11
R08 N07 N08 8.89e-02
L09 N08 N09 3.29e-10
R09 N08 N09 2.84e-02
C10 N09 N10 1.11e-05
L10 N09 N10 3.53e-11
R10 N09 N10 7.34e-03
C11 N10 N11 6.45e-06
L11 N10 N11 2.87e-11
R11 N10 N11 7.30e-03
C12 N11 N12 1.03e-11
L12 N11 N12 8.67e-11
R12 N11 N12 6.97e+00
C13 N12 Port2 5.55e-13
L13 N12 Port2 2.08e-10
R13 N12 Port2 1.73e+02
.ENDS GCJ21BR71C225KA13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C225MA13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C225MA13 Port1 Port2
C01 Port1 N01 2.05e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.68e-11
R03 N02 N03 1.20e-02
C04 N03 N04 2.58e-04
R04 N03 N04 1.31e+01
C05 N04 N05 2.43e-04
R05 N04 N05 1.41e+00
C06 N05 N06 1.95e-04
R06 N05 N06 1.86e-01
C07 N06 N07 1.12e-04
R07 N06 N07 2.01e-02
L08 N07 N08 4.99e-11
R08 N07 N08 8.89e-02
L09 N08 N09 3.29e-10
R09 N08 N09 2.84e-02
C10 N09 N10 1.11e-05
L10 N09 N10 3.53e-11
R10 N09 N10 7.34e-03
C11 N10 N11 6.45e-06
L11 N10 N11 2.87e-11
R11 N10 N11 7.30e-03
C12 N11 N12 1.03e-11
L12 N11 N12 8.67e-11
R12 N11 N12 6.97e+00
C13 N12 Port2 5.55e-13
L13 N12 Port2 2.08e-10
R13 N12 Port2 1.73e+02
.ENDS GCJ21BR71C225MA13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C274KA01
* Property : C = 2.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C274KA01 Port1 Port2
C01 Port1 N01 2.49e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.87e-10
R03 N02 N03 1.14e-02
C04 N03 N04 2.69e-05
R04 N03 N04 1.38e+02
C05 N04 N05 3.73e-05
R05 N04 N05 1.05e+01
C06 N05 N06 3.30e-05
R06 N05 N06 1.35e+00
C07 N06 N07 3.25e-05
R07 N06 N07 1.82e-01
C08 N07 N08 2.18e-05
R08 N07 N08 3.12e-02
C09 N08 N09 2.94e-05
R09 N08 N09 2.50e-03
L10 N09 N10 1.27e-10
R10 N09 N10 6.43e-02
L11 N10 N11 2.15e-12
R11 N10 N11 7.62e-03
C12 N11 N12 9.84e-07
L12 N11 N12 3.05e-11
R12 N11 N12 1.49e-02
C13 N12 N13 2.03e-07
L13 N12 N13 5.81e-11
R13 N12 N13 2.67e-02
C14 N13 N14 1.07e-11
L14 N13 N14 1.45e-10
R14 N13 N14 1.35e+01
C15 N14 Port2 3.19e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 2.17e+01
.ENDS GCJ21BR71C274KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C334KA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71C334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C334MA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71C334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C394KA01 Port1 Port2
C01 Port1 N01 3.89e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.02e-10
R03 N02 N03 1.02e-02
C04 N03 N04 5.63e-05
R04 N03 N04 6.09e+01
C05 N04 N05 6.40e-05
R05 N04 N05 7.84e+00
C06 N05 N06 5.41e-05
R06 N05 N06 1.03e+00
C07 N06 N07 4.50e-05
R07 N06 N07 1.21e-01
C08 N07 N08 2.75e-05
R08 N07 N08 1.47e-02
L09 N08 N09 2.33e-11
R09 N08 N09 6.19e-02
L10 N09 N10 1.85e-10
R10 N09 N10 5.26e-02
C11 N10 N11 1.85e-06
L11 N10 N11 3.08e-11
R11 N10 N11 1.77e-02
C12 N11 N12 4.89e-07
L12 N11 N12 5.28e-11
R12 N11 N12 2.33e-02
C13 N12 N13 1.38e-11
L13 N12 N13 8.02e-11
R13 N12 N13 9.52e+00
C14 N13 Port2 1.86e-12
L14 N13 Port2 1.75e-10
R14 N13 Port2 4.51e+01
.ENDS GCJ21BR71C394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C475KA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C475KA01 Port1 Port2
C01 Port1 N01 3.03e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 9.04e-11
R03 N02 N03 2.21e-02
C04 N03 N04 1.15e-04
R04 N03 N04 4.62e+01
C05 N04 N05 1.14e-04
R05 N04 N05 5.69e+00
C06 N05 N06 9.86e-05
R06 N05 N06 8.01e-01
C07 N06 N07 8.63e-05
R07 N06 N07 8.96e-02
C08 N07 N08 4.42e-05
R08 N07 N08 1.62e-02
L09 N08 N09 1.26e-11
R09 N08 N09 5.77e-02
L10 N09 N10 6.23e-11
R10 N09 N10 5.38e-02
L11 N10 N11 4.40e-10
R11 N10 N11 2.30e-02
C12 N11 N12 2.16e-05
L12 N11 N12 2.77e-11
R12 N11 N12 4.95e-03
C13 N12 N13 1.26e-05
L13 N12 N13 2.10e-11
R13 N12 N13 5.58e-03
C14 N13 N14 2.22e-11
L14 N13 N14 4.20e-11
R14 N13 N14 5.45e+00
C15 N14 Port2 7.93e-13
L15 N14 Port2 1.57e-10
R15 N14 Port2 3.23e+01
.ENDS GCJ21BR71C475KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C475MA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C475MA01 Port1 Port2
C01 Port1 N01 3.03e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 9.04e-11
R03 N02 N03 2.21e-02
C04 N03 N04 1.15e-04
R04 N03 N04 4.62e+01
C05 N04 N05 1.14e-04
R05 N04 N05 5.69e+00
C06 N05 N06 9.86e-05
R06 N05 N06 8.01e-01
C07 N06 N07 8.63e-05
R07 N06 N07 8.96e-02
C08 N07 N08 4.42e-05
R08 N07 N08 1.62e-02
L09 N08 N09 1.26e-11
R09 N08 N09 5.77e-02
L10 N09 N10 6.23e-11
R10 N09 N10 5.38e-02
L11 N10 N11 4.40e-10
R11 N10 N11 2.30e-02
C12 N11 N12 2.16e-05
L12 N11 N12 2.77e-11
R12 N11 N12 4.95e-03
C13 N12 N13 1.26e-05
L13 N12 N13 2.10e-11
R13 N12 N13 5.58e-03
C14 N13 N14 2.22e-11
L14 N13 N14 4.20e-11
R14 N13 N14 5.45e+00
C15 N14 Port2 7.93e-13
L15 N14 Port2 1.57e-10
R15 N14 Port2 3.23e+01
.ENDS GCJ21BR71C475MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C564KA01
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C564KA01 Port1 Port2
C01 Port1 N01 5.49e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 8.65e-11
R03 N02 N03 9.21e-03
C04 N03 N04 8.55e-05
R04 N03 N04 6.49e+01
C05 N04 N05 6.45e-05
R05 N04 N05 1.26e+01
C06 N05 N06 6.88e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.76e-05
R07 N06 N07 1.26e-01
C08 N07 N08 3.93e-05
R08 N07 N08 2.30e-02
L09 N08 N09 2.18e-11
R09 N08 N09 6.28e-02
L10 N09 N10 2.13e-10
R10 N09 N10 5.08e-02
C11 N10 N11 2.20e-06
L11 N10 N11 3.87e-11
R11 N10 N11 1.62e-02
C12 N11 N12 9.81e-07
L12 N11 N12 3.61e-11
R12 N11 N12 1.95e-02
C13 N12 N13 1.42e-11
L13 N12 N13 7.25e-11
R13 N12 N13 8.69e+00
C14 N13 Port2 1.25e-12
L14 N13 Port2 2.14e-10
R14 N13 Port2 7.29e+01
.ENDS GCJ21BR71C564KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C684KA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BR71C684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GCJ21BR71C684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C684MA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BR71C684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E104KA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR71E104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E104MA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR71E104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E105KA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E105KA12 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BR71E105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E105MA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E105MA12 Port1 Port2
C01 Port1 N01 9.43e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.43e-11
R03 N02 N03 4.04e-02
C04 N03 N04 1.25e-04
R04 N03 N04 2.05e+01
C05 N04 N05 1.15e-04
R05 N04 N05 1.54e+00
C06 N05 N06 1.40e-04
R06 N05 N06 1.52e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.66e-02
L08 N07 N08 2.54e-11
R08 N07 N08 7.84e-02
L09 N08 N09 3.37e-10
R09 N08 N09 3.96e-02
C10 N09 N10 5.32e-06
L10 N09 N10 3.33e-11
R10 N09 N10 1.08e-02
C11 N10 N11 4.27e-06
L11 N10 N11 1.81e-11
R11 N10 N11 9.11e-03
C12 N11 N12 1.20e-11
L12 N11 N12 7.70e-11
R12 N11 N12 6.14e+00
C13 N12 Port2 9.53e-13
L13 N12 Port2 2.22e-10
R13 N12 Port2 1.04e+02
.ENDS GCJ21BR71E105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E155KA01
* Property : C = 1.50e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E155KA01 Port1 Port2
C01 Port1 N01 1.10e-06
R01 Port1 N01 3.33e+07
L02 N01 N02 1.65e-10
R03 N02 N03 8.27e-03
C04 N03 N04 4.90e-05
R04 N03 N04 1.06e+02
C05 N04 N05 3.89e-05
R05 N04 N05 1.52e+01
C06 N05 N06 3.22e-05
R06 N05 N06 1.66e+00
C07 N06 N07 2.69e-05
R07 N06 N07 1.75e-01
C08 N07 N08 1.92e-05
R08 N07 N08 1.95e-02
L09 N08 N09 2.69e-11
R09 N08 N09 5.23e-02
L10 N09 N10 1.94e-10
R10 N09 N10 3.79e-02
C11 N10 N11 3.57e-06
L11 N10 N11 4.80e-11
R11 N10 N11 1.31e-02
C12 N11 N12 1.45e-06
L12 N11 N12 5.30e-11
R12 N11 N12 1.53e-02
C13 N12 N13 2.80e-11
L13 N12 N13 4.92e-11
R13 N12 N13 5.12e+00
C14 N13 Port2 2.75e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 1.70e+01
.ENDS GCJ21BR71E155KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E225KA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E225KA01 Port1 Port2
C01 Port1 N01 1.57e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 6.49e-11
R03 N02 N03 1.55e-02
C04 N03 N04 5.87e-05
R04 N03 N04 7.90e+01
C05 N04 N05 7.09e-05
R05 N04 N05 8.35e+00
C06 N05 N06 5.81e-05
R06 N05 N06 1.55e+00
C07 N06 N07 5.58e-05
R07 N06 N07 2.24e-01
C08 N07 N08 5.62e-05
R08 N07 N08 3.55e-02
C09 N08 N09 3.74e-05
R09 N08 N09 1.48e-02
L10 N09 N10 3.77e-11
R10 N09 N10 6.92e-02
L11 N10 N11 2.85e-10
R11 N10 N11 3.18e-02
C12 N11 N12 5.95e-06
L12 N11 N12 4.50e-11
R12 N11 N12 1.03e-02
C13 N12 N13 3.14e-06
L13 N12 N13 3.84e-11
R13 N12 N13 9.12e-03
C14 N13 N14 2.70e-11
L14 N13 N14 3.97e-11
R14 N13 N14 6.67e+00
C15 N14 Port2 1.18e-12
L15 N14 Port2 2.08e-10
R15 N14 Port2 3.92e+01
.ENDS GCJ21BR71E225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E225MA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E225MA01 Port1 Port2
C01 Port1 N01 1.57e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 6.49e-11
R03 N02 N03 1.55e-02
C04 N03 N04 5.87e-05
R04 N03 N04 7.90e+01
C05 N04 N05 7.09e-05
R05 N04 N05 8.35e+00
C06 N05 N06 5.81e-05
R06 N05 N06 1.55e+00
C07 N06 N07 5.58e-05
R07 N06 N07 2.24e-01
C08 N07 N08 5.62e-05
R08 N07 N08 3.55e-02
C09 N08 N09 3.74e-05
R09 N08 N09 1.48e-02
L10 N09 N10 3.77e-11
R10 N09 N10 6.92e-02
L11 N10 N11 2.85e-10
R11 N10 N11 3.18e-02
C12 N11 N12 5.95e-06
L12 N11 N12 4.50e-11
R12 N11 N12 1.03e-02
C13 N12 N13 3.14e-06
L13 N12 N13 3.84e-11
R13 N12 N13 9.12e-03
C14 N13 N14 2.70e-11
L14 N13 N14 3.97e-11
R14 N13 N14 6.67e+00
C15 N14 Port2 1.18e-12
L15 N14 Port2 2.08e-10
R15 N14 Port2 3.92e+01
.ENDS GCJ21BR71E225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E273KA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 3.91e-02
C04 N03 N04 2.43e-06
R04 N03 N04 3.61e+03
C05 N04 N05 4.82e-06
R05 N04 N05 1.65e+02
C06 N05 N06 3.87e-06
R06 N05 N06 2.18e+01
C07 N06 N07 4.56e-06
R07 N06 N07 1.61e+00
C08 N07 N08 3.85e-05
R08 N07 N08 6.00e-01
C09 N08 N09 7.29e-06
R09 N08 N09 2.94e-01
C10 N09 N10 2.98e-06
R10 N09 N10 2.03e-01
C11 N10 N11 1.76e-06
R11 N10 N11 4.18e-02
C12 N11 N12 6.29e-06
R12 N11 N12 1.36e-03
L13 N12 N13 1.21e-10
R13 N12 N13 1.54e-01
C14 N13 N14 2.64e-07
L14 N13 N14 1.59e-11
R14 N13 N14 2.48e-02
C15 N14 N15 5.14e-08
L15 N14 N15 3.52e-11
R15 N14 N15 6.32e-02
C16 N15 N16 4.30e-11
L16 N15 N16 1.64e-10
R16 N15 N16 3.18e+00
C17 N16 Port2 1.73e-12
L17 N16 Port2 2.51e-10
R17 N16 Port2 1.29e+01
.ENDS GCJ21BR71E273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E274KA01
* Property : C = 2.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E274KA01 Port1 Port2
C01 Port1 N01 2.49e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.87e-10
R03 N02 N03 1.14e-02
C04 N03 N04 2.69e-05
R04 N03 N04 1.38e+02
C05 N04 N05 3.73e-05
R05 N04 N05 1.05e+01
C06 N05 N06 3.30e-05
R06 N05 N06 1.35e+00
C07 N06 N07 3.25e-05
R07 N06 N07 1.82e-01
C08 N07 N08 2.18e-05
R08 N07 N08 3.12e-02
C09 N08 N09 2.94e-05
R09 N08 N09 2.50e-03
L10 N09 N10 1.27e-10
R10 N09 N10 6.43e-02
L11 N10 N11 2.15e-12
R11 N10 N11 7.62e-03
C12 N11 N12 9.84e-07
L12 N11 N12 3.05e-11
R12 N11 N12 1.49e-02
C13 N12 N13 2.03e-07
L13 N12 N13 5.81e-11
R13 N12 N13 2.67e-02
C14 N13 N14 1.07e-11
L14 N13 N14 1.45e-10
R14 N13 N14 1.35e+01
C15 N14 Port2 3.19e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 2.17e+01
.ENDS GCJ21BR71E274KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E334KA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E334KA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71E334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E334MA01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E334MA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71E334MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E394KA01 Port1 Port2
C01 Port1 N01 3.89e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.02e-10
R03 N02 N03 1.02e-02
C04 N03 N04 5.63e-05
R04 N03 N04 6.09e+01
C05 N04 N05 6.40e-05
R05 N04 N05 7.84e+00
C06 N05 N06 5.41e-05
R06 N05 N06 1.03e+00
C07 N06 N07 4.50e-05
R07 N06 N07 1.21e-01
C08 N07 N08 2.75e-05
R08 N07 N08 1.47e-02
L09 N08 N09 2.33e-11
R09 N08 N09 6.19e-02
L10 N09 N10 1.85e-10
R10 N09 N10 5.26e-02
C11 N10 N11 1.85e-06
L11 N10 N11 3.08e-11
R11 N10 N11 1.77e-02
C12 N11 N12 4.89e-07
L12 N11 N12 5.28e-11
R12 N11 N12 2.33e-02
C13 N12 N13 1.38e-11
L13 N12 N13 8.02e-11
R13 N12 N13 9.52e+00
C14 N13 Port2 1.86e-12
L14 N13 Port2 1.75e-10
R14 N13 Port2 4.51e+01
.ENDS GCJ21BR71E394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E473KA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR71E473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E473MA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR71E473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E563KA01 Port1 Port2
C01 Port1 N01 5.70e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.15e-10
R03 N02 N03 3.58e-02
C04 N03 N04 7.54e-06
R04 N03 N04 7.59e+02
C05 N04 N05 1.03e-05
R05 N04 N05 7.95e+01
C06 N05 N06 7.75e-06
R06 N05 N06 9.78e+00
C07 N06 N07 7.20e-06
R07 N06 N07 9.78e-01
C08 N07 N08 5.79e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.77e-06
R09 N08 N09 2.39e-02
L10 N09 N10 8.76e-11
R10 N09 N10 8.89e-02
C11 N10 N11 4.23e-07
L11 N10 N11 1.93e-11
R11 N10 N11 1.99e-02
C12 N11 N12 7.34e-08
L12 N11 N12 2.88e-11
R12 N11 N12 2.78e-02
C13 N12 N13 1.30e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 1.41e-12
L14 N13 Port2 2.59e-10
R14 N13 Port2 2.69e+01
.ENDS GCJ21BR71E563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E564KA12
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E564KA12 Port1 Port2
C01 Port1 N01 5.49e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 8.65e-11
R03 N02 N03 9.21e-03
C04 N03 N04 8.55e-05
R04 N03 N04 6.49e+01
C05 N04 N05 6.45e-05
R05 N04 N05 1.26e+01
C06 N05 N06 6.88e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.76e-05
R07 N06 N07 1.26e-01
C08 N07 N08 3.93e-05
R08 N07 N08 2.30e-02
L09 N08 N09 2.18e-11
R09 N08 N09 6.28e-02
L10 N09 N10 2.13e-10
R10 N09 N10 5.08e-02
C11 N10 N11 2.20e-06
L11 N10 N11 3.87e-11
R11 N10 N11 1.62e-02
C12 N11 N12 9.81e-07
L12 N11 N12 3.61e-11
R12 N11 N12 1.95e-02
C13 N12 N13 1.42e-11
L13 N12 N13 7.25e-11
R13 N12 N13 8.69e+00
C14 N13 Port2 1.25e-12
L14 N13 Port2 2.14e-10
R14 N13 Port2 7.29e+01
.ENDS GCJ21BR71E564KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E683KA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR71E683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E683MA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR71E683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E684KA12
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E684KA12 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BR71E684KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E684MA12
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E684MA12 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 7.26e-11
R03 N02 N03 1.10e-02
C04 N03 N04 3.92e-05
R04 N03 N04 2.34e-01
C05 N04 N05 1.01e-04
R05 N04 N05 1.35e-02
C06 N05 N06 6.82e-05
R06 N05 N06 6.12e-03
L07 N06 N07 1.73e-11
R07 N06 N07 4.01e-02
L08 N07 N08 2.25e-10
R08 N07 N08 3.83e-02
C09 N08 N09 3.19e-06
L09 N08 N09 3.38e-11
R09 N08 N09 1.18e-02
C10 N09 N10 1.40e-06
L10 N09 N10 3.34e-11
R10 N09 N10 1.44e-02
C11 N10 N11 1.64e-11
L11 N10 N11 7.50e-11
R11 N10 N11 9.30e+00
C12 N11 Port2 1.20e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 5.88e+01
.ENDS GCJ21BR71E684MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/25[V]
* Murata P/N :GCJ21BR71E823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.41e-10
R03 N02 N03 2.29e-02
C04 N03 N04 1.09e-05
R04 N03 N04 6.44e+02
C05 N04 N05 1.36e-05
R05 N04 N05 6.01e+01
C06 N05 N06 1.18e-05
R06 N05 N06 6.90e+00
C07 N06 N07 1.07e-05
R07 N06 N07 7.56e-01
C08 N07 N08 8.74e-06
R08 N07 N08 9.04e-02
C09 N08 N09 8.05e-06
R09 N08 N09 1.69e-02
L10 N09 N10 1.27e-10
R10 N09 N10 8.60e-02
L11 N10 N11 7.88e-12
R11 N10 N11 3.18e-02
C12 N11 N12 4.70e-07
L12 N11 N12 2.56e-11
R12 N11 N12 2.82e-02
C13 N12 N13 1.14e-07
L13 N12 N13 3.75e-11
R13 N12 N13 3.58e-02
C14 N13 N14 9.33e-12
L14 N13 N14 1.12e-10
R14 N13 N14 1.21e+01
C15 N14 Port2 1.86e-12
L15 N14 Port2 1.74e-10
R15 N14 Port2 3.13e+01
.ENDS GCJ21BR71E823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-01[uF]/25[V]
* Murata P/N :GCJ21BR71E824KA12
* Property : C = 8.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E824KA12 Port1 Port2
C01 Port1 N01 7.85e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 6.30e-11
R03 N02 N03 7.52e-03
C04 N03 N04 9.42e-05
R04 N03 N04 4.22e+01
C05 N04 N05 1.33e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.06e-04
R06 N05 N06 6.25e-01
C07 N06 N07 9.02e-05
R07 N06 N07 7.86e-02
C08 N07 N08 7.08e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.04e-11
R09 N08 N09 4.37e-02
L10 N09 N10 2.17e-10
R10 N09 N10 4.25e-02
C11 N10 N11 2.85e-06
L11 N10 N11 4.65e-11
R11 N10 N11 1.26e-02
C12 N11 N12 1.15e-06
L12 N11 N12 4.98e-11
R12 N11 N12 1.47e-02
C13 N12 N13 2.02e-11
L13 N12 N13 5.75e-11
R13 N12 N13 7.30e+00
C14 N13 Port2 1.14e-12
L14 N13 Port2 2.30e-10
R14 N13 Port2 4.53e+01
.ENDS GCJ21BR71E824KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H104KA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR71H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H104MA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR71H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H124KA01 Port1 Port2
C01 Port1 N01 1.28e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 3.61e-11
R03 N02 N03 1.52e-02
C04 N03 N04 1.75e-05
R04 N03 N04 3.17e+02
C05 N04 N05 1.82e-05
R05 N04 N05 4.38e+01
C06 N05 N06 1.65e-05
R06 N05 N06 4.91e+00
C07 N06 N07 1.63e-05
R07 N06 N07 5.15e-01
C08 N07 N08 1.17e-05
R08 N07 N08 8.30e-02
C09 N08 N09 7.64e-06
R09 N08 N09 1.05e-02
L10 N09 N10 1.37e-10
R10 N09 N10 7.79e-02
C11 N10 N11 4.62e-07
L11 N10 N11 3.55e-11
R11 N10 N11 2.38e-02
C12 N11 N12 1.88e-07
L12 N11 N12 3.20e-11
R12 N11 N12 2.91e-02
C13 N12 N13 1.85e-11
L13 N12 N13 8.48e-11
R13 N12 N13 1.09e+01
C14 N13 Port2 8.70e-13
L14 N13 Port2 3.28e-10
R14 N13 Port2 4.41e+01
.ENDS GCJ21BR71H124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H154KA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BR71H154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H154MA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H154MA01 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 5.47e-11
R03 N02 N03 3.09e-02
C04 N03 N04 9.17e-06
R04 N03 N04 1.12e+00
C05 N04 N05 1.40e-05
R05 N04 N05 7.06e-02
C06 N05 N06 9.71e-06
R06 N05 N06 1.76e-02
L07 N06 N07 1.62e-10
R07 N06 N07 7.07e-02
L08 N07 N08 1.02e-11
R08 N07 N08 4.14e-02
C09 N08 N09 5.98e-07
L09 N08 N09 3.41e-11
R09 N08 N09 2.60e-02
C10 N09 N10 2.78e-07
L10 N09 N10 2.96e-11
R10 N09 N10 2.95e-02
C11 N10 N11 1.83e-11
L11 N10 N11 6.92e-11
R11 N10 N11 7.62e+00
C12 N11 Port2 9.79e-13
L12 N11 Port2 2.76e-10
R12 N11 Port2 5.35e+01
.ENDS GCJ21BR71H154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H184KA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BR71H184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H184MA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H184MA01 Port1 Port2
C01 Port1 N01 1.82e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 5.57e-11
R03 N02 N03 1.96e-02
C04 N03 N04 1.57e-05
R04 N03 N04 8.08e-01
C05 N04 N05 1.80e-05
R05 N04 N05 8.85e-02
C06 N05 N06 1.26e-05
R06 N05 N06 2.03e-02
L07 N06 N07 1.59e-10
R07 N06 N07 6.30e-02
L08 N07 N08 6.14e-12
R08 N07 N08 2.73e-02
C09 N08 N09 1.13e-06
L09 N08 N09 2.20e-11
R09 N08 N09 1.65e-02
C10 N09 N10 3.29e-07
L10 N09 N10 3.26e-11
R10 N09 N10 2.40e-02
C11 N10 N11 2.62e-11
L11 N10 N11 6.14e-11
R11 N10 N11 7.96e+00
C12 N11 Port2 8.29e-13
L12 N11 Port2 3.09e-10
R12 N11 Port2 5.41e+01
.ENDS GCJ21BR71H184MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H224KA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BR71H224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H224MA01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 9.32e-11
R03 N02 N03 8.10e-02
C04 N03 N04 1.27e-05
R04 N03 N04 2.35e-01
C05 N04 N05 2.07e-05
R05 N04 N05 1.79e-02
L06 N05 N06 1.65e-10
R06 N05 N06 8.39e-02
C07 N06 N07 6.71e-07
L07 N06 N07 4.80e-11
R07 N06 N07 2.92e-02
C08 N07 N08 3.37e-07
L08 N07 N08 4.00e-11
R08 N07 N08 3.42e-02
C09 N08 N09 1.35e-11
L09 N08 N09 8.82e-11
R09 N08 N09 8.94e+00
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.88e-10
R10 N09 Port2 3.09e+01
.ENDS GCJ21BR71H224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H334KA12
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H334KA12 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71H334KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H334MA12
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H334MA12 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.58e-01
C05 N04 N05 1.98e-05
R05 N04 N05 1.81e-02
L06 N05 N06 2.17e-10
R06 N05 N06 5.38e-02
L07 N06 N07 1.59e-11
R07 N06 N07 4.72e-02
C08 N07 N08 1.20e-06
L08 N07 N08 4.33e-11
R08 N07 N08 2.07e-02
C09 N08 N09 8.08e-07
L09 N08 N09 2.71e-11
R09 N08 N09 2.30e-02
C10 N09 N10 2.62e-11
L10 N09 N10 4.49e-11
R10 N09 N10 6.04e+00
C11 N10 Port2 1.79e-12
L11 N10 Port2 1.85e-10
R11 N10 Port2 3.68e+01
.ENDS GCJ21BR71H334MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H473KA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR71H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H473MA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR71H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H563KA01 Port1 Port2
C01 Port1 N01 5.70e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.15e-10
R03 N02 N03 3.58e-02
C04 N03 N04 7.54e-06
R04 N03 N04 7.59e+02
C05 N04 N05 1.03e-05
R05 N04 N05 7.95e+01
C06 N05 N06 7.75e-06
R06 N05 N06 9.78e+00
C07 N06 N07 7.20e-06
R07 N06 N07 9.78e-01
C08 N07 N08 5.79e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.77e-06
R09 N08 N09 2.39e-02
L10 N09 N10 8.76e-11
R10 N09 N10 8.89e-02
C11 N10 N11 4.23e-07
L11 N10 N11 1.93e-11
R11 N10 N11 1.99e-02
C12 N11 N12 7.34e-08
L12 N11 N12 2.88e-11
R12 N11 N12 2.78e-02
C13 N12 N13 1.30e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 1.41e-12
L14 N13 Port2 2.59e-10
R14 N13 Port2 2.69e+01
.ENDS GCJ21BR71H563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H683KA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR71H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H683MA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR71H683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.41e-10
R03 N02 N03 2.29e-02
C04 N03 N04 1.09e-05
R04 N03 N04 6.44e+02
C05 N04 N05 1.36e-05
R05 N04 N05 6.01e+01
C06 N05 N06 1.18e-05
R06 N05 N06 6.90e+00
C07 N06 N07 1.07e-05
R07 N06 N07 7.56e-01
C08 N07 N08 8.74e-06
R08 N07 N08 9.04e-02
C09 N08 N09 8.05e-06
R09 N08 N09 1.69e-02
L10 N09 N10 1.27e-10
R10 N09 N10 8.60e-02
L11 N10 N11 7.88e-12
R11 N10 N11 3.18e-02
C12 N11 N12 4.70e-07
L12 N11 N12 2.56e-11
R12 N11 N12 2.82e-02
C13 N12 N13 1.14e-07
L13 N12 N13 3.75e-11
R13 N12 N13 3.58e-02
C14 N13 N14 9.33e-12
L14 N13 N14 1.12e-10
R14 N13 N14 1.21e+01
C15 N14 Port2 1.86e-12
L15 N14 Port2 1.74e-10
R15 N14 Port2 3.13e+01
.ENDS GCJ21BR71H823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ21BR72A104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A104KA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR72A104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ21BR72A104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A104MA01 Port1 Port2
C01 Port1 N01 9.68e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 8.87e-02
C04 N03 N04 5.91e-06
R04 N03 N04 8.33e-01
C05 N04 N05 6.80e-06
R05 N04 N05 6.53e-02
L06 N05 N06 2.34e-10
R06 N05 N06 9.21e-02
L07 N06 N07 1.50e-11
R07 N06 N07 6.26e-02
C08 N07 N08 7.96e-07
L08 N07 N08 1.82e-11
R08 N07 N08 2.58e-02
C09 N08 N09 3.17e-07
L09 N08 N09 2.06e-11
R09 N08 N09 2.70e-02
C10 N09 N10 1.34e-11
L10 N09 N10 6.80e-11
R10 N09 N10 9.58e+00
C11 N10 Port2 2.01e-12
L11 N10 Port2 1.75e-10
R11 N10 Port2 2.36e+01
.ENDS GCJ21BR72A104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A473KA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR72A473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A473MA01 Port1 Port2
C01 Port1 N01 4.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 2.75e-06
R04 N03 N04 1.05e+00
C05 N04 N05 3.39e-06
R05 N04 N05 9.59e-02
L06 N05 N06 1.48e-10
R06 N05 N06 1.72e-01
C07 N06 N07 3.07e-07
L07 N06 N07 1.97e-11
R07 N06 N07 4.20e-02
C08 N07 N08 8.12e-08
L08 N07 N08 2.99e-11
R08 N07 N08 5.19e-02
C09 N08 N09 5.33e-11
L09 N08 N09 1.52e-10
R09 N08 N09 2.37e+00
C10 N09 Port2 2.14e-12
L10 N09 Port2 1.71e-10
R10 N09 Port2 1.62e+01
.ENDS GCJ21BR72A473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A563KA01 Port1 Port2
C01 Port1 N01 5.70e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.15e-10
R03 N02 N03 3.58e-02
C04 N03 N04 7.54e-06
R04 N03 N04 7.59e+02
C05 N04 N05 1.03e-05
R05 N04 N05 7.95e+01
C06 N05 N06 7.75e-06
R06 N05 N06 9.78e+00
C07 N06 N07 7.20e-06
R07 N06 N07 9.78e-01
C08 N07 N08 5.79e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.77e-06
R09 N08 N09 2.39e-02
L10 N09 N10 8.76e-11
R10 N09 N10 8.89e-02
C11 N10 N11 4.23e-07
L11 N10 N11 1.93e-11
R11 N10 N11 1.99e-02
C12 N11 N12 7.34e-08
L12 N11 N12 2.88e-11
R12 N11 N12 2.78e-02
C13 N12 N13 1.30e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 1.41e-12
L14 N13 Port2 2.59e-10
R14 N13 Port2 2.69e+01
.ENDS GCJ21BR72A563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A683KA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR72A683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A683MA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.70e-11
R03 N02 N03 2.51e-02
C04 N03 N04 7.22e-06
R04 N03 N04 7.13e-01
C05 N04 N05 7.75e-06
R05 N04 N05 1.95e-01
C06 N05 N06 8.01e-06
R06 N05 N06 3.58e-02
C07 N06 N07 5.84e-06
R07 N06 N07 1.33e-02
L08 N07 N08 8.52e-11
R08 N07 N08 1.24e-01
C09 N08 N09 2.92e-07
L09 N08 N09 4.28e-11
R09 N08 N09 3.86e-02
C10 N09 N10 3.11e-08
L10 N09 N10 7.05e-11
R10 N09 N10 4.48e-02
C11 N10 N11 1.47e-11
L11 N10 N11 6.42e-11
R11 N10 N11 8.41e+00
C12 N11 Port2 9.14e-13
L12 N11 Port2 2.82e-10
R12 N11 Port2 5.95e+01
.ENDS GCJ21BR72A683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.41e-10
R03 N02 N03 2.29e-02
C04 N03 N04 1.09e-05
R04 N03 N04 6.44e+02
C05 N04 N05 1.36e-05
R05 N04 N05 6.01e+01
C06 N05 N06 1.18e-05
R06 N05 N06 6.90e+00
C07 N06 N07 1.07e-05
R07 N06 N07 7.56e-01
C08 N07 N08 8.74e-06
R08 N07 N08 9.04e-02
C09 N08 N09 8.05e-06
R09 N08 N09 1.69e-02
L10 N09 N10 1.27e-10
R10 N09 N10 8.60e-02
L11 N10 N11 7.88e-12
R11 N10 N11 3.18e-02
C12 N11 N12 4.70e-07
L12 N11 N12 2.56e-11
R12 N11 N12 2.82e-02
C13 N12 N13 1.14e-07
L13 N12 N13 3.75e-11
R13 N12 N13 3.58e-02
C14 N13 N14 9.33e-12
L14 N13 N14 1.12e-10
R14 N13 N14 1.21e+01
C15 N14 Port2 1.86e-12
L15 N14 Port2 1.74e-10
R15 N14 Port2 3.13e+01
.ENDS GCJ21BR72A823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E103KXJ3
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E103KXJ3 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 7.72e-02
C04 N03 N04 5.33e-07
R04 N03 N04 2.98e+00
C05 N04 N05 6.56e-07
R05 N04 N05 2.43e-01
C06 N05 N06 4.86e-07
R06 N05 N06 4.41e-02
L07 N06 N07 8.35e-11
R07 N06 N07 1.78e-01
C08 N07 N08 3.42e-08
L08 N07 N08 1.66e-11
R08 N07 N08 4.61e-02
C09 N08 Port2 2.91e-12
L09 N08 Port2 3.09e-10
R09 N08 Port2 3.26e+01
.ENDS GCJ21BR72E103KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E153KXJ3
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E153KXJ3 Port1 Port2
C01 Port1 N01 1.35e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 2.85e-10
R03 N02 N03 6.46e-02
C04 N03 N04 5.24e-07
R04 N03 N04 7.62e+00
C05 N04 N05 1.10e-06
R05 N04 N05 2.90e-01
C06 N05 N06 1.17e-06
R06 N05 N06 4.81e-02
C07 N06 N07 1.17e-06
R07 N06 N07 1.36e-02
L08 N07 N08 6.96e-11
R08 N07 N08 2.09e-01
L09 N08 N09 6.80e-12
R09 N08 N09 9.12e-02
C10 N09 N10 1.06e-08
L10 N09 N10 5.14e-11
R10 N09 N10 6.97e-02
C11 N10 Port2 4.83e-12
L11 N10 Port2 2.70e-10
R11 N10 Port2 2.59e+01
.ENDS GCJ21BR72E153KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E223KXJ3
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E223KXJ3 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 2.46e-10
R03 N02 N03 4.90e-02
C04 N03 N04 1.18e-06
R04 N03 N04 2.13e+00
C05 N04 N05 1.97e-06
R05 N04 N05 1.62e-01
C06 N05 N06 1.30e-06
R06 N05 N06 4.35e-02
L07 N06 N07 7.92e-11
R07 N06 N07 1.61e-01
C08 N07 N08 3.28e-08
L08 N07 N08 3.29e-11
R08 N07 N08 5.02e-02
C09 N08 Port2 4.23e-12
L09 N08 Port2 1.94e-10
R09 N08 Port2 2.24e+01
.ENDS GCJ21BR72E223KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ319R71H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ319R71H104KA01 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GCJ319R71H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ319R71H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ319R71H104MA01 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GCJ319R71H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ319R72A104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ319R72A104KA01 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GCJ319R72A104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ319R72A104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ319R72A104MA01 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.41e-10
R03 N02 N03 6.20e-02
C04 N03 N04 7.69e-06
R04 N03 N04 1.00e+00
C05 N04 N05 1.35e-05
R05 N04 N05 9.84e-02
C06 N05 N06 8.42e-06
R06 N05 N06 3.63e-02
L07 N06 N07 1.50e-10
R07 N06 N07 1.22e-01
C08 N07 N08 3.38e-07
L08 N07 N08 2.98e-11
R08 N07 N08 1.56e-02
C09 N08 N09 1.12e-07
L09 N08 N09 3.12e-11
R09 N08 N09 2.32e-02
C10 N09 N10 9.45e-12
L10 N09 N10 1.10e-10
R10 N09 N10 1.47e+01
C11 N10 Port2 7.78e-13
L11 N10 Port2 3.95e-10
R11 N10 Port2 6.57e+01
.ENDS GCJ319R72A104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GCJ31BR72E153KXJ1
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72E153KXJ1 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 1.88e-10
R03 N02 N03 9.66e-02
C04 N03 N04 7.66e-07
R04 N03 N04 2.03e+00
C05 N04 N05 7.15e-07
R05 N04 N05 1.31e-01
L06 N05 N06 9.91e-11
R06 N05 N06 1.71e-01
C07 N06 N07 5.85e-12
L07 N06 N07 3.52e-10
R07 N06 N07 2.95e+01
C08 N07 Port2 2.74e-12
L08 N07 Port2 3.29e-10
R08 N07 Port2 3.46e+01
.ENDS GCJ31BR72E153KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GCJ31BR72E223KXJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72E223KXJ1 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 2.95e-10
R03 N02 N03 6.42e-02
C04 N03 N04 1.65e-06
R04 N03 N04 9.63e-01
C05 N04 N05 2.08e-06
R05 N04 N05 1.75e-01
C06 N05 N06 1.09e-06
R06 N05 N06 4.20e-02
L07 N06 N07 1.08e-10
R07 N06 N07 3.23e-01
L08 N07 N08 2.05e-11
R08 N07 N08 3.16e-02
C09 N08 N09 1.79e-08
L09 N08 N09 5.26e-11
R09 N08 N09 5.42e-02
C10 N09 Port2 3.74e-12
L10 N09 Port2 4.58e-10
R10 N09 Port2 7.15e+01
.ENDS GCJ31BR72E223KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GCJ31BR72E683KXJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72E683KXJ1 Port1 Port2
C01 Port1 N01 6.78e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 4.62e-10
R03 N02 N03 3.46e-02
C04 N03 N04 4.52e-06
R04 N03 N04 3.52e-01
C05 N04 N05 8.23e-06
R05 N04 N05 3.07e-02
C06 N05 N06 9.02e-06
R06 N05 N06 1.34e-02
L07 N06 N07 3.17e-11
R07 N06 N07 1.69e-01
L08 N07 N08 1.48e-10
R08 N07 N08 1.02e-01
C09 N08 N09 9.76e-08
L09 N08 N09 4.84e-11
R09 N08 N09 3.15e-02
C10 N09 Port2 9.54e-12
L10 N09 Port2 1.80e-10
R10 N09 Port2 1.37e+01
.ENDS GCJ31BR72E683KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J102KXJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J102KXJ1 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.01e-10
R03 N02 N03 2.49e-01
C04 N03 N04 1.23e-08
R04 N03 N04 2.05e+02
C05 N04 N05 2.09e-07
R05 N04 N05 1.91e+00
C06 N05 N06 7.94e-08
R06 N05 N06 1.27e+00
C07 N06 N07 3.31e-08
R07 N06 N07 4.49e-01
C08 N07 N08 6.60e-09
R08 N07 N08 2.36e-01
L09 N08 N09 1.32e-10
R09 N08 N09 1.69e+00
C10 N09 N10 5.86e-10
L10 N09 N10 6.71e-11
R10 N09 N10 5.36e-01
C11 N10 Port2 3.45e-12
L11 N10 Port2 3.60e-10
R11 N10 Port2 2.29e+01
.ENDS GCJ31BR72J102KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GCJ31BR72J103KXJ1
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J103KXJ1 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.88e-10
R03 N02 N03 6.53e-02
C04 N03 N04 5.19e-07
R04 N03 N04 4.86e+00
C05 N04 N05 1.25e-06
R05 N04 N05 2.79e-01
C06 N05 N06 1.01e-06
R06 N05 N06 9.92e-02
C07 N06 N07 4.03e-07
R07 N06 N07 4.64e-02
L08 N07 N08 1.39e-10
R08 N07 N08 5.52e-01
C09 N08 N09 6.45e-08
L09 N08 N09 2.11e-11
R09 N08 N09 5.72e-02
C10 N09 N10 8.70e-09
L10 N09 N10 5.68e-11
R10 N09 N10 1.28e-01
C11 N10 Port2 5.49e-12
L11 N10 Port2 2.37e-10
R11 N10 Port2 2.13e+01
.ENDS GCJ31BR72J103KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J152KXJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J152KXJ1 Port1 Port2
C01 Port1 N01 1.53e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.56e-10
R03 N02 N03 2.45e-01
C04 N03 N04 3.23e-08
R04 N03 N04 6.96e+01
C05 N04 N05 2.09e-07
R05 N04 N05 6.06e+00
C06 N05 N06 2.24e-07
R06 N05 N06 7.12e-01
C07 N06 N07 2.40e-07
R07 N06 N07 4.19e-01
C08 N07 N08 6.30e-08
R08 N07 N08 3.25e-01
C09 N08 N09 8.50e-09
R09 N08 N09 1.67e-01
L10 N09 N10 2.57e-10
R10 N09 N10 3.45e+00
C11 N10 Port2 1.01e-11
L11 N10 Port2 2.56e-10
R11 N10 Port2 1.59e+01
.ENDS GCJ31BR72J152KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J222KXJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J222KXJ1 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.77e-10
R03 N02 N03 1.69e-01
C04 N03 N04 5.36e-08
R04 N03 N04 4.10e+01
C05 N04 N05 4.67e-07
R05 N04 N05 6.80e-01
C06 N05 N06 1.48e-07
R06 N05 N06 6.80e-01
C07 N06 N07 9.76e-08
R07 N06 N07 1.63e-01
C08 N07 N08 3.09e-08
R08 N07 N08 1.01e-01
L09 N08 N09 8.10e-11
R09 N08 N09 1.40e+00
C10 N09 N10 1.17e-08
L10 N09 N10 1.53e-11
R10 N09 N10 8.10e-02
C11 N10 N11 1.77e-09
L11 N10 N11 3.35e-11
R11 N10 N11 2.18e-01
C12 N11 Port2 6.90e-12
L12 N11 Port2 2.99e-10
R12 N11 Port2 2.08e+01
.ENDS GCJ31BR72J222KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J332KXJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J332KXJ1 Port1 Port2
C01 Port1 N01 3.29e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.37e-10
R03 N02 N03 1.12e-01
C04 N03 N04 1.02e-07
R04 N03 N04 1.83e+01
C05 N04 N05 2.62e-07
R05 N04 N05 6.07e-01
C06 N05 N06 1.69e-07
R06 N05 N06 2.15e-01
C07 N06 N07 3.01e-08
R07 N06 N07 8.57e-02
L08 N07 N08 1.52e-10
R08 N07 N08 8.29e-01
C09 N08 N09 1.94e-09
L09 N08 N09 4.86e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 5.59e-12
L10 N09 Port2 3.36e-10
R10 N09 Port2 2.45e+01
.ENDS GCJ31BR72J332KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J472KXJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J472KXJ1 Port1 Port2
C01 Port1 N01 4.72e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.93e-10
R03 N02 N03 9.50e-02
C04 N03 N04 1.91e-07
R04 N03 N04 9.56e+00
C05 N04 N05 5.77e-07
R05 N04 N05 5.50e-01
C06 N05 N06 2.25e-07
R06 N05 N06 2.46e-01
C07 N06 N07 7.10e-08
R07 N06 N07 6.46e-02
L08 N07 N08 1.82e-10
R08 N07 N08 6.41e-01
C09 N08 N09 7.01e-08
L09 N08 N09 8.10e-12
R09 N08 N09 3.40e-02
C10 N09 N10 6.25e-09
L10 N09 N10 2.74e-11
R10 N09 N10 1.32e-01
C11 N10 Port2 5.83e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.70e+01
.ENDS GCJ31BR72J472KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J682KXJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J682KXJ1 Port1 Port2
C01 Port1 N01 6.83e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.74e-10
R03 N02 N03 9.84e-02
C04 N03 N04 3.31e-07
R04 N03 N04 4.81e+00
C05 N04 N05 4.07e-07
R05 N04 N05 3.91e-01
C06 N05 N06 2.34e-07
R06 N05 N06 7.12e-02
L07 N06 N07 9.84e-11
R07 N06 N07 4.79e-01
C08 N07 N08 4.96e-08
L08 N07 N08 1.38e-11
R08 N07 N08 4.19e-02
C09 N08 N09 8.42e-09
L09 N08 N09 2.45e-11
R09 N08 N09 1.08e-01
C10 N09 Port2 7.68e-12
L10 N09 Port2 2.81e-10
R10 N09 Port2 2.20e+01
.ENDS GCJ31BR72J682KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A102KXJ1
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A102KXJ1 Port1 Port2
C01 Port1 N01 1.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.80e-10
R03 N02 N03 2.90e-01
C04 N03 N04 1.35e-08
R04 N03 N04 1.82e+02
C05 N04 N05 1.05e-07
R05 N04 N05 1.62e+00
C06 N05 N06 7.79e-08
R06 N05 N06 5.13e-01
C07 N06 N07 3.90e-08
R07 N06 N07 2.57e-01
C08 N07 N08 8.94e-09
R08 N07 N08 1.74e-01
C09 N08 N09 4.17e-10
L09 N08 N09 7.14e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 2.63e-12
L10 N09 Port2 4.51e-10
R10 N09 Port2 2.61e+01
.ENDS GCJ31BR73A102KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A152KXJ1
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A152KXJ1 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.68e-10
R03 N02 N03 2.22e-01
C04 N03 N04 2.66e-08
R04 N03 N04 9.69e+01
C05 N04 N05 4.85e-07
R05 N04 N05 1.65e+00
C06 N05 N06 1.01e-07
R06 N05 N06 1.14e+00
C07 N06 N07 5.69e-08
R07 N06 N07 2.80e-01
C08 N07 N08 2.16e-08
R08 N07 N08 1.06e-01
L09 N08 N09 1.76e-10
R09 N08 N09 2.36e+00
C10 N09 N10 1.95e-09
L10 N09 N10 1.92e-11
R10 N09 N10 2.27e-01
C11 N10 Port2 7.59e-12
L11 N10 Port2 2.71e-10
R11 N10 Port2 2.17e+01
.ENDS GCJ31BR73A152KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A222KXJ1
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A222KXJ1 Port1 Port2
C01 Port1 N01 2.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-10
R03 N02 N03 2.12e-01
C04 N03 N04 4.34e-08
R04 N03 N04 5.81e+01
C05 N04 N05 1.20e-07
R05 N04 N05 1.03e+00
C06 N05 N06 9.72e-08
R06 N05 N06 1.64e-01
C07 N06 N07 3.45e-08
R07 N06 N07 1.03e-01
C08 N07 N08 9.15e-10
L08 N07 N08 5.66e-11
R08 N07 N08 2.49e-01
C09 N08 Port2 5.51e-12
L09 N08 Port2 3.74e-10
R09 N08 Port2 2.07e+01
.ENDS GCJ31BR73A222KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A332KXJ1
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A332KXJ1 Port1 Port2
C01 Port1 N01 3.41e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.65e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.11e-07
R04 N03 N04 1.57e+01
C05 N04 N05 2.38e-07
R05 N04 N05 6.70e-01
C06 N05 N06 1.93e-06
R06 N05 N06 4.13e-01
C07 N06 N07 2.22e-07
R07 N06 N07 1.43e-01
C08 N07 N08 6.25e-08
R08 N07 N08 9.68e-02
C09 N08 N09 1.86e-09
L09 N08 N09 3.05e-11
R09 N08 N09 1.37e-01
C10 N09 Port2 5.88e-12
L10 N09 Port2 4.41e-10
R10 N09 Port2 2.50e+01
.ENDS GCJ31BR73A332KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A472KXJ1
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A472KXJ1 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.99e-10
R03 N02 N03 1.09e-01
C04 N03 N04 1.88e-07
R04 N03 N04 8.65e+00
C05 N04 N05 4.12e-07
R05 N04 N05 4.14e-01
C06 N05 N06 2.32e-07
R06 N05 N06 1.34e-01
C07 N06 N07 1.19e-07
R07 N06 N07 2.80e-02
L08 N07 N08 1.29e-10
R08 N07 N08 9.58e-01
C09 N08 N09 5.72e-08
L09 N08 N09 9.93e-12
R09 N08 N09 5.25e-02
C10 N09 N10 2.87e-09
L10 N09 N10 5.98e-11
R10 N09 N10 1.99e-01
C11 N10 Port2 5.85e-12
L11 N10 Port2 2.67e-10
R11 N10 Port2 2.63e+01
.ENDS GCJ31BR73A472KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GCJ31CC71E106KA15
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71E106KA15 Port1 Port2
C01 Port1 N01 9.40e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.57e-10
R03 N02 N03 1.59e-02
C04 N03 N04 1.42e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.80e-03
R05 N04 N05 4.63e-01
C06 N05 N06 1.83e-03
R06 N05 N06 8.71e-02
C07 N06 N07 1.05e-03
R07 N06 N07 1.66e-02
L08 N07 N08 1.66e-11
R08 N07 N08 6.02e-02
L09 N08 N09 8.57e-11
R09 N08 N09 4.07e-02
L10 N09 N10 7.72e-10
R10 N09 N10 1.87e-02
C11 N10 N11 5.02e-05
L11 N10 N11 6.97e-11
R11 N10 N11 6.67e-03
C12 N11 N12 3.64e-05
L12 N11 N12 4.43e-11
R12 N11 N12 4.86e-03
C13 N12 N13 1.15e-11
L13 N12 N13 6.09e-11
R13 N12 N13 5.47e+00
C14 N13 Port2 1.81e-12
L14 N13 Port2 1.77e-10
R14 N13 Port2 8.13e+01
.ENDS GCJ31CC71E106KA15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GCJ31CC71E106MA15
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71E106MA15 Port1 Port2
C01 Port1 N01 9.40e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.57e-10
R03 N02 N03 1.59e-02
C04 N03 N04 1.42e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.80e-03
R05 N04 N05 4.63e-01
C06 N05 N06 1.83e-03
R06 N05 N06 8.71e-02
C07 N06 N07 1.05e-03
R07 N06 N07 1.66e-02
L08 N07 N08 1.66e-11
R08 N07 N08 6.02e-02
L09 N08 N09 8.57e-11
R09 N08 N09 4.07e-02
L10 N09 N10 7.72e-10
R10 N09 N10 1.87e-02
C11 N10 N11 5.02e-05
L11 N10 N11 6.97e-11
R11 N10 N11 6.67e-03
C12 N11 N12 3.64e-05
L12 N11 N12 4.43e-11
R12 N11 N12 4.86e-03
C13 N12 N13 1.15e-11
L13 N12 N13 6.09e-11
R13 N12 N13 5.47e+00
C14 N13 Port2 1.81e-12
L14 N13 Port2 1.77e-10
R14 N13 Port2 8.13e+01
.ENDS GCJ31CC71E106MA15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ31CC71H475KA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71H475KA01 Port1 Port2
C01 Port1 N01 4.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.69e-10
R03 N02 N03 8.39e-03
C04 N03 N04 9.18e-04
R04 N03 N04 1.15e+01
C05 N04 N05 8.38e-04
R05 N04 N05 1.13e+00
C06 N05 N06 7.94e-04
R06 N05 N06 1.71e-01
C07 N06 N07 8.78e-04
R07 N06 N07 2.21e-02
C08 N07 N08 5.92e-04
R08 N07 N08 5.54e-03
L09 N08 N09 1.69e-11
R09 N08 N09 1.02e-01
L10 N09 N10 5.67e-11
R10 N09 N10 4.31e-02
L11 N10 N11 5.68e-10
R11 N10 N11 2.59e-02
C12 N11 N12 1.59e-05
L12 N11 N12 9.84e-11
R12 N11 N12 8.58e-03
C13 N12 N13 1.35e-05
L13 N12 N13 5.25e-11
R13 N12 N13 7.19e-03
C14 N13 N14 4.71e-11
L14 N13 N14 2.22e-11
R14 N13 N14 2.36e+00
C15 N14 Port2 1.50e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 7.70e+01
.ENDS GCJ31CC71H475KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ31CC71H475MA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71H475MA01 Port1 Port2
C01 Port1 N01 4.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.69e-10
R03 N02 N03 8.39e-03
C04 N03 N04 9.18e-04
R04 N03 N04 1.15e+01
C05 N04 N05 8.38e-04
R05 N04 N05 1.13e+00
C06 N05 N06 7.94e-04
R06 N05 N06 1.71e-01
C07 N06 N07 8.78e-04
R07 N06 N07 2.21e-02
C08 N07 N08 5.92e-04
R08 N07 N08 5.54e-03
L09 N08 N09 1.69e-11
R09 N08 N09 1.02e-01
L10 N09 N10 5.67e-11
R10 N09 N10 4.31e-02
L11 N10 N11 5.68e-10
R11 N10 N11 2.59e-02
C12 N11 N12 1.59e-05
L12 N11 N12 9.84e-11
R12 N11 N12 8.58e-03
C13 N12 N13 1.35e-05
L13 N12 N13 5.25e-11
R13 N12 N13 7.19e-03
C14 N13 N14 4.71e-11
L14 N13 N14 2.22e-11
R14 N13 N14 2.36e+00
C15 N14 Port2 1.50e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 7.70e+01
.ENDS GCJ31CC71H475MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ31CC72A225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC72A225KE01 Port1 Port2
C01 Port1 N01 2.08e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 3.71e-12
R03 N02 N03 6.58e-03
C04 N03 N04 2.78e-04
R04 N03 N04 1.91e+01
C05 N04 N05 2.16e-04
R05 N04 N05 3.13e+00
C06 N05 N06 1.70e-04
R06 N05 N06 5.30e-01
C07 N06 N07 1.87e-04
R07 N06 N07 5.22e-02
C08 N07 N08 1.20e-04
R08 N07 N08 9.04e-03
L09 N08 N09 4.37e-11
R09 N08 N09 7.05e-02
L10 N09 N10 3.56e-10
R10 N09 N10 3.33e-02
C11 N10 N11 5.95e-06
L11 N10 N11 9.34e-11
R11 N10 N11 1.28e-02
C12 N11 N12 2.57e-06
L12 N11 N12 8.89e-11
R12 N11 N12 1.21e-02
C13 N12 N13 1.67e-11
L13 N12 N13 7.73e-11
R13 N12 N13 8.70e+00
C14 N13 Port2 8.49e-13
L14 N13 Port2 4.02e-10
R14 N13 Port2 1.68e+02
.ENDS GCJ31CC72A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ31CL81C475KA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81C475KA01 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CL81C475KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ31CL81C475MA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81C475MA01 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CL81C475MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ31CL81E105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E105KA01 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CL81E105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ31CL81E105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E105MA01 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CL81E105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/5.60e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E564KA01
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E564KA01 Port1 Port2
C01 Port1 N01 5.47e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.19e-10
R03 N02 N03 9.29e-03
C04 N03 N04 7.92e-05
R04 N03 N04 2.93e+01
C05 N04 N05 8.33e-05
R05 N04 N05 3.86e+00
C06 N05 N06 7.01e-05
R06 N05 N06 4.43e-01
C07 N06 N07 1.12e-04
R07 N06 N07 4.33e-02
C08 N07 N08 3.87e-05
R08 N07 N08 2.45e-02
L09 N08 N09 1.42e-11
R09 N08 N09 6.03e-02
L10 N09 N10 2.83e-10
R10 N09 N10 5.57e-02
C11 N10 N11 2.41e-06
L11 N10 N11 5.12e-11
R11 N10 N11 1.91e-02
C12 N11 N12 8.27e-07
L12 N11 N12 6.00e-11
R12 N11 N12 2.09e-02
C13 N12 N13 1.41e-11
L13 N12 N13 1.48e-10
R13 N12 N13 2.60e+01
C14 N13 N14 3.48e-12
L14 N13 N14 2.86e-10
R14 N13 N14 5.05e+01
C15 N14 Port2 2.16e-12
L15 N14 Port2 1.58e-10
R15 N14 Port2 1.81e+01
.ENDS GCJ31CL81E564KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E684KA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CL81E684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E684MA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CL81E684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/8.20e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E824KA01
* Property : C = 8.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E824KA01 Port1 Port2
C01 Port1 N01 8.03e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 1.90e-10
R03 N02 N03 7.46e-03
C04 N03 N04 9.89e-05
R04 N03 N04 2.49e+01
C05 N04 N05 1.27e-04
R05 N04 N05 1.98e+00
C06 N05 N06 1.24e-04
R06 N05 N06 2.55e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.36e-02
C08 N07 N08 6.51e-05
R08 N07 N08 1.67e-02
L09 N08 N09 2.58e-11
R09 N08 N09 5.48e-02
L10 N09 N10 3.30e-10
R10 N09 N10 4.91e-02
C11 N10 N11 2.74e-06
L11 N10 N11 7.07e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.33e-06
L12 N11 N12 6.09e-11
R12 N11 N12 1.94e-02
C13 N12 N13 9.71e-12
L13 N12 N13 1.53e-10
R13 N12 N13 1.96e+01
C14 N13 Port2 2.49e-12
L14 N13 Port2 2.94e-10
R14 N13 Port2 6.19e+01
.ENDS GCJ31CL81E824KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GCJ31CL8ED226KE07
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8ED226KE07 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.35e-10
R03 N02 N03 4.50e-03
C04 N03 N04 3.30e-04
R04 N03 N04 2.48e+01
C05 N04 N05 5.21e-04
R05 N04 N05 1.64e+00
C06 N05 N06 4.94e-04
R06 N05 N06 2.56e-01
C07 N06 N07 5.35e-04
R07 N06 N07 3.93e-02
C08 N07 N08 5.97e-04
R08 N07 N08 6.74e-03
C09 N08 N09 3.52e-04
R09 N08 N09 3.31e-03
L10 N09 N10 2.52e-11
R10 N09 N10 8.05e-02
L11 N10 N11 6.98e-11
R11 N10 N11 3.41e-02
L12 N11 N12 4.30e-10
R12 N11 N12 1.50e-02
C13 N12 N13 3.81e-05
L13 N12 N13 1.26e-10
R13 N12 N13 4.52e-03
C14 N13 N14 1.89e-05
L14 N13 N14 1.07e-10
R14 N13 N14 4.44e-03
C15 N14 N15 2.06e-11
L15 N14 N15 4.27e-11
R15 N14 N15 4.20e+00
C16 N15 Port2 2.26e-12
L16 N15 Port2 1.30e-10
R16 N15 Port2 5.74e+01
.ENDS GCJ31CL8ED226KE07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ31CL8EL105KA07
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8EL105KA07 Port1 Port2
C01 Port1 N01 9.85e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.02e-10
R03 N02 N03 4.44e-03
C04 N03 N04 2.22e-04
R04 N03 N04 1.75e+01
C05 N04 N05 1.85e-04
R05 N04 N05 3.48e+00
C06 N05 N06 1.41e-04
R06 N05 N06 5.53e-01
C07 N06 N07 1.52e-04
R07 N06 N07 5.59e-02
C08 N07 N08 2.81e-04
R08 N07 N08 6.21e-03
C09 N08 N09 1.55e-04
R09 N08 N09 3.67e-03
C10 N09 N10 3.07e-05
R10 N09 N10 2.67e-03
L11 N10 N11 5.31e-11
R11 N10 N11 6.37e-02
L12 N11 N12 4.04e-10
R12 N11 N12 3.90e-02
C13 N12 N13 2.78e-06
L13 N12 N13 8.91e-11
R13 N12 N13 2.51e-02
C14 N13 N14 2.84e-06
L14 N13 N14 3.69e-11
R14 N13 N14 1.77e-02
C15 N14 N15 6.85e-10
L15 N14 N15 4.23e-11
R15 N14 N15 3.04e-01
C16 N15 Port2 4.76e-12
L16 N15 Port2 1.20e-10
R16 N15 Port2 9.81e+00
.ENDS GCJ31CL8EL105KA07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GCJ31CL8YA105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA105KA01 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CL8YA105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GCJ31CL8YA105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA105MA01 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CL8YA105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/5.60e-01[uF]/35[V]
* Murata P/N :GCJ31CL8YA564KA01
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA564KA01 Port1 Port2
C01 Port1 N01 5.47e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.19e-10
R03 N02 N03 9.29e-03
C04 N03 N04 7.92e-05
R04 N03 N04 2.93e+01
C05 N04 N05 8.33e-05
R05 N04 N05 3.86e+00
C06 N05 N06 7.01e-05
R06 N05 N06 4.43e-01
C07 N06 N07 1.12e-04
R07 N06 N07 4.33e-02
C08 N07 N08 3.87e-05
R08 N07 N08 2.45e-02
L09 N08 N09 1.42e-11
R09 N08 N09 6.03e-02
L10 N09 N10 2.83e-10
R10 N09 N10 5.57e-02
C11 N10 N11 2.41e-06
L11 N10 N11 5.12e-11
R11 N10 N11 1.91e-02
C12 N11 N12 8.27e-07
L12 N11 N12 6.00e-11
R12 N11 N12 2.09e-02
C13 N12 N13 1.41e-11
L13 N12 N13 1.48e-10
R13 N12 N13 2.60e+01
C14 N13 N14 3.48e-12
L14 N13 N14 2.86e-10
R14 N13 N14 5.05e+01
C15 N14 Port2 2.16e-12
L15 N14 Port2 1.58e-10
R15 N14 Port2 1.81e+01
.ENDS GCJ31CL8YA564KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/6.80e-01[uF]/35[V]
* Murata P/N :GCJ31CL8YA684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA684KA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CL8YA684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/6.80e-01[uF]/35[V]
* Murata P/N :GCJ31CL8YA684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA684MA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CL8YA684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/8.20e-01[uF]/35[V]
* Murata P/N :GCJ31CL8YA824KA01
* Property : C = 8.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA824KA01 Port1 Port2
C01 Port1 N01 8.03e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 1.90e-10
R03 N02 N03 7.46e-03
C04 N03 N04 9.89e-05
R04 N03 N04 2.49e+01
C05 N04 N05 1.27e-04
R05 N04 N05 1.98e+00
C06 N05 N06 1.24e-04
R06 N05 N06 2.55e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.36e-02
C08 N07 N08 6.51e-05
R08 N07 N08 1.67e-02
L09 N08 N09 2.58e-11
R09 N08 N09 5.48e-02
L10 N09 N10 3.30e-10
R10 N09 N10 4.91e-02
C11 N10 N11 2.74e-06
L11 N10 N11 7.07e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.33e-06
L12 N11 N12 6.09e-11
R12 N11 N12 1.94e-02
C13 N12 N13 9.71e-12
L13 N12 N13 1.53e-10
R13 N12 N13 1.96e+01
C14 N13 Port2 2.49e-12
L14 N13 Port2 2.94e-10
R14 N13 Port2 6.19e+01
.ENDS GCJ31CL8YA824KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GCJ31CR70J226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR70J226KE01 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.35e-10
R03 N02 N03 4.50e-03
C04 N03 N04 3.30e-04
R04 N03 N04 2.48e+01
C05 N04 N05 5.21e-04
R05 N04 N05 1.64e+00
C06 N05 N06 4.94e-04
R06 N05 N06 2.56e-01
C07 N06 N07 5.35e-04
R07 N06 N07 3.93e-02
C08 N07 N08 5.97e-04
R08 N07 N08 6.74e-03
C09 N08 N09 3.52e-04
R09 N08 N09 3.31e-03
L10 N09 N10 2.52e-11
R10 N09 N10 8.05e-02
L11 N10 N11 6.98e-11
R11 N10 N11 3.41e-02
L12 N11 N12 4.30e-10
R12 N11 N12 1.50e-02
C13 N12 N13 3.81e-05
L13 N12 N13 1.26e-10
R13 N12 N13 4.52e-03
C14 N13 N14 1.89e-05
L14 N13 N14 1.07e-10
R14 N13 N14 4.44e-03
C15 N14 N15 2.06e-11
L15 N14 N15 4.27e-11
R15 N14 N15 4.20e+00
C16 N15 Port2 2.26e-12
L16 N15 Port2 1.30e-10
R16 N15 Port2 5.74e+01
.ENDS GCJ31CR70J226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GCJ31CR70J226ME01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR70J226ME01 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.35e-10
R03 N02 N03 4.50e-03
C04 N03 N04 3.30e-04
R04 N03 N04 2.48e+01
C05 N04 N05 5.21e-04
R05 N04 N05 1.64e+00
C06 N05 N06 4.94e-04
R06 N05 N06 2.56e-01
C07 N06 N07 5.35e-04
R07 N06 N07 3.93e-02
C08 N07 N08 5.97e-04
R08 N07 N08 6.74e-03
C09 N08 N09 3.52e-04
R09 N08 N09 3.31e-03
L10 N09 N10 2.52e-11
R10 N09 N10 8.05e-02
L11 N10 N11 6.98e-11
R11 N10 N11 3.41e-02
L12 N11 N12 4.30e-10
R12 N11 N12 1.50e-02
C13 N12 N13 3.81e-05
L13 N12 N13 1.26e-10
R13 N12 N13 4.52e-03
C14 N13 N14 1.89e-05
L14 N13 N14 1.07e-10
R14 N13 N14 4.44e-03
C15 N14 N15 2.06e-11
L15 N14 N15 4.27e-11
R15 N14 N15 4.20e+00
C16 N15 Port2 2.26e-12
L16 N15 Port2 1.30e-10
R16 N15 Port2 5.74e+01
.ENDS GCJ31CR70J226ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ31CR71A106KA13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71A106KA13 Port1 Port2
C01 Port1 N01 9.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.25e-10
R03 N02 N03 6.71e-03
C04 N03 N04 1.43e-03
R04 N03 N04 3.70e+00
C05 N04 N05 1.40e-03
R05 N04 N05 7.24e-01
C06 N05 N06 1.38e-03
R06 N05 N06 1.50e-01
C07 N06 N07 1.25e-03
R07 N06 N07 2.78e-02
C08 N07 N08 7.47e-04
R08 N07 N08 5.15e-03
L09 N08 N09 1.52e-11
R09 N08 N09 6.93e-02
L10 N09 N10 9.84e-11
R10 N09 N10 5.02e-02
L11 N10 N11 5.44e-10
R11 N10 N11 1.85e-02
C12 N11 N12 2.93e-05
L12 N11 N12 1.11e-10
R12 N11 N12 6.21e-03
C13 N12 N13 2.50e-05
L13 N12 N13 5.76e-11
R13 N12 N13 5.14e-03
C14 N13 N14 8.51e-11
L14 N13 N14 1.11e-11
R14 N13 N14 1.72e+00
C15 N14 Port2 1.34e-12
L15 N14 Port2 2.36e-10
R15 N14 Port2 4.96e+01
.ENDS GCJ31CR71A106KA13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ31CR71A106MA13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71A106MA13 Port1 Port2
C01 Port1 N01 9.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.25e-10
R03 N02 N03 6.71e-03
C04 N03 N04 1.43e-03
R04 N03 N04 3.70e+00
C05 N04 N05 1.40e-03
R05 N04 N05 7.24e-01
C06 N05 N06 1.38e-03
R06 N05 N06 1.50e-01
C07 N06 N07 1.25e-03
R07 N06 N07 2.78e-02
C08 N07 N08 7.47e-04
R08 N07 N08 5.15e-03
L09 N08 N09 1.52e-11
R09 N08 N09 6.93e-02
L10 N09 N10 9.84e-11
R10 N09 N10 5.02e-02
L11 N10 N11 5.44e-10
R11 N10 N11 1.85e-02
C12 N11 N12 2.93e-05
L12 N11 N12 1.11e-10
R12 N11 N12 6.21e-03
C13 N12 N13 2.50e-05
L13 N12 N13 5.76e-11
R13 N12 N13 5.14e-03
C14 N13 N14 8.51e-11
L14 N13 N14 1.11e-11
R14 N13 N14 1.72e+00
C15 N14 Port2 1.34e-12
L15 N14 Port2 2.36e-10
R15 N14 Port2 4.96e+01
.ENDS GCJ31CR71A106MA13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GCJ31CR71A226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71A226KE01 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.35e-10
R03 N02 N03 4.50e-03
C04 N03 N04 3.30e-04
R04 N03 N04 2.48e+01
C05 N04 N05 5.21e-04
R05 N04 N05 1.64e+00
C06 N05 N06 4.94e-04
R06 N05 N06 2.56e-01
C07 N06 N07 5.35e-04
R07 N06 N07 3.93e-02
C08 N07 N08 5.97e-04
R08 N07 N08 6.74e-03
C09 N08 N09 3.52e-04
R09 N08 N09 3.31e-03
L10 N09 N10 2.52e-11
R10 N09 N10 8.05e-02
L11 N10 N11 6.98e-11
R11 N10 N11 3.41e-02
L12 N11 N12 4.30e-10
R12 N11 N12 1.50e-02
C13 N12 N13 3.81e-05
L13 N12 N13 1.26e-10
R13 N12 N13 4.52e-03
C14 N13 N14 1.89e-05
L14 N13 N14 1.07e-10
R14 N13 N14 4.44e-03
C15 N14 N15 2.06e-11
L15 N14 N15 4.27e-11
R15 N14 N15 4.20e+00
C16 N15 Port2 2.26e-12
L16 N15 Port2 1.30e-10
R16 N15 Port2 5.74e+01
.ENDS GCJ31CR71A226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GCJ31CR71A226ME01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71A226ME01 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.35e-10
R03 N02 N03 4.50e-03
C04 N03 N04 3.30e-04
R04 N03 N04 2.48e+01
C05 N04 N05 5.21e-04
R05 N04 N05 1.64e+00
C06 N05 N06 4.94e-04
R06 N05 N06 2.56e-01
C07 N06 N07 5.35e-04
R07 N06 N07 3.93e-02
C08 N07 N08 5.97e-04
R08 N07 N08 6.74e-03
C09 N08 N09 3.52e-04
R09 N08 N09 3.31e-03
L10 N09 N10 2.52e-11
R10 N09 N10 8.05e-02
L11 N10 N11 6.98e-11
R11 N10 N11 3.41e-02
L12 N11 N12 4.30e-10
R12 N11 N12 1.50e-02
C13 N12 N13 3.81e-05
L13 N12 N13 1.26e-10
R13 N12 N13 4.52e-03
C14 N13 N14 1.89e-05
L14 N13 N14 1.07e-10
R14 N13 N14 4.44e-03
C15 N14 N15 2.06e-11
L15 N14 N15 4.27e-11
R15 N14 N15 4.20e+00
C16 N15 Port2 2.26e-12
L16 N15 Port2 1.30e-10
R16 N15 Port2 5.74e+01
.ENDS GCJ31CR71A226ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ31CR71C106KA15
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71C106KA15 Port1 Port2
C01 Port1 N01 6.90e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.65e-10
R03 N02 N03 6.86e-03
C04 N03 N04 1.59e-04
R04 N03 N04 2.97e+01
C05 N04 N05 2.13e-04
R05 N04 N05 2.52e+00
C06 N05 N06 2.49e-04
R06 N05 N06 3.21e-01
C07 N06 N07 1.87e-04
R07 N06 N07 7.30e-02
C08 N07 N08 1.04e-04
R08 N07 N08 1.24e-02
L09 N08 N09 1.48e-11
R09 N08 N09 1.00e-01
L10 N09 N10 8.14e-11
R10 N09 N10 5.76e-02
L11 N10 N11 5.61e-10
R11 N10 N11 2.02e-02
C12 N11 N12 2.60e-05
L12 N11 N12 7.31e-11
R12 N11 N12 4.88e-03
C13 N12 N13 2.46e-05
L13 N12 N13 3.56e-11
R13 N12 N13 3.80e-03
C14 N13 N14 2.28e-11
L14 N13 N14 6.27e-11
R14 N13 N14 5.16e+00
C15 N14 Port2 1.60e-12
L15 N14 Port2 2.26e-10
R15 N14 Port2 1.28e+02
.ENDS GCJ31CR71C106KA15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ31CR71C106MA15
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71C106MA15 Port1 Port2
C01 Port1 N01 6.90e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.65e-10
R03 N02 N03 6.86e-03
C04 N03 N04 1.59e-04
R04 N03 N04 2.97e+01
C05 N04 N05 2.13e-04
R05 N04 N05 2.52e+00
C06 N05 N06 2.49e-04
R06 N05 N06 3.21e-01
C07 N06 N07 1.87e-04
R07 N06 N07 7.30e-02
C08 N07 N08 1.04e-04
R08 N07 N08 1.24e-02
L09 N08 N09 1.48e-11
R09 N08 N09 1.00e-01
L10 N09 N10 8.14e-11
R10 N09 N10 5.76e-02
L11 N10 N11 5.61e-10
R11 N10 N11 2.02e-02
C12 N11 N12 2.60e-05
L12 N11 N12 7.31e-11
R12 N11 N12 4.88e-03
C13 N12 N13 2.46e-05
L13 N12 N13 3.56e-11
R13 N12 N13 3.80e-03
C14 N13 N14 2.28e-11
L14 N13 N14 6.27e-11
R14 N13 N14 5.16e+00
C15 N14 Port2 1.60e-12
L15 N14 Port2 2.26e-10
R15 N14 Port2 1.28e+02
.ENDS GCJ31CR71C106MA15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ31CR71C475KA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71C475KA01 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CR71C475KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ31CR71C475MA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71C475MA01 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CR71C475MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ31CR71E475KA12
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71E475KA12 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CR71E475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ31CR71E475MA12
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71E475MA12 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 6.09e-11
R03 N02 N03 1.64e-02
C04 N03 N04 9.39e-04
R04 N03 N04 5.65e+00
C05 N04 N05 6.75e-04
R05 N04 N05 1.02e+00
C06 N05 N06 8.30e-04
R06 N05 N06 1.49e-01
C07 N06 N07 8.97e-04
R07 N06 N07 3.22e-02
C08 N07 N08 5.79e-04
R08 N07 N08 1.31e-02
L09 N08 N09 7.19e-11
R09 N08 N09 5.76e-02
L10 N09 N10 5.40e-10
R10 N09 N10 2.33e-02
C11 N10 N11 1.90e-05
L11 N10 N11 7.52e-11
R11 N10 N11 9.70e-03
C12 N11 N12 1.54e-05
L12 N11 N12 4.48e-11
R12 N11 N12 7.78e-03
C13 N12 N13 3.40e-11
L13 N12 N13 3.50e-11
R13 N12 N13 4.62e+00
C14 N13 Port2 8.46e-13
L14 N13 Port2 3.58e-10
R14 N13 Port2 1.11e+02
.ENDS GCJ31CR71E475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H105KA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H105KA12 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CR71H105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H105MA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H105MA12 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 7.88e-11
R03 N02 N03 3.39e-02
C04 N03 N04 1.26e-04
R04 N03 N04 3.94e+01
C05 N04 N05 1.57e-04
R05 N04 N05 2.78e+00
C06 N05 N06 1.91e-04
R06 N05 N06 3.66e-01
C07 N06 N07 2.56e-04
R07 N06 N07 1.03e-01
C08 N07 N08 8.20e-05
R08 N07 N08 3.72e-02
L09 N08 N09 5.28e-11
R09 N08 N09 1.07e-01
L10 N09 N10 4.16e-10
R10 N09 N10 4.99e-02
C11 N10 N11 3.60e-06
L11 N10 N11 7.73e-11
R11 N10 N11 1.74e-02
C12 N11 N12 2.64e-06
L12 N11 N12 4.51e-11
R12 N11 N12 1.40e-02
C13 N12 N13 1.68e-11
L13 N12 N13 7.89e-11
R13 N12 N13 6.67e+00
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.45e-10
R14 N13 Port2 1.19e+02
.ENDS GCJ31CR71H105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H155KA12
* Property : C = 1.50e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H155KA12 Port1 Port2
C01 Port1 N01 1.50e-06
R01 Port1 N01 3.33e+08
L02 N01 N02 2.05e-10
R03 N02 N03 8.05e-03
C04 N03 N04 5.25e-04
R04 N03 N04 9.69e+00
C05 N04 N05 2.02e-04
R05 N04 N05 3.35e+00
C06 N05 N06 1.72e-04
R06 N05 N06 4.24e-01
C07 N06 N07 1.65e-04
R07 N06 N07 5.01e-02
C08 N07 N08 1.24e-04
R08 N07 N08 8.53e-03
L09 N08 N09 2.80e-11
R09 N08 N09 3.52e-02
L10 N09 N10 2.93e-10
R10 N09 N10 3.42e-02
C11 N10 N11 5.55e-06
L11 N10 N11 6.45e-11
R11 N10 N11 1.21e-02
C12 N11 N12 2.56e-06
L12 N11 N12 5.74e-11
R12 N11 N12 1.30e-02
C13 N12 N13 2.33e-11
L13 N12 N13 7.61e-11
R13 N12 N13 8.48e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 3.52e-10
R14 N13 Port2 5.13e+01
.ENDS GCJ31CR71H155KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H155MA12
* Property : C = 1.50e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H155MA12 Port1 Port2
C01 Port1 N01 1.50e-06
R01 Port1 N01 3.33e+08
L02 N01 N02 2.05e-10
R03 N02 N03 8.05e-03
C04 N03 N04 5.25e-04
R04 N03 N04 9.69e+00
C05 N04 N05 2.02e-04
R05 N04 N05 3.35e+00
C06 N05 N06 1.72e-04
R06 N05 N06 4.24e-01
C07 N06 N07 1.65e-04
R07 N06 N07 5.01e-02
C08 N07 N08 1.24e-04
R08 N07 N08 8.53e-03
L09 N08 N09 2.80e-11
R09 N08 N09 3.52e-02
L10 N09 N10 2.93e-10
R10 N09 N10 3.42e-02
C11 N10 N11 5.55e-06
L11 N10 N11 6.45e-11
R11 N10 N11 1.21e-02
C12 N11 N12 2.56e-06
L12 N11 N12 5.74e-11
R12 N11 N12 1.30e-02
C13 N12 N13 2.33e-11
L13 N12 N13 7.61e-11
R13 N12 N13 8.48e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 3.52e-10
R14 N13 Port2 5.13e+01
.ENDS GCJ31CR71H155MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H225KA12
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H225KA12 Port1 Port2
C01 Port1 N01 2.10e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 2.00e-10
R03 N02 N03 1.38e-02
C04 N03 N04 3.46e-04
R04 N03 N04 5.49e+00
C05 N04 N05 2.69e-04
R05 N04 N05 8.07e-01
C06 N05 N06 2.58e-04
R06 N05 N06 9.30e-02
C07 N06 N07 1.62e-04
R07 N06 N07 1.49e-02
L08 N07 N08 5.14e-11
R08 N07 N08 6.49e-02
L09 N08 N09 3.68e-10
R09 N08 N09 4.05e-02
C10 N09 N10 5.78e-06
L10 N09 N10 1.02e-10
R10 N09 N10 1.68e-02
C11 N10 N11 3.42e-06
L11 N10 N11 7.52e-11
R11 N10 N11 1.49e-02
C12 N11 N12 1.51e-11
L12 N11 N12 5.88e-11
R12 N11 N12 5.04e+00
C13 N12 Port2 2.24e-12
L13 N12 Port2 1.55e-10
R13 N12 Port2 6.48e+01
.ENDS GCJ31CR71H225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H225MA12
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H225MA12 Port1 Port2
C01 Port1 N01 2.10e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 2.00e-10
R03 N02 N03 1.38e-02
C04 N03 N04 3.46e-04
R04 N03 N04 5.49e+00
C05 N04 N05 2.69e-04
R05 N04 N05 8.07e-01
C06 N05 N06 2.58e-04
R06 N05 N06 9.30e-02
C07 N06 N07 1.62e-04
R07 N06 N07 1.49e-02
L08 N07 N08 5.14e-11
R08 N07 N08 6.49e-02
L09 N08 N09 3.68e-10
R09 N08 N09 4.05e-02
C10 N09 N10 5.78e-06
L10 N09 N10 1.02e-10
R10 N09 N10 1.68e-02
C11 N10 N11 3.42e-06
L11 N10 N11 7.52e-11
R11 N10 N11 1.49e-02
C12 N11 N12 1.51e-11
L12 N11 N12 5.88e-11
R12 N11 N12 5.04e+00
C13 N12 Port2 2.24e-12
L13 N12 Port2 1.55e-10
R13 N12 Port2 6.48e+01
.ENDS GCJ31CR71H225MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-01[uF]/50[V]
* Murata P/N :GCJ31CR71H684KA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H684KA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CR71H684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-01[uF]/50[V]
* Murata P/N :GCJ31CR71H684MA01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H684MA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.43e-02
C04 N03 N04 5.28e-05
R04 N03 N04 1.62e-01
C05 N04 N05 4.91e-05
R05 N04 N05 1.63e-02
L06 N05 N06 2.36e-11
R06 N05 N06 6.63e-02
L07 N06 N07 3.27e-10
R07 N06 N07 4.97e-02
C08 N07 N08 2.52e-06
L08 N07 N08 6.40e-11
R08 N07 N08 1.81e-02
C09 N08 N09 1.20e-06
L09 N08 N09 5.67e-11
R09 N08 N09 1.76e-02
C10 N09 N10 4.64e-11
L10 N09 N10 3.54e-11
R10 N09 N10 4.24e+00
C11 N10 Port2 8.91e-13
L11 N10 Port2 3.75e-10
R11 N10 Port2 8.44e+01
.ENDS GCJ31CR71H684MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ31CR72A105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72A105KA01 Port1 Port2
C01 Port1 N01 9.85e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.02e-10
R03 N02 N03 4.44e-03
C04 N03 N04 2.22e-04
R04 N03 N04 1.75e+01
C05 N04 N05 1.85e-04
R05 N04 N05 3.48e+00
C06 N05 N06 1.41e-04
R06 N05 N06 5.53e-01
C07 N06 N07 1.52e-04
R07 N06 N07 5.59e-02
C08 N07 N08 2.81e-04
R08 N07 N08 6.21e-03
C09 N08 N09 1.55e-04
R09 N08 N09 3.67e-03
C10 N09 N10 3.07e-05
R10 N09 N10 2.67e-03
L11 N10 N11 5.31e-11
R11 N10 N11 6.37e-02
L12 N11 N12 4.04e-10
R12 N11 N12 3.90e-02
C13 N12 N13 2.78e-06
L13 N12 N13 8.91e-11
R13 N12 N13 2.51e-02
C14 N13 N14 2.84e-06
L14 N13 N14 3.69e-11
R14 N13 N14 1.77e-02
C15 N14 N15 6.85e-10
L15 N14 N15 4.23e-11
R15 N14 N15 3.04e-01
C16 N15 Port2 4.76e-12
L16 N15 Port2 1.20e-10
R16 N15 Port2 9.81e+00
.ENDS GCJ31CR72A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ31CR72A105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72A105MA01 Port1 Port2
C01 Port1 N01 9.85e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 3.02e-10
R03 N02 N03 4.44e-03
C04 N03 N04 2.22e-04
R04 N03 N04 1.75e+01
C05 N04 N05 1.85e-04
R05 N04 N05 3.48e+00
C06 N05 N06 1.41e-04
R06 N05 N06 5.53e-01
C07 N06 N07 1.52e-04
R07 N06 N07 5.59e-02
C08 N07 N08 2.81e-04
R08 N07 N08 6.21e-03
C09 N08 N09 1.55e-04
R09 N08 N09 3.67e-03
C10 N09 N10 3.07e-05
R10 N09 N10 2.67e-03
L11 N10 N11 5.31e-11
R11 N10 N11 6.37e-02
L12 N11 N12 4.04e-10
R12 N11 N12 3.90e-02
C13 N12 N13 2.78e-06
L13 N12 N13 8.91e-11
R13 N12 N13 2.51e-02
C14 N13 N14 2.84e-06
L14 N13 N14 3.69e-11
R14 N13 N14 1.77e-02
C15 N14 N15 6.85e-10
L15 N14 N15 4.23e-11
R15 N14 N15 3.04e-01
C16 N15 Port2 4.76e-12
L16 N15 Port2 1.20e-10
R16 N15 Port2 9.81e+00
.ENDS GCJ31CR72A105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/250[V]
* Murata P/N :GCJ31CR72E104KXJ3
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72E104KXJ3 Port1 Port2
C01 Port1 N01 9.84e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 4.77e-10
R03 N02 N03 2.41e-02
C04 N03 N04 7.33e-06
R04 N03 N04 2.17e-01
C05 N04 N05 1.93e-05
R05 N04 N05 2.07e-02
C06 N05 N06 9.02e-06
R06 N05 N06 1.40e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.43e-01
L08 N07 N08 1.51e-10
R08 N07 N08 1.01e-01
C09 N08 N09 3.64e-07
L09 N08 N09 5.41e-11
R09 N08 N09 2.43e-02
C10 N09 N10 9.15e-08
L10 N09 N10 8.18e-11
R10 N09 N10 4.74e-02
C11 N10 Port2 7.10e-12
L11 N10 Port2 1.92e-10
R11 N10 Port2 1.98e+01
.ENDS GCJ31CR72E104KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-02[uF]/250[V]
* Murata P/N :GCJ31CR72E333KXJ3
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72E333KXJ3 Port1 Port2
C01 Port1 N01 3.15e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 5.10e-10
R03 N02 N03 5.04e-02
C04 N03 N04 2.14e-06
R04 N03 N04 7.44e-01
C05 N04 N05 3.98e-06
R05 N04 N05 7.97e-02
C06 N05 N06 1.91e-06
R06 N05 N06 3.90e-02
L07 N06 N07 4.14e-11
R07 N06 N07 1.76e-01
L08 N07 N08 4.54e-11
R08 N07 N08 1.14e-01
C09 N08 N09 1.40e-07
L09 N08 N09 2.45e-11
R09 N08 N09 1.96e-02
C10 N09 N10 1.50e-08
L10 N09 N10 7.22e-11
R10 N09 N10 6.94e-02
C11 N10 Port2 7.69e-12
L11 N10 Port2 3.22e-10
R11 N10 Port2 3.48e+01
.ENDS GCJ31CR72E333KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-02[uF]/250[V]
* Murata P/N :GCJ31CR72E473KXJ3
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72E473KXJ3 Port1 Port2
C01 Port1 N01 4.79e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 4.40e-10
R03 N02 N03 3.46e-02
C04 N03 N04 4.55e-06
R04 N03 N04 3.50e-01
C05 N04 N05 5.11e-06
R05 N04 N05 9.41e-02
C06 N05 N06 2.94e-06
R06 N05 N06 2.16e-02
L07 N06 N07 1.38e-10
R07 N06 N07 1.37e-01
L08 N07 N08 1.70e-12
R08 N07 N08 2.28e-02
C09 N08 N09 2.26e-07
L09 N08 N09 3.97e-11
R09 N08 N09 3.33e-02
C10 N09 N10 4.73e-08
L10 N09 N10 6.30e-11
R10 N09 N10 5.78e-02
C11 N10 N11 2.26e-08
L11 N10 N11 6.59e-13
R11 N10 N11 1.32e-01
C12 N11 Port2 4.22e-12
L12 N11 Port2 3.08e-10
R12 N11 Port2 2.83e+01
.ENDS GCJ31CR72E473KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GCJ31CR72J153KXJ3
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72J153KXJ3 Port1 Port2
C01 Port1 N01 1.46e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.67e-10
R03 N02 N03 5.07e-02
C04 N03 N04 9.72e-07
R04 N03 N04 1.64e+00
C05 N04 N05 1.47e-06
R05 N04 N05 2.26e-01
C06 N05 N06 1.02e-06
R06 N05 N06 6.23e-02
C07 N06 N07 8.86e-07
R07 N06 N07 1.80e-02
L08 N07 N08 1.64e-10
R08 N07 N08 4.30e-01
C09 N08 N09 1.28e-07
L09 N08 N09 1.85e-11
R09 N08 N09 5.26e-02
C10 N09 N10 1.22e-08
L10 N09 N10 7.73e-11
R10 N09 N10 1.20e-01
C11 N10 Port2 1.04e-11
L11 N10 Port2 1.81e-10
R11 N10 Port2 1.52e+01
.ENDS GCJ31CR72J153KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GCJ31CR72J223KXJ3
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72J223KXJ3 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 4.41e-10
R03 N02 N03 3.92e-02
C04 N03 N04 1.00e-06
R04 N03 N04 3.99e+00
C05 N04 N05 1.55e-06
R05 N04 N05 1.91e-01
C06 N05 N06 7.78e-07
R06 N05 N06 3.40e-02
L07 N06 N07 1.87e-10
R07 N06 N07 2.76e-01
L08 N07 N08 3.04e-11
R08 N07 N08 1.62e-01
C09 N08 N09 1.15e-07
L09 N08 N09 3.58e-11
R09 N08 N09 6.12e-02
C10 N09 N10 2.57e-08
L10 N09 N10 6.37e-11
R10 N09 N10 9.93e-02
C11 N10 Port2 7.76e-12
L11 N10 Port2 1.60e-10
R11 N10 Port2 1.44e+01
.ENDS GCJ31CR72J223KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/1000[V]
* Murata P/N :GCJ31CR73A103KXJ3
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR73A103KXJ3 Port1 Port2
C01 Port1 N01 9.92e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.76e-10
R03 N02 N03 5.80e-02
C04 N03 N04 4.51e-07
R04 N03 N04 5.60e+00
C05 N04 N05 7.14e-07
R05 N04 N05 3.01e-01
C06 N05 N06 5.94e-07
R06 N05 N06 4.45e-02
C07 N06 N07 3.18e-07
R07 N06 N07 1.99e-02
L08 N07 N08 1.45e-10
R08 N07 N08 2.95e-01
C09 N08 N09 3.99e-08
L09 N08 N09 4.51e-11
R09 N08 N09 1.11e-01
C10 N09 N10 1.18e-08
L10 N09 N10 6.08e-11
R10 N09 N10 1.47e-01
C11 N10 Port2 5.63e-12
L11 N10 Port2 1.92e-10
R11 N10 Port2 1.65e+01
.ENDS GCJ31CR73A103KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/1000[V]
* Murata P/N :GCJ31CR73A682KXJ3
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR73A682KXJ3 Port1 Port2
C01 Port1 N01 6.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.88e-10
R03 N02 N03 8.09e-02
C04 N03 N04 3.05e-07
R04 N03 N04 8.26e+00
C05 N04 N05 7.85e-07
R05 N04 N05 3.77e-01
C06 N05 N06 5.56e-07
R06 N05 N06 1.43e-01
C07 N06 N07 2.60e-07
R07 N06 N07 4.86e-02
L08 N07 N08 9.18e-11
R08 N07 N08 3.02e-01
C09 N08 N09 3.51e-08
L09 N08 N09 2.94e-11
R09 N08 N09 7.27e-02
C10 N09 N10 1.11e-08
L10 N09 N10 3.38e-11
R10 N09 N10 1.35e-01
C11 N10 Port2 7.01e-12
L11 N10 Port2 2.94e-10
R11 N10 Port2 2.58e+01
.ENDS GCJ31CR73A682KXJ3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ31ML81C105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81C105KA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31ML81C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ31ML81C105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81C105MA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31ML81C105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ31ML81C225KA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81C225KA01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31ML81C225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ31ML81C225MA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81C225MA01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31ML81C225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ31ML81E394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81E394KA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31ML81E394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ31ML81E394MA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81E394MA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31ML81E394MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ31ML81E474KA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81E474KA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31ML81E474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ31ML81E474MA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81E474MA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31ML81E474MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/3.90e-01[uF]/35[V]
* Murata P/N :GCJ31ML8YA394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML8YA394KA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31ML8YA394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/3.90e-01[uF]/35[V]
* Murata P/N :GCJ31ML8YA394MA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML8YA394MA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31ML8YA394MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GCJ31ML8YA474KA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML8YA474KA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31ML8YA474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GCJ31ML8YA474MA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML8YA474MA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31ML8YA474MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ31MR71C105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71C105KA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ31MR71C105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71C105MA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71C105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ31MR71C225KA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71C225KA01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31MR71C225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ31MR71C225MA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71C225MA01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31MR71C225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E104KA01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GCJ31MR71E104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E104MA01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GCJ31MR71E104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E105KA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E105KA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71E105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E105MA01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E105MA01 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71E105MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E124KA01
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E124KA01 Port1 Port2
C01 Port1 N01 1.20e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 6.85e-11
R03 N02 N03 2.39e-02
C04 N03 N04 1.58e-05
R04 N03 N04 3.51e+02
C05 N04 N05 1.84e-05
R05 N04 N05 4.32e+01
C06 N05 N06 1.65e-05
R06 N05 N06 4.74e+00
C07 N06 N07 1.46e-05
R07 N06 N07 5.70e-01
C08 N07 N08 1.12e-05
R08 N07 N08 7.28e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.36e-02
L10 N09 N10 1.01e-10
R10 N09 N10 1.05e-01
C11 N10 N11 5.00e-07
L11 N10 N11 4.07e-11
R11 N10 N11 2.03e-02
C12 N11 N12 4.93e-08
L12 N11 N12 7.53e-11
R12 N11 N12 3.40e-02
C13 N12 N13 4.68e-12
L13 N12 N13 2.71e-10
R13 N12 N13 4.34e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 3.38e-10
R14 N13 Port2 5.48e+01
.ENDS GCJ31MR71E124KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E154KA01 Port1 Port2
C01 Port1 N01 1.45e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.72e-10
R03 N02 N03 7.44e-02
C04 N03 N04 1.65e-05
R04 N03 N04 3.37e+02
C05 N04 N05 2.38e-05
R05 N04 N05 2.80e+01
C06 N05 N06 2.00e-05
R06 N05 N06 3.78e+00
C07 N06 N07 1.73e-05
R07 N06 N07 2.74e-01
C08 N07 N08 9.75e-05
R08 N07 N08 1.94e-01
C09 N08 N09 1.24e-05
R09 N08 N09 3.97e-02
L10 N09 N10 1.63e-10
R10 N09 N10 1.08e-01
L11 N10 N11 8.70e-12
R11 N10 N11 4.57e-02
C12 N11 N12 5.40e-07
L12 N11 N12 4.93e-11
R12 N11 N12 2.53e-02
C13 N12 N13 1.26e-07
L13 N12 N13 4.50e-11
R13 N12 N13 2.62e-02
C14 N13 N14 9.95e-12
L14 N13 N14 1.25e-10
R14 N13 N14 2.12e+01
C15 N14 Port2 1.76e-12
L15 N14 Port2 3.27e-10
R15 N14 Port2 6.35e+01
.ENDS GCJ31MR71E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.80e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E184KA01 Port1 Port2
C01 Port1 N01 1.85e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 8.01e-11
R03 N02 N03 5.94e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.80e+02
C05 N04 N05 3.14e-05
R05 N04 N05 2.13e+01
C06 N05 N06 2.43e-05
R06 N05 N06 2.74e+00
C07 N06 N07 2.40e-05
R07 N06 N07 2.87e-01
C08 N07 N08 1.30e-05
R08 N07 N08 4.39e-02
L09 N08 N09 1.59e-10
R09 N08 N09 9.32e-02
L10 N09 N10 3.42e-11
R10 N09 N10 8.40e-02
C11 N10 N11 8.12e-07
L11 N10 N11 4.05e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.26e-07
L12 N11 N12 7.06e-11
R12 N11 N12 2.94e-02
C13 N12 N13 9.28e-12
L13 N12 N13 1.03e-10
R13 N12 N13 1.62e+01
C14 N13 Port2 1.26e-12
L14 N13 Port2 3.83e-10
R14 N13 Port2 7.57e+01
.ENDS GCJ31MR71E184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E224KA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR71E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E224MA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR71E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E225KA12
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E225KA12 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31MR71E225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E225MA12
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E225MA12 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.75e-10
R03 N02 N03 9.63e-03
C04 N03 N04 2.72e-04
R04 N03 N04 1.82e+01
C05 N04 N05 2.72e-04
R05 N04 N05 2.37e+00
C06 N05 N06 2.44e-04
R06 N05 N06 3.10e-01
C07 N06 N07 3.39e-04
R07 N06 N07 3.28e-02
C08 N07 N08 1.54e-04
R08 N07 N08 1.16e-02
L09 N08 N09 6.83e-11
R09 N08 N09 6.52e-02
L10 N09 N10 4.23e-10
R10 N09 N10 3.02e-02
C11 N10 N11 1.18e-05
L11 N10 N11 4.60e-11
R11 N10 N11 7.80e-03
C12 N11 N12 5.58e-06
L12 N11 N12 4.21e-11
R12 N11 N12 7.76e-03
C13 N12 N13 1.69e-11
L13 N12 N13 7.27e-11
R13 N12 N13 5.82e+00
C14 N13 Port2 1.43e-12
L14 N13 Port2 2.28e-10
R14 N13 Port2 7.04e+01
.ENDS GCJ31MR71E225MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E335KA12
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E335KA12 Port1 Port2
C01 Port1 N01 3.11e-06
R01 Port1 N01 1.52e+08
L02 N01 N02 1.41e-10
R03 N02 N03 1.62e-02
C04 N03 N04 5.95e-04
R04 N03 N04 8.36e+00
C05 N04 N05 4.66e-04
R05 N04 N05 1.08e+00
C06 N05 N06 3.41e-04
R06 N05 N06 1.71e-01
C07 N06 N07 2.57e-04
R07 N06 N07 1.87e-02
L08 N07 N08 1.64e-11
R08 N07 N08 9.27e-02
L09 N08 N09 5.72e-11
R09 N08 N09 5.69e-02
L10 N09 N10 3.84e-10
R10 N09 N10 2.90e-02
C11 N10 N11 1.06e-05
L11 N10 N11 7.78e-11
R11 N10 N11 8.23e-03
C12 N11 N12 5.74e-06
L12 N11 N12 6.33e-11
R12 N11 N12 9.22e-03
C13 N12 N13 4.59e-11
L13 N12 N13 2.29e-11
R13 N12 N13 2.82e+00
C14 N13 Port2 9.73e-13
L14 N13 Port2 2.47e-10
R14 N13 Port2 1.15e+02
.ENDS GCJ31MR71E335KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e+00[uF]/25[V]
* Murata P/N :GCJ31MR71E335MA12
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E335MA12 Port1 Port2
C01 Port1 N01 3.11e-06
R01 Port1 N01 1.52e+08
L02 N01 N02 1.41e-10
R03 N02 N03 1.62e-02
C04 N03 N04 5.95e-04
R04 N03 N04 8.36e+00
C05 N04 N05 4.66e-04
R05 N04 N05 1.08e+00
C06 N05 N06 3.41e-04
R06 N05 N06 1.71e-01
C07 N06 N07 2.57e-04
R07 N06 N07 1.87e-02
L08 N07 N08 1.64e-11
R08 N07 N08 9.27e-02
L09 N08 N09 5.72e-11
R09 N08 N09 5.69e-02
L10 N09 N10 3.84e-10
R10 N09 N10 2.90e-02
C11 N10 N11 1.06e-05
L11 N10 N11 7.78e-11
R11 N10 N11 8.23e-03
C12 N11 N12 5.74e-06
L12 N11 N12 6.33e-11
R12 N11 N12 9.22e-03
C13 N12 N13 4.59e-11
L13 N12 N13 2.29e-11
R13 N12 N13 2.82e+00
C14 N13 Port2 9.73e-13
L14 N13 Port2 2.47e-10
R14 N13 Port2 1.15e+02
.ENDS GCJ31MR71E335MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H104KA01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GCJ31MR71H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H104MA01 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.13e-10
R03 N02 N03 6.34e-02
C04 N03 N04 7.41e-06
R04 N03 N04 5.23e-01
C05 N04 N05 1.03e-05
R05 N04 N05 5.21e-02
C06 N05 N06 1.19e-05
R06 N05 N06 1.26e-02
L07 N06 N07 1.58e-10
R07 N06 N07 7.26e-02
L08 N07 N08 2.62e-11
R08 N07 N08 5.69e-02
C09 N08 N09 5.40e-07
L09 N08 N09 3.37e-11
R09 N08 N09 1.79e-02
C10 N09 N10 9.78e-12
L10 N09 N10 1.32e-10
R10 N09 N10 1.38e+01
C11 N10 Port2 1.27e-12
L11 N10 Port2 4.05e-10
R11 N10 Port2 6.16e+01
.ENDS GCJ31MR71H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ31MR71H105KA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H105KA12 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71H105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ31MR71H105MA12
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H105MA12 Port1 Port2
C01 Port1 N01 9.94e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.17e-10
R03 N02 N03 2.65e-02
C04 N03 N04 1.50e-04
R04 N03 N04 1.59e+01
C05 N04 N05 1.36e-04
R05 N04 N05 2.17e+00
C06 N05 N06 1.38e-04
R06 N05 N06 2.88e-01
C07 N06 N07 1.30e-04
R07 N06 N07 4.81e-02
C08 N07 N08 9.08e-05
R08 N07 N08 1.51e-02
L09 N08 N09 5.29e-11
R09 N08 N09 1.54e-01
L10 N09 N10 2.22e-10
R10 N09 N10 5.20e-02
C11 N10 N11 2.90e-06
L11 N10 N11 7.01e-11
R11 N10 N11 1.11e-02
C12 N11 N12 1.37e-06
L12 N11 N12 6.05e-11
R12 N11 N12 1.63e-02
C13 N12 N13 1.80e-11
L13 N12 N13 7.22e-11
R13 N12 N13 5.34e+00
C14 N13 Port2 7.43e-13
L14 N13 Port2 3.29e-10
R14 N13 Port2 1.42e+02
.ENDS GCJ31MR71H105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H224KA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR71H224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H224MA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR71H224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.70e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H274KA01
* Property : C = 2.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H274KA01 Port1 Port2
C01 Port1 N01 2.74e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.73e-10
R03 N02 N03 4.19e-02
C04 N03 N04 2.85e-05
R04 N03 N04 1.55e+02
C05 N04 N05 4.22e-05
R05 N04 N05 1.58e+01
C06 N05 N06 3.26e-05
R06 N05 N06 2.04e+00
C07 N06 N07 3.15e-05
R07 N06 N07 2.24e-01
C08 N07 N08 1.75e-05
R08 N07 N08 3.25e-02
L09 N08 N09 2.58e-10
R09 N08 N09 7.87e-02
L10 N09 N10 1.80e-11
R10 N09 N10 4.06e-02
C11 N10 N11 2.21e-06
L11 N10 N11 2.86e-11
R11 N10 N11 1.22e-02
C12 N11 N12 4.84e-07
L12 N11 N12 5.53e-11
R12 N11 N12 2.37e-02
C13 N12 N13 1.62e-11
L13 N12 N13 9.39e-11
R13 N12 N13 1.44e+01
C14 N13 N14 2.50e-12
L14 N13 N14 2.93e-10
R14 N13 N14 2.84e+01
C15 N14 Port2 3.53e-12
L15 N14 Port2 1.14e-10
R15 N14 Port2 3.42e+01
.ENDS GCJ31MR71H274KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.90e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H394KA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H394KA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31MR71H394KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.90e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H394MA01
* Property : C = 3.90e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H394MA01 Port1 Port2
C01 Port1 N01 4.03e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.29e-10
R03 N02 N03 2.37e-02
C04 N03 N04 7.21e-05
R04 N03 N04 8.79e-02
C05 N04 N05 3.75e-05
R05 N04 N05 4.25e-02
C06 N05 N06 4.20e-05
R06 N05 N06 6.83e-03
L07 N06 N07 2.00e-11
R07 N06 N07 7.60e-02
L08 N07 N08 1.80e-10
R08 N07 N08 6.97e-02
C09 N08 N09 2.48e-06
L09 N08 N09 3.09e-11
R09 N08 N09 1.36e-02
C10 N09 N10 2.67e-07
L10 N09 N10 9.74e-11
R10 N09 N10 2.67e-02
C11 N10 N11 1.91e-11
L11 N10 N11 8.23e-11
R11 N10 N11 6.45e+00
C12 N11 Port2 1.12e-12
L12 N11 Port2 3.79e-10
R12 N11 Port2 8.71e+01
.ENDS GCJ31MR71H394MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H474KA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H474KA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31MR71H474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H474MA01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H474MA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 8.63e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.32e-05
R04 N03 N04 1.41e-01
C05 N04 N05 2.93e-05
R05 N04 N05 3.60e-02
L06 N05 N06 2.67e-11
R06 N05 N06 1.05e-01
L07 N06 N07 2.16e-10
R07 N06 N07 6.52e-02
C08 N07 N08 1.26e-06
L08 N07 N08 6.80e-11
R08 N07 N08 1.81e-02
C09 N08 N09 4.92e-07
L09 N08 N09 6.34e-11
R09 N08 N09 2.26e-02
C10 N09 N10 1.90e-11
L10 N09 N10 5.94e-11
R10 N09 N10 5.21e+00
C11 N10 Port2 7.99e-13
L11 N10 Port2 3.77e-10
R11 N10 Port2 1.36e+02
.ENDS GCJ31MR71H474MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/5.60e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H564KA12
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H564KA12 Port1 Port2
C01 Port1 N01 5.47e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.82e-10
R03 N02 N03 3.12e-02
C04 N03 N04 6.99e-05
R04 N03 N04 1.07e-01
C05 N04 N05 3.99e-05
R05 N04 N05 2.43e-02
L06 N05 N06 3.62e-11
R06 N05 N06 1.33e-01
L07 N06 N07 2.62e-10
R07 N06 N07 5.71e-02
C08 N07 N08 2.54e-06
L08 N07 N08 4.51e-11
R08 N07 N08 1.27e-02
C09 N08 N09 7.95e-07
L09 N08 N09 5.80e-11
R09 N08 N09 1.82e-02
C10 N09 N10 1.60e-11
L10 N09 N10 6.70e-11
R10 N09 N10 7.11e+00
C11 N10 Port2 1.39e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 1.09e+02
.ENDS GCJ31MR71H564KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/5.60e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H564MA12
* Property : C = 5.60e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H564MA12 Port1 Port2
C01 Port1 N01 5.47e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.82e-10
R03 N02 N03 3.12e-02
C04 N03 N04 6.99e-05
R04 N03 N04 1.07e-01
C05 N04 N05 3.99e-05
R05 N04 N05 2.43e-02
L06 N05 N06 3.62e-11
R06 N05 N06 1.33e-01
L07 N06 N07 2.62e-10
R07 N06 N07 5.71e-02
C08 N07 N08 2.54e-06
L08 N07 N08 4.51e-11
R08 N07 N08 1.27e-02
C09 N08 N09 7.95e-07
L09 N08 N09 5.80e-11
R09 N08 N09 1.82e-02
C10 N09 N10 1.60e-11
L10 N09 N10 6.70e-11
R10 N09 N10 7.11e+00
C11 N10 Port2 1.39e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 1.09e+02
.ENDS GCJ31MR71H564MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-01[uF]/100[V]
* Murata P/N :GCJ31MR72A154KA01
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR72A154KA01 Port1 Port2
C01 Port1 N01 1.45e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.72e-10
R03 N02 N03 7.44e-02
C04 N03 N04 1.65e-05
R04 N03 N04 3.37e+02
C05 N04 N05 2.38e-05
R05 N04 N05 2.80e+01
C06 N05 N06 2.00e-05
R06 N05 N06 3.78e+00
C07 N06 N07 1.73e-05
R07 N06 N07 2.74e-01
C08 N07 N08 9.75e-05
R08 N07 N08 1.94e-01
C09 N08 N09 1.24e-05
R09 N08 N09 3.97e-02
L10 N09 N10 1.63e-10
R10 N09 N10 1.08e-01
L11 N10 N11 8.70e-12
R11 N10 N11 4.57e-02
C12 N11 N12 5.40e-07
L12 N11 N12 4.93e-11
R12 N11 N12 2.53e-02
C13 N12 N13 1.26e-07
L13 N12 N13 4.50e-11
R13 N12 N13 2.62e-02
C14 N13 N14 9.95e-12
L14 N13 N14 1.25e-10
R14 N13 N14 2.12e+01
C15 N14 Port2 1.76e-12
L15 N14 Port2 3.27e-10
R15 N14 Port2 6.35e+01
.ENDS GCJ31MR72A154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.80e-01[uF]/100[V]
* Murata P/N :GCJ31MR72A184KA01
* Property : C = 1.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR72A184KA01 Port1 Port2
C01 Port1 N01 1.85e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 8.01e-11
R03 N02 N03 5.94e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.80e+02
C05 N04 N05 3.14e-05
R05 N04 N05 2.13e+01
C06 N05 N06 2.43e-05
R06 N05 N06 2.74e+00
C07 N06 N07 2.40e-05
R07 N06 N07 2.87e-01
C08 N07 N08 1.30e-05
R08 N07 N08 4.39e-02
L09 N08 N09 1.59e-10
R09 N08 N09 9.32e-02
L10 N09 N10 3.42e-11
R10 N09 N10 8.40e-02
C11 N10 N11 8.12e-07
L11 N10 N11 4.05e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.26e-07
L12 N11 N12 7.06e-11
R12 N11 N12 2.94e-02
C13 N12 N13 9.28e-12
L13 N12 N13 1.03e-10
R13 N12 N13 1.62e+01
C14 N13 Port2 1.26e-12
L14 N13 Port2 3.83e-10
R14 N13 Port2 7.57e+01
.ENDS GCJ31MR72A184KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GCJ31MR72A224KA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR72A224KA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR72A224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GCJ31MR72A224MA01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR72A224MA01 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-11
R03 N02 N03 6.35e-02
C04 N03 N04 3.89e-05
R04 N03 N04 1.55e-01
C05 N04 N05 2.16e-05
R05 N04 N05 5.86e-02
C06 N05 N06 2.38e-05
R06 N05 N06 1.52e-02
L07 N06 N07 2.91e-10
R07 N06 N07 8.33e-02
L08 N07 N08 2.67e-11
R08 N07 N08 8.14e-02
C09 N08 N09 1.16e-06
L09 N08 N09 3.35e-11
R09 N08 N09 1.97e-02
C10 N09 N10 4.82e-07
L10 N09 N10 3.21e-11
R10 N09 N10 2.15e-02
C11 N10 N11 1.03e-11
L11 N10 N11 8.15e-11
R11 N10 N11 1.27e+01
C12 N11 Port2 8.79e-13
L12 N11 Port2 4.34e-10
R12 N11 Port2 8.57e+01
.ENDS GCJ31MR72A224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GCJ32DC72A475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DC72A475KE01 Port1 Port2
C01 Port1 N01 4.57e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 4.33e-11
R03 N02 N03 4.86e-03
C04 N03 N04 8.67e-04
R04 N03 N04 6.12e+00
C05 N04 N05 5.01e-04
R05 N04 N05 1.57e+00
C06 N05 N06 5.01e-04
R06 N05 N06 2.20e-01
C07 N06 N07 6.07e-04
R07 N06 N07 3.25e-02
C08 N07 N08 3.27e-04
R08 N07 N08 6.70e-03
L09 N08 N09 4.76e-11
R09 N08 N09 5.25e-02
L10 N09 N10 3.19e-10
R10 N09 N10 2.42e-02
C11 N10 N11 9.31e-06
L11 N10 N11 1.14e-10
R11 N10 N11 1.25e-02
C12 N11 N12 5.78e-06
L12 N11 N12 7.25e-11
R12 N11 N12 9.92e-03
C13 N12 N13 3.05e-11
L13 N12 N13 6.25e-11
R13 N12 N13 4.23e+00
C14 N13 Port2 1.66e-12
L14 N13 Port2 2.29e-10
R14 N13 Port2 7.59e+01
.ENDS GCJ32DC72A475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ32DL8EL225KA07
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DL8EL225KA07 Port1 Port2
C01 Port1 N01 2.13e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 4.87e-11
R03 N02 N03 2.84e-02
C04 N03 N04 7.04e-04
R04 N03 N04 7.54e+00
C05 N04 N05 5.60e-04
R05 N04 N05 1.81e+00
C06 N05 N06 4.66e-04
R06 N05 N06 4.81e-01
C07 N06 N07 3.51e-04
R07 N06 N07 1.20e-01
C08 N07 N08 2.34e-04
R08 N07 N08 2.12e-02
L09 N08 N09 3.80e-11
R09 N08 N09 5.04e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.89e-02
C11 N10 N11 5.27e-06
L11 N10 N11 8.84e-11
R11 N10 N11 1.75e-02
C12 N11 N12 4.05e-06
L12 N11 N12 3.76e-11
R12 N11 N12 1.01e-02
C13 N12 N13 2.30e-11
L13 N12 N13 7.54e-11
R13 N12 N13 7.54e+00
C14 N13 Port2 1.64e-12
L14 N13 Port2 2.62e-10
R14 N13 Port2 6.47e+01
.ENDS GCJ32DL8EL225KA07
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ32DR72A225KA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72A225KA01 Port1 Port2
C01 Port1 N01 2.13e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 4.87e-11
R03 N02 N03 2.84e-02
C04 N03 N04 7.04e-04
R04 N03 N04 7.54e+00
C05 N04 N05 5.60e-04
R05 N04 N05 1.81e+00
C06 N05 N06 4.66e-04
R06 N05 N06 4.81e-01
C07 N06 N07 3.51e-04
R07 N06 N07 1.20e-01
C08 N07 N08 2.34e-04
R08 N07 N08 2.12e-02
L09 N08 N09 3.80e-11
R09 N08 N09 5.04e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.89e-02
C11 N10 N11 5.27e-06
L11 N10 N11 8.84e-11
R11 N10 N11 1.75e-02
C12 N11 N12 4.05e-06
L12 N11 N12 3.76e-11
R12 N11 N12 1.01e-02
C13 N12 N13 2.30e-11
L13 N12 N13 7.54e-11
R13 N12 N13 7.54e+00
C14 N13 Port2 1.64e-12
L14 N13 Port2 2.62e-10
R14 N13 Port2 6.47e+01
.ENDS GCJ32DR72A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ32DR72A225MA01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72A225MA01 Port1 Port2
C01 Port1 N01 2.13e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 4.87e-11
R03 N02 N03 2.84e-02
C04 N03 N04 7.04e-04
R04 N03 N04 7.54e+00
C05 N04 N05 5.60e-04
R05 N04 N05 1.81e+00
C06 N05 N06 4.66e-04
R06 N05 N06 4.81e-01
C07 N06 N07 3.51e-04
R07 N06 N07 1.20e-01
C08 N07 N08 2.34e-04
R08 N07 N08 2.12e-02
L09 N08 N09 3.80e-11
R09 N08 N09 5.04e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.89e-02
C11 N10 N11 5.27e-06
L11 N10 N11 8.84e-11
R11 N10 N11 1.75e-02
C12 N11 N12 4.05e-06
L12 N11 N12 3.76e-11
R12 N11 N12 1.01e-02
C13 N12 N13 2.30e-11
L13 N12 N13 7.54e-11
R13 N12 N13 7.54e+00
C14 N13 Port2 1.64e-12
L14 N13 Port2 2.62e-10
R14 N13 Port2 6.47e+01
.ENDS GCJ32DR72A225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-01[uF]/250[V]
* Murata P/N :GCJ32DR72E104KXJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72E104KXJ1 Port1 Port2
C01 Port1 N01 1.01e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 2.81e-10
R03 N02 N03 1.99e-02
C04 N03 N04 8.32e-06
R04 N03 N04 1.91e-01
C05 N04 N05 1.51e-05
R05 N04 N05 2.10e-02
C06 N05 N06 1.29e-05
R06 N05 N06 9.81e-03
L07 N06 N07 2.10e-11
R07 N06 N07 1.12e-01
L08 N07 N08 1.39e-10
R08 N07 N08 7.42e-02
C09 N08 N09 4.10e-07
L09 N08 N09 3.65e-11
R09 N08 N09 3.76e-02
C10 N09 N10 8.96e-08
L10 N09 N10 5.52e-11
R10 N09 N10 3.93e-02
C11 N10 Port2 7.63e-12
L11 N10 Port2 2.70e-10
R11 N10 Port2 2.78e+01
.ENDS GCJ32DR72E104KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GCJ32DR72E224KXJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72E224KXJ1 Port1 Port2
C01 Port1 N01 2.21e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.49e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.67e-05
R04 N03 N04 9.50e-02
C05 N04 N05 2.59e-05
R05 N04 N05 9.72e-03
C06 N05 N06 8.99e-05
R06 N05 N06 1.77e-03
L07 N06 N07 3.11e-11
R07 N06 N07 1.78e-01
L08 N07 N08 1.49e-10
R08 N07 N08 7.60e-02
C09 N08 N09 5.31e-07
L09 N08 N09 7.07e-11
R09 N08 N09 4.92e-02
C10 N09 N10 2.60e-07
L10 N09 N10 5.24e-11
R10 N09 N10 4.49e-02
C11 N10 Port2 7.67e-12
L11 N10 Port2 1.86e-10
R11 N10 Port2 2.52e+01
.ENDS GCJ32DR72E224KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J153KXJ1
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J153KXJ1 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 2.50e-10
R03 N02 N03 4.00e-02
C04 N03 N04 9.35e-07
R04 N03 N04 1.70e+00
C05 N04 N05 1.48e-06
R05 N04 N05 2.14e-01
C06 N05 N06 1.29e-06
R06 N05 N06 6.18e-02
C07 N06 N07 3.90e-07
R07 N06 N07 2.76e-02
L08 N07 N08 1.26e-10
R08 N07 N08 3.37e-01
C09 N08 N09 4.08e-08
L09 N08 N09 4.01e-11
R09 N08 N09 1.01e-01
C10 N09 N10 1.32e-08
L10 N09 N10 4.10e-11
R10 N09 N10 1.16e-01
C11 N10 Port2 6.62e-12
L11 N10 Port2 3.41e-10
R11 N10 Port2 3.06e+01
.ENDS GCJ32DR72J153KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J223KXJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J223KXJ1 Port1 Port2
C01 Port1 N01 2.13e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.89e-10
R03 N02 N03 3.62e-02
C04 N03 N04 1.40e-06
R04 N03 N04 1.14e+00
C05 N04 N05 1.93e-06
R05 N04 N05 1.31e-01
C06 N05 N06 1.72e-06
R06 N05 N06 3.52e-02
C07 N06 N07 1.27e-06
R07 N06 N07 7.88e-03
L08 N07 N08 5.82e-11
R08 N07 N08 3.11e-01
L09 N08 N09 6.38e-11
R09 N08 N09 1.15e-01
C10 N09 N10 6.81e-08
L10 N09 N10 2.83e-11
R10 N09 N10 7.66e-02
C11 N10 N11 1.63e-08
L11 N10 N11 3.97e-11
R11 N10 N11 1.01e-01
C12 N11 Port2 5.05e-12
L12 N11 Port2 2.70e-10
R12 N11 Port2 3.67e+01
.ENDS GCJ32DR72J223KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J333KXJ1
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J333KXJ1 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 2.93e-10
R03 N02 N03 2.89e-02
C04 N03 N04 2.14e-06
R04 N03 N04 7.43e-01
C05 N04 N05 3.03e-06
R05 N04 N05 6.18e-02
C06 N05 N06 2.70e-06
R06 N05 N06 2.05e-02
L07 N06 N07 9.53e-11
R07 N06 N07 1.22e-01
C08 N07 N08 8.39e-08
L08 N07 N08 5.38e-11
R08 N07 N08 1.03e-01
C09 N08 N09 3.05e-08
L09 N08 N09 5.13e-11
R09 N08 N09 1.18e-01
C10 N09 Port2 6.97e-12
L10 N09 Port2 2.82e-10
R10 N09 Port2 2.68e+01
.ENDS GCJ32DR72J333KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J473KXJ1
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J473KXJ1 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 2.08e-10
R03 N02 N03 2.23e-02
C04 N03 N04 3.44e-06
R04 N03 N04 4.63e-01
C05 N04 N05 6.85e-06
R05 N04 N05 4.63e-02
C06 N05 N06 2.73e-06
R06 N05 N06 2.67e-02
L07 N06 N07 1.35e-10
R07 N06 N07 1.73e-01
C08 N07 N08 1.12e-07
L08 N07 N08 7.03e-11
R08 N07 N08 1.12e-01
C09 N08 N09 3.87e-08
L09 N08 N09 7.36e-11
R09 N08 N09 1.07e-01
C10 N09 Port2 5.99e-12
L10 N09 Port2 1.89e-10
R10 N09 Port2 1.66e+01
.ENDS GCJ32DR72J473KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-02[uF]/1000[V]
* Murata P/N :GCJ32DR73A153KXJ1
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR73A153KXJ1 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 2.50e-10
R03 N02 N03 4.00e-02
C04 N03 N04 9.35e-07
R04 N03 N04 1.70e+00
C05 N04 N05 1.48e-06
R05 N04 N05 2.14e-01
C06 N05 N06 1.29e-06
R06 N05 N06 6.18e-02
C07 N06 N07 3.90e-07
R07 N06 N07 2.76e-02
L08 N07 N08 1.26e-10
R08 N07 N08 3.37e-01
C09 N08 N09 4.08e-08
L09 N08 N09 4.01e-11
R09 N08 N09 1.01e-01
C10 N09 N10 1.32e-08
L10 N09 N10 4.10e-11
R10 N09 N10 1.16e-01
C11 N10 Port2 6.62e-12
L11 N10 Port2 3.41e-10
R11 N10 Port2 3.06e+01
.ENDS GCJ32DR73A153KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/1000[V]
* Murata P/N :GCJ32DR73A223KXJ1
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR73A223KXJ1 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.85e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.31e-06
R04 N03 N04 1.21e+00
C05 N04 N05 1.85e-06
R05 N04 N05 8.58e-02
C06 N05 N06 3.15e-06
R06 N05 N06 2.91e-02
C07 N06 N07 2.50e-07
R07 N06 N07 2.53e-02
L08 N07 N08 1.85e-10
R08 N07 N08 1.80e-01
L09 N08 N09 2.55e-11
R09 N08 N09 1.39e-01
C10 N09 N10 4.52e-08
L10 N09 N10 7.24e-11
R10 N09 N10 1.59e-01
C11 N10 N11 2.98e-08
L11 N10 N11 3.98e-11
R11 N10 N11 1.30e-01
C12 N11 Port2 4.12e-12
L12 N11 Port2 2.75e-10
R12 N11 Port2 3.49e+01
.ENDS GCJ32DR73A223KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GCJ32EC71E226KE02
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EC71E226KE02 Port1 Port2
C01 Port1 N01 2.06e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.08e-11
R03 N02 N03 2.24e-03
C04 N03 N04 2.42e-03
R04 N03 N04 2.76e+00
C05 N04 N05 3.67e-03
R05 N04 N05 1.79e-01
C06 N05 N06 2.81e-03
R06 N05 N06 2.85e-02
C07 N06 N07 4.82e-03
R07 N06 N07 2.02e-03
C08 N07 N08 2.25e-03
R08 N07 N08 3.98e-04
L09 N08 N09 1.87e-11
R09 N08 N09 5.20e-02
L10 N09 N10 7.42e-11
R10 N09 N10 2.15e-02
L11 N10 N11 6.03e-10
R11 N10 N11 1.49e-02
C12 N11 N12 4.72e-05
L12 N11 N12 1.58e-10
R12 N11 N12 5.59e-03
C13 N12 N13 5.19e-05
L13 N12 N13 5.79e-11
R13 N12 N13 3.32e-03
C14 N13 N14 4.88e-11
L14 N13 N14 3.23e-11
R14 N13 N14 2.13e+00
C15 N14 Port2 1.05e-12
L15 N14 Port2 2.30e-10
R15 N14 Port2 8.14e+01
.ENDS GCJ32EC71E226KE02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GCJ32EC71H106KA01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EC71H106KA01 Port1 Port2
C01 Port1 N01 9.49e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 9.35e-11
R03 N02 N03 1.18e-02
C04 N03 N04 1.55e-03
R04 N03 N04 3.19e+00
C05 N04 N05 2.12e-03
R05 N04 N05 3.25e-01
C06 N05 N06 2.28e-03
R06 N05 N06 6.20e-02
C07 N06 N07 1.56e-03
R07 N06 N07 2.08e-02
L08 N07 N08 1.39e-11
R08 N07 N08 5.04e-02
L09 N08 N09 9.03e-11
R09 N08 N09 4.47e-02
L10 N09 N10 6.69e-10
R10 N09 N10 2.34e-02
C11 N10 N11 2.55e-05
L11 N10 N11 1.17e-10
R11 N10 N11 6.81e-03
C12 N11 N12 2.63e-05
L12 N11 N12 4.80e-11
R12 N11 N12 4.97e-03
C13 N12 N13 1.90e-11
L13 N12 N13 5.61e-11
R13 N12 N13 3.02e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.43e-10
R14 N13 Port2 4.84e+01
.ENDS GCJ32EC71H106KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GCJ32EC71H106MA01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EC71H106MA01 Port1 Port2
C01 Port1 N01 9.49e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 9.35e-11
R03 N02 N03 1.18e-02
C04 N03 N04 1.55e-03
R04 N03 N04 3.19e+00
C05 N04 N05 2.12e-03
R05 N04 N05 3.25e-01
C06 N05 N06 2.28e-03
R06 N05 N06 6.20e-02
C07 N06 N07 1.56e-03
R07 N06 N07 2.08e-02
L08 N07 N08 1.39e-11
R08 N07 N08 5.04e-02
L09 N08 N09 9.03e-11
R09 N08 N09 4.47e-02
L10 N09 N10 6.69e-10
R10 N09 N10 2.34e-02
C11 N10 N11 2.55e-05
L11 N10 N11 1.17e-10
R11 N10 N11 6.81e-03
C12 N11 N12 2.63e-05
L12 N11 N12 4.80e-11
R12 N11 N12 4.97e-03
C13 N12 N13 1.90e-11
L13 N12 N13 5.61e-11
R13 N12 N13 3.02e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.43e-10
R14 N13 Port2 4.84e+01
.ENDS GCJ32EC71H106MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ32EL81E475KA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EL81E475KA01 Port1 Port2
C01 Port1 N01 4.39e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.75e-11
R03 N02 N03 1.10e-02
C04 N03 N04 6.89e-04
R04 N03 N04 7.70e+00
C05 N04 N05 9.49e-04
R05 N04 N05 8.30e-01
C06 N05 N06 5.81e-04
R06 N05 N06 2.49e-01
C07 N06 N07 8.93e-04
R07 N06 N07 2.42e-02
C08 N07 N08 3.58e-04
R08 N07 N08 1.05e-02
L09 N08 N09 6.20e-11
R09 N08 N09 6.14e-02
L10 N09 N10 4.52e-10
R10 N09 N10 2.35e-02
C11 N10 N11 9.73e-06
L11 N10 N11 1.22e-10
R11 N10 N11 1.42e-02
C12 N11 N12 1.23e-05
L12 N11 N12 3.90e-11
R12 N11 N12 9.49e-03
C13 N12 N13 2.35e-11
L13 N12 N13 6.81e-11
R13 N12 N13 5.05e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 2.77e-10
R14 N13 Port2 6.56e+01
.ENDS GCJ32EL81E475KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ32EL81E475MA01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EL81E475MA01 Port1 Port2
C01 Port1 N01 4.39e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.75e-11
R03 N02 N03 1.10e-02
C04 N03 N04 6.89e-04
R04 N03 N04 7.70e+00
C05 N04 N05 9.49e-04
R05 N04 N05 8.30e-01
C06 N05 N06 5.81e-04
R06 N05 N06 2.49e-01
C07 N06 N07 8.93e-04
R07 N06 N07 2.42e-02
C08 N07 N08 3.58e-04
R08 N07 N08 1.05e-02
L09 N08 N09 6.20e-11
R09 N08 N09 6.14e-02
L10 N09 N10 4.52e-10
R10 N09 N10 2.35e-02
C11 N10 N11 9.73e-06
L11 N10 N11 1.22e-10
R11 N10 N11 1.42e-02
C12 N11 N12 1.23e-05
L12 N11 N12 3.90e-11
R12 N11 N12 9.49e-03
C13 N12 N13 2.35e-11
L13 N12 N13 6.81e-11
R13 N12 N13 5.05e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 2.77e-10
R14 N13 Port2 6.56e+01
.ENDS GCJ32EL81E475MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GCJ32EL8EF226KE08
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EL8EF226KE08 Port1 Port2
C01 Port1 N01 2.06e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.08e-11
R03 N02 N03 2.24e-03
C04 N03 N04 2.42e-03
R04 N03 N04 2.76e+00
C05 N04 N05 3.67e-03
R05 N04 N05 1.79e-01
C06 N05 N06 2.81e-03
R06 N05 N06 2.85e-02
C07 N06 N07 4.82e-03
R07 N06 N07 2.02e-03
C08 N07 N08 2.25e-03
R08 N07 N08 3.98e-04
L09 N08 N09 1.87e-11
R09 N08 N09 5.20e-02
L10 N09 N10 7.42e-11
R10 N09 N10 2.15e-02
L11 N10 N11 6.03e-10
R11 N10 N11 1.49e-02
C12 N11 N12 4.72e-05
L12 N11 N12 1.58e-10
R12 N11 N12 5.59e-03
C13 N12 N13 5.19e-05
L13 N12 N13 5.79e-11
R13 N12 N13 3.32e-03
C14 N13 N14 4.88e-11
L14 N13 N14 3.23e-11
R14 N13 N14 2.13e+00
C15 N14 Port2 1.05e-12
L15 N14 Port2 2.30e-10
R15 N14 Port2 8.14e+01
.ENDS GCJ32EL8EF226KE08
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GCJ32ER70J476KE01
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER70J476KE01 Port1 Port2
C01 Port1 N01 3.34e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 2.55e-11
R03 N02 N03 7.38e-03
C04 N03 N04 9.73e-04
R04 N03 N04 6.40e+00
C05 N04 N05 1.48e-03
R05 N04 N05 6.87e-01
C06 N05 N06 1.38e-03
R06 N05 N06 1.16e-01
C07 N06 N07 1.13e-03
R07 N06 N07 2.21e-02
C08 N07 N08 8.61e-04
R08 N07 N08 4.71e-03
L09 N08 N09 1.01e-10
R09 N08 N09 3.52e-02
L10 N09 N10 1.56e-11
R10 N09 N10 3.36e-02
L11 N10 N11 6.96e-10
R11 N10 N11 1.01e-02
C12 N11 N12 1.20e-04
L12 N11 N12 9.74e-11
R12 N11 N12 3.18e-03
C13 N12 N13 1.28e-04
L13 N12 N13 4.12e-11
R13 N12 N13 2.51e-03
C14 N13 N14 6.44e-11
L14 N13 N14 4.89e-11
R14 N13 N14 4.04e+00
C15 N14 N15 1.75e-11
L15 N14 N15 6.07e-11
R15 N14 N15 5.48e+00
C16 N15 Port2 1.73e-12
L16 N15 Port2 2.77e-10
R16 N15 Port2 7.07e+01
.ENDS GCJ32ER70J476KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GCJ32ER70J476ME01
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER70J476ME01 Port1 Port2
C01 Port1 N01 3.34e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 2.55e-11
R03 N02 N03 7.38e-03
C04 N03 N04 9.73e-04
R04 N03 N04 6.40e+00
C05 N04 N05 1.48e-03
R05 N04 N05 6.87e-01
C06 N05 N06 1.38e-03
R06 N05 N06 1.16e-01
C07 N06 N07 1.13e-03
R07 N06 N07 2.21e-02
C08 N07 N08 8.61e-04
R08 N07 N08 4.71e-03
L09 N08 N09 1.01e-10
R09 N08 N09 3.52e-02
L10 N09 N10 1.56e-11
R10 N09 N10 3.36e-02
L11 N10 N11 6.96e-10
R11 N10 N11 1.01e-02
C12 N11 N12 1.20e-04
L12 N11 N12 9.74e-11
R12 N11 N12 3.18e-03
C13 N12 N13 1.28e-04
L13 N12 N13 4.12e-11
R13 N12 N13 2.51e-03
C14 N13 N14 6.44e-11
L14 N13 N14 4.89e-11
R14 N13 N14 4.04e+00
C15 N14 N15 1.75e-11
L15 N14 N15 6.07e-11
R15 N14 N15 5.48e+00
C16 N15 Port2 1.73e-12
L16 N15 Port2 2.77e-10
R16 N15 Port2 7.07e+01
.ENDS GCJ32ER70J476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GCJ32ER71C226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER71C226KE01 Port1 Port2
C01 Port1 N01 1.69e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 8.69e-11
R03 N02 N03 1.07e-02
C04 N03 N04 4.62e-04
R04 N03 N04 1.23e+01
C05 N04 N05 5.08e-04
R05 N04 N05 1.26e+00
C06 N05 N06 4.36e-04
R06 N05 N06 1.61e-01
C07 N06 N07 3.10e-04
R07 N06 N07 1.60e-02
L08 N07 N08 1.26e-11
R08 N07 N08 5.26e-02
L09 N08 N09 9.50e-11
R09 N08 N09 4.68e-02
L10 N09 N10 5.58e-10
R10 N09 N10 1.36e-02
C11 N10 N11 4.41e-05
L11 N10 N11 1.11e-10
R11 N10 N11 4.91e-03
C12 N11 N12 5.22e-05
L12 N11 N12 4.04e-11
R12 N11 N12 3.26e-03
C13 N12 N13 5.31e-11
L13 N12 N13 5.66e-11
R13 N12 N13 2.96e+00
C14 N13 N14 1.95e-11
L14 N13 N14 5.23e-11
R14 N13 N14 3.65e+00
C15 N14 Port2 2.27e-12
L15 N14 Port2 1.71e-10
R15 N14 Port2 1.17e+02
.ENDS GCJ32ER71C226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GCJ32ER71C226ME01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER71C226ME01 Port1 Port2
C01 Port1 N01 1.69e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 8.69e-11
R03 N02 N03 1.07e-02
C04 N03 N04 4.62e-04
R04 N03 N04 1.23e+01
C05 N04 N05 5.08e-04
R05 N04 N05 1.26e+00
C06 N05 N06 4.36e-04
R06 N05 N06 1.61e-01
C07 N06 N07 3.10e-04
R07 N06 N07 1.60e-02
L08 N07 N08 1.26e-11
R08 N07 N08 5.26e-02
L09 N08 N09 9.50e-11
R09 N08 N09 4.68e-02
L10 N09 N10 5.58e-10
R10 N09 N10 1.36e-02
C11 N10 N11 4.41e-05
L11 N10 N11 1.11e-10
R11 N10 N11 4.91e-03
C12 N11 N12 5.22e-05
L12 N11 N12 4.04e-11
R12 N11 N12 3.26e-03
C13 N12 N13 5.31e-11
L13 N12 N13 5.66e-11
R13 N12 N13 2.96e+00
C14 N13 N14 1.95e-11
L14 N13 N14 5.23e-11
R14 N13 N14 3.65e+00
C15 N14 Port2 2.27e-12
L15 N14 Port2 1.71e-10
R15 N14 Port2 1.17e+02
.ENDS GCJ32ER71C226ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ32ER71H475KA12
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER71H475KA12 Port1 Port2
C01 Port1 N01 4.39e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.75e-11
R03 N02 N03 1.10e-02
C04 N03 N04 6.89e-04
R04 N03 N04 7.70e+00
C05 N04 N05 9.49e-04
R05 N04 N05 8.30e-01
C06 N05 N06 5.81e-04
R06 N05 N06 2.49e-01
C07 N06 N07 8.93e-04
R07 N06 N07 2.42e-02
C08 N07 N08 3.58e-04
R08 N07 N08 1.05e-02
L09 N08 N09 6.20e-11
R09 N08 N09 6.14e-02
L10 N09 N10 4.52e-10
R10 N09 N10 2.35e-02
C11 N10 N11 9.73e-06
L11 N10 N11 1.22e-10
R11 N10 N11 1.42e-02
C12 N11 N12 1.23e-05
L12 N11 N12 3.90e-11
R12 N11 N12 9.49e-03
C13 N12 N13 2.35e-11
L13 N12 N13 6.81e-11
R13 N12 N13 5.05e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 2.77e-10
R14 N13 Port2 6.56e+01
.ENDS GCJ32ER71H475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ32ER71H475MA12
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER71H475MA12 Port1 Port2
C01 Port1 N01 4.39e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.75e-11
R03 N02 N03 1.10e-02
C04 N03 N04 6.89e-04
R04 N03 N04 7.70e+00
C05 N04 N05 9.49e-04
R05 N04 N05 8.30e-01
C06 N05 N06 5.81e-04
R06 N05 N06 2.49e-01
C07 N06 N07 8.93e-04
R07 N06 N07 2.42e-02
C08 N07 N08 3.58e-04
R08 N07 N08 1.05e-02
L09 N08 N09 6.20e-11
R09 N08 N09 6.14e-02
L10 N09 N10 4.52e-10
R10 N09 N10 2.35e-02
C11 N10 N11 9.73e-06
L11 N10 N11 1.22e-10
R11 N10 N11 1.42e-02
C12 N11 N12 1.23e-05
L12 N11 N12 3.90e-11
R12 N11 N12 9.49e-03
C13 N12 N13 2.35e-11
L13 N12 N13 6.81e-11
R13 N12 N13 5.05e+00
C14 N13 Port2 1.36e-12
L14 N13 Port2 2.77e-10
R14 N13 Port2 6.56e+01
.ENDS GCJ32ER71H475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8R(-55to150[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ32ER91C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER91C106KE01 Port1 Port2
C01 Port1 N01 9.35e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.86e-12
R03 N02 N03 2.98e-03
C04 N03 N04 4.13e-04
R04 N03 N04 9.30e+00
C05 N04 N05 4.30e-04
R05 N04 N05 8.98e-01
C06 N05 N06 3.58e-04
R06 N05 N06 1.18e-01
C07 N06 N07 3.97e-04
R07 N06 N07 1.16e-02
C08 N07 N08 4.89e-04
R08 N07 N08 2.79e-03
L09 N08 N09 3.65e-11
R09 N08 N09 4.02e-02
L10 N09 N10 4.59e-10
R10 N09 N10 2.76e-02
C11 N10 N11 2.10e-05
L11 N10 N11 1.23e-10
R11 N10 N11 1.04e-02
C12 N11 N12 1.01e-05
L12 N11 N12 1.06e-10
R12 N11 N12 7.89e-03
C13 N12 N13 9.42e-12
L13 N12 N13 7.80e-11
R13 N12 N13 1.49e+01
C14 N13 Port2 1.55e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 8.66e+01
.ENDS GCJ32ER91C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8R(-55to150[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ32ER91C106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER91C106ME01 Port1 Port2
C01 Port1 N01 9.35e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.86e-12
R03 N02 N03 2.98e-03
C04 N03 N04 4.13e-04
R04 N03 N04 9.30e+00
C05 N04 N05 4.30e-04
R05 N04 N05 8.98e-01
C06 N05 N06 3.58e-04
R06 N05 N06 1.18e-01
C07 N06 N07 3.97e-04
R07 N06 N07 1.16e-02
C08 N07 N08 4.89e-04
R08 N07 N08 2.79e-03
L09 N08 N09 3.65e-11
R09 N08 N09 4.02e-02
L10 N09 N10 4.59e-10
R10 N09 N10 2.76e-02
C11 N10 N11 2.10e-05
L11 N10 N11 1.23e-10
R11 N10 N11 1.04e-02
C12 N11 N12 1.01e-05
L12 N11 N12 1.06e-10
R12 N11 N12 7.89e-03
C13 N12 N13 9.42e-12
L13 N12 N13 7.80e-11
R13 N12 N13 1.49e+01
C14 N13 Port2 1.55e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 8.66e+01
.ENDS GCJ32ER91C106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8R(-55to150[deg])/6.80e+00[uF]/16[V]
* Murata P/N :GCJ32ER91C685KE01
* Property : C = 6.80e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER91C685KE01 Port1 Port2
C01 Port1 N01 6.62e-06
R01 Port1 N01 7.35e+06
L02 N01 N02 1.02e-10
R03 N02 N03 4.41e-03
C04 N03 N04 3.52e-04
R04 N03 N04 1.51e+01
C05 N04 N05 4.09e-04
R05 N04 N05 2.36e+00
C06 N05 N06 2.78e-04
R06 N05 N06 4.32e-01
C07 N06 N07 2.43e-04
R07 N06 N07 5.83e-02
C08 N07 N08 1.82e-04
R08 N07 N08 7.64e-03
C09 N08 N09 1.23e-03
R09 N08 N09 1.92e-04
L10 N09 N10 1.08e-11
R10 N09 N10 3.93e-02
L11 N10 N11 5.07e-11
R11 N10 N11 2.32e-02
L12 N11 N12 3.77e-10
R12 N11 N12 1.94e-02
C13 N12 N13 1.51e-05
L13 N12 N13 1.05e-10
R13 N12 N13 1.22e-02
C14 N13 N14 8.04e-06
L14 N13 N14 8.09e-11
R14 N13 N14 9.45e-03
C15 N14 N15 1.58e-11
L15 N14 N15 8.79e-11
R15 N14 N15 1.90e+01
C16 N15 Port2 2.26e-12
L16 N15 Port2 2.08e-10
R16 N15 Port2 1.02e+02
.ENDS GCJ32ER91C685KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-01[uF]/250[V]
* Murata P/N :GCJ32QR72E154KXJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72E154KXJ1 Port1 Port2
C01 Port1 N01 1.48e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.39e-10
R03 N02 N03 1.48e-02
C04 N03 N04 1.37e-05
R04 N03 N04 1.16e-01
C05 N04 N05 1.98e-05
R05 N04 N05 2.54e-02
C06 N05 N06 1.65e-05
R06 N05 N06 6.09e-03
L07 N06 N07 3.83e-11
R07 N06 N07 2.05e-01
L08 N07 N08 1.60e-10
R08 N07 N08 7.96e-02
C09 N08 N09 5.34e-07
L09 N08 N09 3.52e-11
R09 N08 N09 2.75e-02
C10 N09 N10 1.54e-07
L10 N09 N10 4.44e-11
R10 N09 N10 3.39e-02
C11 N10 Port2 8.27e-12
L11 N10 Port2 1.50e-10
R11 N10 Port2 2.69e+01
.ENDS GCJ32QR72E154KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GCJ32QR72E683KXJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72E683KXJ1 Port1 Port2
C01 Port1 N01 6.39e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 2.49e-10
R03 N02 N03 2.86e-02
C04 N03 N04 4.73e-06
R04 N03 N04 3.37e-01
C05 N04 N05 4.95e-06
R05 N04 N05 2.56e-02
C06 N05 N06 1.64e-05
R06 N05 N06 2.44e-02
L07 N06 N07 6.29e-11
R07 N06 N07 1.06e-01
L08 N07 N08 9.31e-12
R08 N07 N08 5.33e-02
C09 N08 N09 3.16e-07
L09 N08 N09 2.16e-11
R09 N08 N09 2.61e-02
C10 N09 N10 2.40e-08
L10 N09 N10 7.14e-11
R10 N09 N10 5.46e-02
C11 N10 Port2 5.37e-12
L11 N10 Port2 2.78e-10
R11 N10 Port2 2.86e+01
.ENDS GCJ32QR72E683KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GCJ32QR72J103KXJ1
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72J103KXJ1 Port1 Port2
C01 Port1 N01 9.62e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 6.38e-02
C04 N03 N04 4.97e-07
R04 N03 N04 3.20e+00
C05 N04 N05 8.84e-07
R05 N04 N05 1.80e-01
C06 N05 N06 7.88e-07
R06 N05 N06 7.17e-02
C07 N06 N07 3.29e-07
R07 N06 N07 2.16e-02
L08 N07 N08 9.63e-11
R08 N07 N08 7.60e-01
C09 N08 N09 2.72e-08
L09 N08 N09 2.75e-11
R09 N08 N09 7.98e-02
C10 N09 N10 3.94e-09
L10 N09 N10 5.00e-11
R10 N09 N10 1.42e-01
C11 N10 Port2 6.24e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 3.48e+01
.ENDS GCJ32QR72J103KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-03[uF]/630[V]
* Murata P/N :GCJ32QR72J682KXJ1
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72J682KXJ1 Port1 Port2
C01 Port1 N01 6.63e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.69e-10
R03 N02 N03 7.82e-02
C04 N03 N04 3.08e-07
R04 N03 N04 5.17e+00
C05 N04 N05 5.73e-07
R05 N04 N05 2.78e-01
C06 N05 N06 9.29e-07
R06 N05 N06 8.58e-02
C07 N06 N07 2.68e-07
R07 N06 N07 5.67e-02
C08 N07 N08 3.87e-07
R08 N07 N08 6.51e-03
L09 N08 N09 8.50e-11
R09 N08 N09 9.06e-01
C10 N09 N10 2.35e-08
L10 N09 N10 1.46e-11
R10 N09 N10 6.26e-02
C11 N10 N11 5.14e-09
L11 N10 N11 1.92e-11
R11 N10 N11 1.22e-01
C12 N11 Port2 7.09e-12
L12 N11 Port2 3.19e-10
R12 N11 Port2 3.36e+01
.ENDS GCJ32QR72J682KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GCJ43DR72E224KXJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72E224KXJ1 Port1 Port2
C01 Port1 N01 2.22e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.23e-10
R03 N02 N03 1.47e-02
C04 N03 N04 2.00e-05
R04 N03 N04 7.96e-02
C05 N04 N05 2.96e-05
R05 N04 N05 1.35e-02
C06 N05 N06 5.51e-05
R06 N05 N06 2.89e-03
L07 N06 N07 1.78e-11
R07 N06 N07 1.34e-01
L08 N07 N08 1.70e-10
R08 N07 N08 7.72e-02
C09 N08 N09 5.74e-07
L09 N08 N09 6.84e-11
R09 N08 N09 3.45e-02
C10 N09 N10 1.82e-07
L10 N09 N10 6.84e-11
R10 N09 N10 3.45e-02
C11 N10 Port2 7.74e-12
L11 N10 Port2 2.92e-10
R11 N10 Port2 3.30e+01
.ENDS GCJ43DR72E224KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GCJ43DR72E334KXJ1
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72E334KXJ1 Port1 Port2
C01 Port1 N01 3.26e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 3.30e-10
R03 N02 N03 1.24e-02
C04 N03 N04 3.43e-05
R04 N03 N04 4.64e-02
C05 N04 N05 5.19e-05
R05 N04 N05 9.70e-03
C06 N05 N06 8.23e-05
R06 N05 N06 1.93e-03
L07 N06 N07 1.50e-11
R07 N06 N07 1.05e-01
L08 N07 N08 1.53e-10
R08 N07 N08 8.18e-02
C09 N08 N09 8.70e-07
L09 N08 N09 5.95e-11
R09 N08 N09 2.08e-02
C10 N09 N10 2.14e-07
L10 N09 N10 8.03e-11
R10 N09 N10 3.07e-02
C11 N10 Port2 6.75e-12
L11 N10 Port2 3.35e-10
R11 N10 Port2 3.87e+01
.ENDS GCJ43DR72E334KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :GCJ43DR72E474KXJ1
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72E474KXJ1 Port1 Port2
C01 Port1 N01 4.69e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 2.50e-10
R03 N02 N03 8.74e-03
C04 N03 N04 4.88e-05
R04 N03 N04 3.26e-02
C05 N04 N05 1.04e-04
R05 N04 N05 6.07e-03
C06 N05 N06 6.01e-05
R06 N05 N06 4.20e-03
L07 N06 N07 1.47e-11
R07 N06 N07 6.69e-02
L08 N07 N08 1.98e-10
R08 N07 N08 6.53e-02
C09 N08 N09 8.61e-07
L09 N08 N09 9.98e-11
R09 N08 N09 3.03e-02
C10 N09 N10 4.03e-07
L10 N09 N10 7.74e-11
R10 N09 N10 2.77e-02
C11 N10 Port2 5.69e-12
L11 N10 Port2 2.62e-10
R11 N10 Port2 3.48e+01
.ENDS GCJ43DR72E474KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GCJ43DR72J104KXJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72J104KXJ1 Port1 Port2
C01 Port1 N01 9.88e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 3.07e-10
R03 N02 N03 1.41e-02
C04 N03 N04 7.18e-06
R04 N03 N04 2.22e-01
C05 N04 N05 7.69e-06
R05 N04 N05 2.49e-02
C06 N05 N06 8.24e-06
R06 N05 N06 1.64e-03
L07 N06 N07 1.58e-10
R07 N06 N07 1.14e-01
L08 N07 N08 1.48e-11
R08 N07 N08 7.88e-02
C09 N08 N09 1.82e-07
L09 N08 N09 9.89e-11
R09 N08 N09 9.73e-02
C10 N09 N10 8.49e-08
L10 N09 N10 8.04e-11
R10 N09 N10 8.28e-02
C11 N10 Port2 7.57e-12
L11 N10 Port2 2.16e-10
R11 N10 Port2 3.37e+01
.ENDS GCJ43DR72J104KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :GCJ43DR72J333KXJ1
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72J333KXJ1 Port1 Port2
C01 Port1 N01 3.27e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 2.18e-10
R03 N02 N03 2.77e-02
C04 N03 N04 2.80e-06
R04 N03 N04 5.69e-01
C05 N04 N05 4.97e-06
R05 N04 N05 8.04e-02
C06 N05 N06 2.80e-06
R06 N05 N06 4.42e-02
C07 N06 N07 9.48e-07
R07 N06 N07 1.06e-02
L08 N07 N08 1.62e-10
R08 N07 N08 2.67e-01
C09 N08 N09 8.11e-08
L09 N08 N09 5.31e-11
R09 N08 N09 8.09e-02
C10 N09 N10 2.75e-08
L10 N09 N10 4.96e-11
R10 N09 N10 8.47e-02
C11 N10 Port2 5.36e-12
L11 N10 Port2 4.63e-10
R11 N10 Port2 4.77e+01
.ENDS GCJ43DR72J333KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GCJ43DR72J473KXJ1
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72J473KXJ1 Port1 Port2
C01 Port1 N01 4.98e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 2.24e-10
R03 N02 N03 2.20e-02
C04 N03 N04 3.78e-06
R04 N03 N04 4.21e-01
C05 N04 N05 9.95e-06
R05 N04 N05 3.05e-02
C06 N05 N06 3.78e-06
R06 N05 N06 2.66e-02
C07 N06 N07 4.24e-06
R07 N06 N07 2.37e-03
L08 N07 N08 1.53e-10
R08 N07 N08 1.96e-01
L09 N08 N09 1.93e-11
R09 N08 N09 1.63e-01
C10 N09 N10 1.02e-07
L10 N09 N10 8.42e-11
R10 N09 N10 1.09e-01
C11 N10 N11 4.16e-08
L11 N10 N11 7.17e-11
R11 N10 N11 1.04e-01
C12 N11 Port2 5.87e-12
L12 N11 Port2 2.79e-10
R12 N11 Port2 4.55e+01
.ENDS GCJ43DR72J473KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-02[uF]/1000[V]
* Murata P/N :GCJ43DR73A333KXJ1
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR73A333KXJ1 Port1 Port2
C01 Port1 N01 3.27e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 2.18e-10
R03 N02 N03 2.77e-02
C04 N03 N04 2.80e-06
R04 N03 N04 5.69e-01
C05 N04 N05 4.97e-06
R05 N04 N05 8.04e-02
C06 N05 N06 2.80e-06
R06 N05 N06 4.42e-02
C07 N06 N07 9.48e-07
R07 N06 N07 1.06e-02
L08 N07 N08 1.62e-10
R08 N07 N08 2.67e-01
C09 N08 N09 8.11e-08
L09 N08 N09 5.31e-11
R09 N08 N09 8.09e-02
C10 N09 N10 2.75e-08
L10 N09 N10 4.96e-11
R10 N09 N10 8.47e-02
C11 N10 Port2 5.36e-12
L11 N10 Port2 4.63e-10
R11 N10 Port2 4.77e+01
.ENDS GCJ43DR73A333KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/1000[V]
* Murata P/N :GCJ43DR73A473KXJ1
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR73A473KXJ1 Port1 Port2
C01 Port1 N01 4.98e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 2.24e-10
R03 N02 N03 2.20e-02
C04 N03 N04 3.78e-06
R04 N03 N04 4.21e-01
C05 N04 N05 9.95e-06
R05 N04 N05 3.05e-02
C06 N05 N06 3.78e-06
R06 N05 N06 2.66e-02
C07 N06 N07 4.24e-06
R07 N06 N07 2.37e-03
L08 N07 N08 1.53e-10
R08 N07 N08 1.96e-01
L09 N08 N09 1.93e-11
R09 N08 N09 1.63e-01
C10 N09 N10 1.02e-07
L10 N09 N10 8.42e-11
R10 N09 N10 1.09e-01
C11 N10 N11 4.16e-08
L11 N10 N11 7.17e-11
R11 N10 N11 1.04e-01
C12 N11 Port2 5.87e-12
L12 N11 Port2 2.79e-10
R12 N11 Port2 4.55e+01
.ENDS GCJ43DR73A473KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.50e-01[uF]/250[V]
* Murata P/N :GCJ43QR72E154KXJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43QR72E154KXJ1 Port1 Port2
C01 Port1 N01 1.50e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.77e-10
R03 N02 N03 2.14e-02
C04 N03 N04 1.41e-05
R04 N03 N04 1.13e-01
C05 N04 N05 2.04e-05
R05 N04 N05 1.96e-02
C06 N05 N06 2.24e-05
R06 N05 N06 6.64e-03
L07 N06 N07 3.54e-11
R07 N06 N07 1.50e-01
L08 N07 N08 1.29e-10
R08 N07 N08 1.09e-01
C09 N08 N09 3.91e-07
L09 N08 N09 4.59e-11
R09 N08 N09 2.16e-02
C10 N09 N10 6.64e-08
L10 N09 N10 7.64e-11
R10 N09 N10 3.36e-02
C11 N10 Port2 6.80e-12
L11 N10 Port2 2.76e-10
R11 N10 Port2 2.54e+01
.ENDS GCJ43QR72E154KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/6.80e-02[uF]/630[V]
* Murata P/N :GCJ43QR72J683KXJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43QR72J683KXJ1 Port1 Port2
C01 Port1 N01 6.72e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 3.45e-10
R03 N02 N03 1.88e-02
C04 N03 N04 5.41e-06
R04 N03 N04 2.94e-01
C05 N04 N05 6.36e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.30e-06
R06 N05 N06 1.14e-02
L07 N06 N07 2.00e-11
R07 N06 N07 1.69e-01
L08 N07 N08 1.26e-10
R08 N07 N08 1.20e-01
C09 N08 N09 1.35e-07
L09 N08 N09 6.65e-11
R09 N08 N09 8.24e-02
C10 N09 N10 4.91e-08
L10 N09 N10 6.35e-11
R10 N09 N10 9.03e-02
C11 N10 Port2 1.38e-11
L11 N10 Port2 1.56e-10
R11 N10 Port2 2.12e+01
.ENDS GCJ43QR72J683KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :GCJ55DR72E105KXJ1
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E105KXJ1 Port1 Port2
C01 Port1 N01 1.07e-06
R01 Port1 N01 1.00e+08
L02 N01 N02 1.33e-10
R03 N02 N03 6.64e-03
C04 N03 N04 1.00e-05
R04 N03 N04 5.30e+02
C05 N04 N05 1.32e-04
R05 N04 N05 4.02e-01
C06 N05 N06 1.12e-04
R06 N05 N06 5.06e-02
C07 N06 N07 7.95e-05
R07 N06 N07 6.67e-03
L08 N07 N08 2.27e-11
R08 N07 N08 1.16e-01
L09 N08 N09 1.53e-10
R09 N08 N09 5.67e-02
C10 N09 N10 1.69e-06
L10 N09 N10 9.73e-11
R10 N09 N10 1.90e-02
C11 N10 N11 3.97e-07
L11 N10 N11 1.14e-10
R11 N10 N11 2.14e-02
C12 N11 Port2 6.30e-12
L12 N11 Port2 3.30e-10
R12 N11 Port2 7.40e+01
.ENDS GCJ55DR72E105KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GCJ55DR72E334KXJ1
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E334KXJ1 Port1 Port2
C01 Port1 N01 3.32e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 1.52e-10
R03 N02 N03 1.38e-02
C04 N03 N04 3.24e-05
R04 N03 N04 4.91e-02
C05 N04 N05 6.17e-05
R05 N04 N05 8.15e-03
C06 N05 N06 3.89e-05
R06 N05 N06 3.25e-03
L07 N06 N07 6.84e-12
R07 N06 N07 6.96e-02
L08 N07 N08 1.43e-10
R08 N07 N08 5.92e-02
C09 N08 N09 6.47e-07
L09 N08 N09 5.80e-11
R09 N08 N09 1.89e-02
C10 N09 N10 3.10e-07
L10 N09 N10 3.32e-11
R10 N09 N10 1.49e-02
C11 N10 Port2 6.47e-12
L11 N10 Port2 5.05e-10
R11 N10 Port2 4.97e+01
.ENDS GCJ55DR72E334KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :GCJ55DR72E474KXJ1
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E474KXJ1 Port1 Port2
C01 Port1 N01 4.61e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 1.92e-10
R03 N02 N03 8.42e-03
C04 N03 N04 4.30e-05
R04 N03 N04 3.70e-02
C05 N04 N05 5.93e-05
R05 N04 N05 8.48e-03
C06 N05 N06 8.58e-05
R06 N05 N06 1.17e-03
L07 N06 N07 2.85e-11
R07 N06 N07 1.39e-01
L08 N07 N08 1.19e-10
R08 N07 N08 7.11e-02
C09 N08 N09 9.30e-07
L09 N08 N09 7.01e-11
R09 N08 N09 3.30e-02
C10 N09 N10 1.85e-07
L10 N09 N10 1.06e-10
R10 N09 N10 3.79e-02
C11 N10 Port2 8.10e-12
L11 N10 Port2 3.06e-10
R11 N10 Port2 6.15e+01
.ENDS GCJ55DR72E474KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-01[uF]/250[V]
* Murata P/N :GCJ55DR72E684KXJ1
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E684KXJ1 Port1 Port2
C01 Port1 N01 6.68e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 2.42e-10
R03 N02 N03 8.51e-03
C04 N03 N04 6.36e-05
R04 N03 N04 2.50e-02
C05 N04 N05 2.01e-04
R05 N04 N05 3.15e-03
C06 N05 N06 1.18e-04
R06 N05 N06 1.69e-03
L07 N06 N07 3.60e-11
R07 N06 N07 1.92e-01
L08 N07 N08 1.57e-10
R08 N07 N08 5.06e-02
C09 N08 N09 1.17e-06
L09 N08 N09 7.03e-11
R09 N08 N09 1.90e-02
C10 N09 N10 4.54e-07
L10 N09 N10 5.21e-11
R10 N09 N10 1.70e-02
C11 N10 Port2 9.07e-12
L11 N10 Port2 3.29e-10
R11 N10 Port2 6.30e+01
.ENDS GCJ55DR72E684KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GCJ55DR72J104KXJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72J104KXJ1 Port1 Port2
C01 Port1 N01 1.00e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 7.63e-11
R03 N02 N03 1.35e-02
C04 N03 N04 8.44e-06
R04 N03 N04 1.88e-01
C05 N04 N05 2.33e-05
R05 N04 N05 1.37e-02
C06 N05 N06 9.47e-06
R06 N05 N06 1.30e-02
C07 N06 N07 7.02e-06
R07 N06 N07 2.72e-03
L08 N07 N08 1.72e-10
R08 N07 N08 1.92e-01
C09 N08 N09 1.69e-07
L09 N08 N09 8.45e-11
R09 N08 N09 8.91e-02
C10 N09 N10 6.41e-08
L10 N09 N10 6.72e-11
R10 N09 N10 7.24e-02
C11 N10 Port2 5.46e-12
L11 N10 Port2 4.14e-10
R11 N10 Port2 6.03e+01
.ENDS GCJ55DR72J104KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :GCJ55DR72J154KXJ1
* Property : C = 1.50e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72J154KXJ1 Port1 Port2
C01 Port1 N01 1.46e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 1.11e-10
R03 N02 N03 1.32e-02
C04 N03 N04 1.08e-05
R04 N03 N04 1.48e-01
C05 N04 N05 2.47e-05
R05 N04 N05 1.17e-02
C06 N05 N06 1.52e-05
R06 N05 N06 9.75e-03
L07 N06 N07 1.13e-10
R07 N06 N07 1.04e-01
C08 N07 N08 2.66e-07
L08 N07 N08 6.76e-11
R08 N07 N08 5.66e-02
C09 N08 N09 8.80e-08
L09 N08 N09 6.16e-11
R09 N08 N09 5.28e-02
C10 N09 Port2 6.38e-12
L10 N09 Port2 5.13e-10
R10 N09 Port2 4.93e+01
.ENDS GCJ55DR72J154KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :GCJ55DR72J224KXJ1
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72J224KXJ1 Port1 Port2
C01 Port1 N01 2.29e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.32e-11
R03 N02 N03 8.26e-03
C04 N03 N04 2.00e-05
R04 N03 N04 7.97e-02
C05 N04 N05 2.14e-05
R05 N04 N05 1.45e-02
C06 N05 N06 1.48e-05
R06 N05 N06 1.42e-03
L07 N06 N07 1.20e-11
R07 N06 N07 1.02e-01
L08 N07 N08 1.41e-10
R08 N07 N08 9.06e-02
C09 N08 N09 3.42e-07
L09 N08 N09 1.15e-10
R09 N08 N09 7.99e-02
C10 N09 N10 1.27e-07
L10 N09 N10 1.02e-10
R10 N09 N10 6.80e-02
C11 N10 Port2 4.41e-12
L11 N10 Port2 3.89e-10
R11 N10 Port2 9.61e+01
.ENDS GCJ55DR72J224KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-01[uF]/1000[V]
* Murata P/N :GCJ55DR73A104KXJ1
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR73A104KXJ1 Port1 Port2
C01 Port1 N01 1.00e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 7.63e-11
R03 N02 N03 1.35e-02
C04 N03 N04 8.44e-06
R04 N03 N04 1.88e-01
C05 N04 N05 2.33e-05
R05 N04 N05 1.37e-02
C06 N05 N06 9.47e-06
R06 N05 N06 1.30e-02
C07 N06 N07 7.02e-06
R07 N06 N07 2.72e-03
L08 N07 N08 1.72e-10
R08 N07 N08 1.92e-01
C09 N08 N09 1.69e-07
L09 N08 N09 8.45e-11
R09 N08 N09 8.91e-02
C10 N09 N10 6.41e-08
L10 N09 N10 6.72e-11
R10 N09 N10 7.24e-02
C11 N10 Port2 5.46e-12
L11 N10 Port2 4.14e-10
R11 N10 Port2 6.03e+01
.ENDS GCJ55DR73A104KXJ1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-02[uF]/1000[V]
* Murata P/N :GCJ55DR73A683KXJ1
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR73A683KXJ1 Port1 Port2
C01 Port1 N01 6.77e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 1.70e-10
R03 N02 N03 1.98e-02
C04 N03 N04 5.18e-06
R04 N03 N04 3.07e-01
C05 N04 N05 6.37e-06
R05 N04 N05 2.33e-02
C06 N05 N06 1.64e-05
R06 N05 N06 1.85e-02
C07 N06 N07 3.58e-06
R07 N06 N07 4.44e-03
L08 N07 N08 8.64e-12
R08 N07 N08 1.84e-01
L09 N08 N09 6.71e-11
R09 N08 N09 9.86e-02
C10 N09 N10 1.33e-07
L10 N09 N10 5.13e-11
R10 N09 N10 5.79e-02
C11 N10 N11 3.75e-08
L11 N10 N11 5.01e-11
R11 N10 N11 5.79e-02
C12 N11 Port2 6.99e-12
L12 N11 Port2 5.13e-10
R12 N11 Port2 5.16e+01
.ENDS GCJ55DR73A683KXJ1
