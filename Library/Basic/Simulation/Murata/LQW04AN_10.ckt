*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN36NJ10
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN36NJ10 port1 port2
C1 port1 port2 4.81e-15
L2 port1 1 3.68e-8
R2 1 port2 9.00e-1
R3 port1 port2 2.97e+4
L4 port1 2 3.41e-6
R4 2 port2 283
L5 port1 3 6.57e-7
R5 3 port2 507
L6 port1 4 1.01e-6
R6 4 port2 3.94e+3
L7 port1 5 3.18e-8
C7 5 6 1.64e-14
R7 6 port2 26.0
.ENDS LQW04AN36NJ10
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN39NJ10
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN39NJ10 port1 port2
C1 port1 port2 5.92e-14
L2 port1 1 4.03e-8
R2 1 port2 9.00e-1
R3 port1 port2 2.97e+4
L4 port1 2 3.41e-6
R4 2 port2 283
L5 port1 3 5.59e-7
R5 3 port2 507
L6 port1 4 1.01e-6
R6 4 port2 4.42e+3
L7 port1 5 2.10e-8
C7 5 6 2.99e-14
R7 6 port2 62.3
.ENDS LQW04AN39NJ10
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN43NJ10
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN43NJ10 port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 4.32e-8
R2 1 port2 1.00
R3 port1 port2 2.77e+4
L4 port1 2 3.04e-6
R4 2 port2 283
L5 port1 3 6.13e-7
R5 3 port2 507
L6 port1 4 1.27e-6
R6 4 port2 5.56e+3
L7 port1 5 3.83e-8
C7 5 6 2.02e-14
R7 6 port2 54.3
.ENDS LQW04AN43NJ10
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN47NJ10
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN47NJ10 port1 port2
C1 port1 port2 1.96e-14
L2 port1 1 4.74e-8
R2 1 port2 1.00
R3 port1 port2 3.74e+4
L4 port1 2 3.04e-6
R4 2 port2 283
L5 port1 3 6.88e-7
R5 3 port2 596
L6 port1 4 1.27e-6
R6 4 port2 6.53e+3
L7 port1 5 1.92e-8
C7 5 6 4.74e-14
R7 6 port2 24.2
.ENDS LQW04AN47NJ10
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN52NJ10
* Property : L = 52[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN52NJ10 port1 port2
C1 port1 port2 2.58e-14
L2 port1 1 5.32e-8
R2 1 port2 1.10
R3 port1 port2 3.74e+4
L4 port1 2 2.77e-6
R4 2 port2 332
L5 port1 3 7.90e-7
R5 3 port2 654
L6 port1 4 1.27e-6
R6 4 port2 5.43e+3
L7 port1 5 2.84e-8
C7 5 6 4.13e-14
R7 6 port2 44.0
.ENDS LQW04AN52NJ10
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW04AN56NJ10
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW04AN56NJ10 port1 port2
C1 port1 port2 3.57e-14
L2 port1 1 6.10e-8
R2 1 port2 1.10
R3 port1 port2 4.60e+4
L4 port1 2 9.64e-7
R4 2 port2 20.1
L5 port1 3 6.53e-7
R5 3 port2 512
L6 port1 4 1.28e-6
R6 4 port2 6.29e+3
L7 port1 5 2.31e-8
C7 5 6 5.55e-14
R7 6 port2 32.0
.ENDS LQW04AN56NJ10
*----------------------------------------------------------------------
