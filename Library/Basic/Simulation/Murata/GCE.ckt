*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E273KA01 Port1 Port2
C01 Port1 N01 2.60e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.73e-02
C04 N03 N04 1.19e-06
R04 N03 N04 2.56e+00
C05 N04 N05 1.77e-06
R05 N04 N05 1.89e-01
C06 N05 N06 1.85e-06
R06 N05 N06 3.10e-02
L07 N06 N07 1.00e-10
R07 N06 N07 1.38e-01
C08 N07 N08 1.28e-07
L08 N07 N08 1.98e-11
R08 N07 N08 2.60e-02
C09 N08 N09 4.23e-08
L09 N08 N09 3.09e-11
R09 N08 N09 6.56e-02
C10 N09 N10 4.26e-12
L10 N09 N10 1.83e-10
R10 N09 N10 2.40e+01
C11 N10 Port2 2.64e-12
L11 N10 Port2 1.43e-10
R11 N10 Port2 3.16e+01
.ENDS GCE188R71E273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E273MA01 Port1 Port2
C01 Port1 N01 2.60e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.73e-02
C04 N03 N04 1.19e-06
R04 N03 N04 2.56e+00
C05 N04 N05 1.77e-06
R05 N04 N05 1.89e-01
C06 N05 N06 1.85e-06
R06 N05 N06 3.10e-02
L07 N06 N07 1.00e-10
R07 N06 N07 1.38e-01
C08 N07 N08 1.28e-07
L08 N07 N08 1.98e-11
R08 N07 N08 2.60e-02
C09 N08 N09 4.23e-08
L09 N08 N09 3.09e-11
R09 N08 N09 6.56e-02
C10 N09 N10 4.26e-12
L10 N09 N10 1.83e-10
R10 N09 N10 2.40e+01
C11 N10 Port2 2.64e-12
L11 N10 Port2 1.43e-10
R11 N10 Port2 3.16e+01
.ENDS GCE188R71E273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCE188R71E333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E333KA01 Port1 Port2
C01 Port1 N01 3.27e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 3.18e-02
C04 N03 N04 1.52e-06
R04 N03 N04 2.09e+00
C05 N04 N05 2.17e-06
R05 N04 N05 1.68e-01
C06 N05 N06 1.92e-06
R06 N05 N06 2.56e-02
L07 N06 N07 1.06e-10
R07 N06 N07 1.25e-01
C08 N07 N08 4.84e-07
L08 N07 N08 8.35e-12
R08 N07 N08 1.33e-02
C09 N08 N09 3.76e-08
L09 N08 N09 4.84e-11
R09 N08 N09 6.35e-02
C10 N09 N10 5.10e-12
L10 N09 N10 1.36e-10
R10 N09 N10 1.93e+01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.51e-10
R11 N10 Port2 3.80e+01
.ENDS GCE188R71E333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCE188R71E333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E333MA01 Port1 Port2
C01 Port1 N01 3.27e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 3.18e-02
C04 N03 N04 1.52e-06
R04 N03 N04 2.09e+00
C05 N04 N05 2.17e-06
R05 N04 N05 1.68e-01
C06 N05 N06 1.92e-06
R06 N05 N06 2.56e-02
L07 N06 N07 1.06e-10
R07 N06 N07 1.25e-01
C08 N07 N08 4.84e-07
L08 N07 N08 8.35e-12
R08 N07 N08 1.33e-02
C09 N08 N09 3.76e-08
L09 N08 N09 4.84e-11
R09 N08 N09 6.35e-02
C10 N09 N10 5.10e-12
L10 N09 N10 1.36e-10
R10 N09 N10 1.93e+01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.51e-10
R11 N10 Port2 3.80e+01
.ENDS GCE188R71E333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCE188R71E393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E393KA01 Port1 Port2
C01 Port1 N01 4.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 2.98e-02
C04 N03 N04 2.08e-06
R04 N03 N04 1.31e+00
C05 N04 N05 3.92e-06
R05 N04 N05 1.23e-01
C06 N05 N06 2.06e-06
R06 N05 N06 3.54e-02
L07 N06 N07 1.39e-10
R07 N06 N07 1.32e-01
C08 N07 N08 2.89e-07
L08 N07 N08 1.97e-11
R08 N07 N08 2.60e-02
C09 N08 N09 7.21e-08
L09 N08 N09 3.58e-11
R09 N08 N09 5.52e-02
C10 N09 N10 5.71e-12
L10 N09 N10 9.60e-11
R10 N09 N10 1.60e+01
C11 N10 Port2 3.74e-12
L11 N10 Port2 9.11e-11
R11 N10 Port2 3.01e+01
.ENDS GCE188R71E393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCE188R71E393MA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E393MA01 Port1 Port2
C01 Port1 N01 4.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 2.98e-02
C04 N03 N04 2.08e-06
R04 N03 N04 1.31e+00
C05 N04 N05 3.92e-06
R05 N04 N05 1.23e-01
C06 N05 N06 2.06e-06
R06 N05 N06 3.54e-02
L07 N06 N07 1.39e-10
R07 N06 N07 1.32e-01
C08 N07 N08 2.89e-07
L08 N07 N08 1.97e-11
R08 N07 N08 2.60e-02
C09 N08 N09 7.21e-08
L09 N08 N09 3.58e-11
R09 N08 N09 5.52e-02
C10 N09 N10 5.71e-12
L10 N09 N10 9.60e-11
R10 N09 N10 1.60e+01
C11 N10 Port2 3.74e-12
L11 N10 Port2 9.11e-11
R11 N10 Port2 3.01e+01
.ENDS GCE188R71E393MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E473KA01 Port1 Port2
C01 Port1 N01 4.87e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 2.58e-02
C04 N03 N04 2.37e-06
R04 N03 N04 9.13e-01
C05 N04 N05 3.48e-06
R05 N04 N05 6.20e-02
C06 N05 N06 3.43e-06
R06 N05 N06 9.87e-03
L07 N06 N07 1.58e-10
R07 N06 N07 1.28e-01
L08 N07 N08 4.41e-12
R08 N07 N08 4.68e-02
C09 N08 N09 3.10e-07
L09 N08 N09 2.23e-11
R09 N08 N09 3.09e-02
C10 N09 N10 1.02e-07
L10 N09 N10 3.47e-11
R10 N09 N10 5.60e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 1.48e-10
R11 N10 Port2 3.05e+01
.ENDS GCE188R71E473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E473MA01 Port1 Port2
C01 Port1 N01 4.87e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 2.58e-02
C04 N03 N04 2.37e-06
R04 N03 N04 9.13e-01
C05 N04 N05 3.48e-06
R05 N04 N05 6.20e-02
C06 N05 N06 3.43e-06
R06 N05 N06 9.87e-03
L07 N06 N07 1.58e-10
R07 N06 N07 1.28e-01
L08 N07 N08 4.41e-12
R08 N07 N08 4.68e-02
C09 N08 N09 3.10e-07
L09 N08 N09 2.23e-11
R09 N08 N09 3.09e-02
C10 N09 N10 1.02e-07
L10 N09 N10 3.47e-11
R10 N09 N10 5.60e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 1.48e-10
R11 N10 Port2 3.05e+01
.ENDS GCE188R71E473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCE188R71H102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H102KA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.52e-11
R03 N02 N03 3.16e-01
C04 N03 N04 8.06e-09
R04 N03 N04 5.00e+02
C05 N04 N05 5.21e-08
R05 N04 N05 2.50e+00
C06 N05 N06 2.69e-08
R06 N05 N06 4.24e-01
C07 N06 N07 1.08e-08
R07 N06 N07 1.48e-01
C08 N07 N08 1.45e-11
L08 N07 N08 2.59e-10
R08 N07 N08 4.89e+00
C09 N08 Port2 1.08e-12
L09 N08 Port2 2.54e-10
R09 N08 Port2 3.92e+01
.ENDS GCE188R71H102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCE188R71H102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H102MA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.52e-11
R03 N02 N03 3.16e-01
C04 N03 N04 8.06e-09
R04 N03 N04 5.00e+02
C05 N04 N05 5.21e-08
R05 N04 N05 2.50e+00
C06 N05 N06 2.69e-08
R06 N05 N06 4.24e-01
C07 N06 N07 1.08e-08
R07 N06 N07 1.48e-01
C08 N07 N08 1.45e-11
L08 N07 N08 2.59e-10
R08 N07 N08 4.89e+00
C09 N08 Port2 1.08e-12
L09 N08 Port2 2.54e-10
R09 N08 Port2 3.92e+01
.ENDS GCE188R71H102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCE188R71H103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H103KA01 Port1 Port2
C01 Port1 N01 9.37e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.01e-02
C04 N03 N04 3.13e-07
R04 N03 N04 1.24e+01
C05 N04 N05 6.53e-07
R05 N04 N05 4.07e-01
C06 N05 N06 4.99e-07
R06 N05 N06 5.79e-02
L07 N06 N07 1.37e-10
R07 N06 N07 2.63e-01
C08 N07 N08 7.80e-08
L08 N07 N08 1.48e-11
R08 N07 N08 5.19e-02
C09 N08 N09 1.61e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.37e-02
C10 N09 N10 7.59e-12
L10 N09 N10 6.68e-11
R10 N09 N10 1.35e+01
C11 N10 Port2 2.19e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 3.81e+01
.ENDS GCE188R71H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCE188R71H103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H103MA01 Port1 Port2
C01 Port1 N01 9.37e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.01e-02
C04 N03 N04 3.13e-07
R04 N03 N04 1.24e+01
C05 N04 N05 6.53e-07
R05 N04 N05 4.07e-01
C06 N05 N06 4.99e-07
R06 N05 N06 5.79e-02
L07 N06 N07 1.37e-10
R07 N06 N07 2.63e-01
C08 N07 N08 7.80e-08
L08 N07 N08 1.48e-11
R08 N07 N08 5.19e-02
C09 N08 N09 1.61e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.37e-02
C10 N09 N10 7.59e-12
L10 N09 N10 6.68e-11
R10 N09 N10 1.35e+01
C11 N10 Port2 2.19e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 3.81e+01
.ENDS GCE188R71H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H122KA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H122KA01 Port1 Port2
C01 Port1 N01 1.31e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.96e-01
C04 N03 N04 1.46e-08
R04 N03 N04 2.21e+02
C05 N04 N05 1.13e-07
R05 N04 N05 8.51e+00
C06 N05 N06 5.31e-08
R06 N05 N06 1.18e+00
C07 N06 N07 1.96e-08
R07 N06 N07 2.70e-01
C08 N07 N08 4.67e-08
R08 N07 N08 7.83e-03
C09 N08 N09 1.08e-09
L09 N08 N09 1.51e-11
R09 N08 N09 1.44e-01
C10 N09 N10 1.26e-11
L10 N09 N10 2.54e-10
R10 N09 N10 5.37e+00
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.31e-10
R11 N10 Port2 1.40e+01
.ENDS GCE188R71H122KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GCE188R71H123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H123KA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 5.91e-02
C04 N03 N04 4.13e-07
R04 N03 N04 1.93e+01
C05 N04 N05 1.04e-06
R05 N04 N05 6.12e-01
C06 N05 N06 1.16e-06
R06 N05 N06 1.08e-01
C07 N06 N07 8.12e-07
R07 N06 N07 3.66e-02
L08 N07 N08 1.05e-10
R08 N07 N08 1.72e-01
C09 N08 N09 1.36e-07
L09 N08 N09 9.35e-12
R09 N08 N09 3.14e-02
C10 N09 N10 2.46e-08
L10 N09 N10 2.32e-11
R10 N09 N10 8.10e-02
C11 N10 N11 3.62e-12
L11 N10 N11 1.74e-10
R11 N10 N11 2.09e+01
C12 N11 Port2 5.35e-12
L12 N11 Port2 6.93e-11
R12 N11 Port2 2.32e+01
.ENDS GCE188R71H123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GCE188R71H123MA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H123MA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 5.91e-02
C04 N03 N04 4.13e-07
R04 N03 N04 1.93e+01
C05 N04 N05 1.04e-06
R05 N04 N05 6.12e-01
C06 N05 N06 1.16e-06
R06 N05 N06 1.08e-01
C07 N06 N07 8.12e-07
R07 N06 N07 3.66e-02
L08 N07 N08 1.05e-10
R08 N07 N08 1.72e-01
C09 N08 N09 1.36e-07
L09 N08 N09 9.35e-12
R09 N08 N09 3.14e-02
C10 N09 N10 2.46e-08
L10 N09 N10 2.32e-11
R10 N09 N10 8.10e-02
C11 N10 N11 3.62e-12
L11 N10 N11 1.74e-10
R11 N10 N11 2.09e+01
C12 N11 Port2 5.35e-12
L12 N11 Port2 6.93e-11
R12 N11 Port2 2.32e+01
.ENDS GCE188R71H123MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCE188R71H152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H152KA01 Port1 Port2
C01 Port1 N01 1.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 2.10e-01
C04 N03 N04 1.77e-08
R04 N03 N04 2.37e+02
C05 N04 N05 1.16e-07
R05 N04 N05 1.87e+00
C06 N05 N06 6.29e-08
R06 N05 N06 4.53e-01
C07 N06 N07 1.92e-08
R07 N06 N07 1.40e-01
L08 N07 N08 1.58e-11
R08 N07 N08 1.12e-01
C09 N08 N09 2.48e-09
L09 N08 N09 1.26e-11
R09 N08 N09 1.88e-01
C10 N09 N10 1.40e-11
L10 N09 N10 2.24e-10
R10 N09 N10 4.51e+00
C11 N10 Port2 1.77e-12
L11 N10 Port2 1.87e-10
R11 N10 Port2 2.43e+01
.ENDS GCE188R71H152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCE188R71H152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H152MA01 Port1 Port2
C01 Port1 N01 1.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 2.10e-01
C04 N03 N04 1.77e-08
R04 N03 N04 2.37e+02
C05 N04 N05 1.16e-07
R05 N04 N05 1.87e+00
C06 N05 N06 6.29e-08
R06 N05 N06 4.53e-01
C07 N06 N07 1.92e-08
R07 N06 N07 1.40e-01
L08 N07 N08 1.58e-11
R08 N07 N08 1.12e-01
C09 N08 N09 2.48e-09
L09 N08 N09 1.26e-11
R09 N08 N09 1.88e-01
C10 N09 N10 1.40e-11
L10 N09 N10 2.24e-10
R10 N09 N10 4.51e+00
C11 N10 Port2 1.77e-12
L11 N10 Port2 1.87e-10
R11 N10 Port2 2.43e+01
.ENDS GCE188R71H152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCE188R71H153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H153KA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 4.78e-02
C04 N03 N04 6.89e-07
R04 N03 N04 1.46e+01
C05 N04 N05 1.69e-06
R05 N04 N05 9.20e-01
C06 N05 N06 1.28e-06
R06 N05 N06 2.38e-01
C07 N06 N07 1.25e-06
R07 N06 N07 4.94e-02
L08 N07 N08 9.14e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.10e-07
L09 N08 N09 1.66e-11
R09 N08 N09 4.72e-02
C10 N09 N10 2.54e-08
L10 N09 N10 3.30e-11
R10 N09 N10 9.64e-02
C11 N10 N11 4.59e-08
L11 N10 N11 5.67e-12
R11 N10 N11 2.58e-02
C12 N11 N12 8.37e-12
L12 N11 N12 7.06e-11
R12 N11 N12 1.14e+01
C13 N12 Port2 3.50e-12
L13 N12 Port2 8.98e-11
R13 N12 Port2 1.77e+01
.ENDS GCE188R71H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCE188R71H153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H153MA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 4.78e-02
C04 N03 N04 6.89e-07
R04 N03 N04 1.46e+01
C05 N04 N05 1.69e-06
R05 N04 N05 9.20e-01
C06 N05 N06 1.28e-06
R06 N05 N06 2.38e-01
C07 N06 N07 1.25e-06
R07 N06 N07 4.94e-02
L08 N07 N08 9.14e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.10e-07
L09 N08 N09 1.66e-11
R09 N08 N09 4.72e-02
C10 N09 N10 2.54e-08
L10 N09 N10 3.30e-11
R10 N09 N10 9.64e-02
C11 N10 N11 4.59e-08
L11 N10 N11 5.67e-12
R11 N10 N11 2.58e-02
C12 N11 N12 8.37e-12
L12 N11 N12 7.06e-11
R12 N11 N12 1.14e+01
C13 N12 Port2 3.50e-12
L13 N12 Port2 8.98e-11
R13 N12 Port2 1.77e+01
.ENDS GCE188R71H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GCE188R71H182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H182KA01 Port1 Port2
C01 Port1 N01 1.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 2.18e-01
C04 N03 N04 2.92e-08
R04 N03 N04 8.63e+01
C05 N04 N05 1.92e-07
R05 N04 N05 1.16e+00
C06 N05 N06 5.72e-08
R06 N05 N06 5.18e-01
C07 N06 N07 3.36e-08
R07 N06 N07 1.05e-01
C08 N07 N08 1.42e-07
R08 N07 N08 3.31e-03
C09 N08 N09 1.19e-09
L09 N08 N09 3.36e-11
R09 N08 N09 2.48e-01
C10 N09 N10 1.07e-11
L10 N09 N10 2.04e-10
R10 N09 N10 3.43e+00
C11 N10 Port2 3.48e-12
L11 N10 Port2 1.14e-10
R11 N10 Port2 1.45e+01
.ENDS GCE188R71H182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCE188R71H183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H183KA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 4.00e-02
C04 N03 N04 8.78e-07
R04 N03 N04 8.40e+00
C05 N04 N05 1.80e-06
R05 N04 N05 4.92e-01
C06 N05 N06 1.69e-06
R06 N05 N06 1.17e-01
C07 N06 N07 1.59e-06
R07 N06 N07 3.29e-02
L08 N07 N08 1.09e-10
R08 N07 N08 1.86e-01
C09 N08 N09 1.14e-07
L09 N08 N09 2.03e-11
R09 N08 N09 5.52e-02
C10 N09 N10 2.80e-08
L10 N09 N10 3.89e-11
R10 N09 N10 9.99e-02
C11 N10 Port2 4.40e-12
L11 N10 Port2 8.64e-11
R11 N10 Port2 1.08e+01
.ENDS GCE188R71H183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCE188R71H183MA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H183MA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 4.00e-02
C04 N03 N04 8.78e-07
R04 N03 N04 8.40e+00
C05 N04 N05 1.80e-06
R05 N04 N05 4.92e-01
C06 N05 N06 1.69e-06
R06 N05 N06 1.17e-01
C07 N06 N07 1.59e-06
R07 N06 N07 3.29e-02
L08 N07 N08 1.09e-10
R08 N07 N08 1.86e-01
C09 N08 N09 1.14e-07
L09 N08 N09 2.03e-11
R09 N08 N09 5.52e-02
C10 N09 N10 2.80e-08
L10 N09 N10 3.89e-11
R10 N09 N10 9.99e-02
C11 N10 Port2 4.40e-12
L11 N10 Port2 8.64e-11
R11 N10 Port2 1.08e+01
.ENDS GCE188R71H183MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H222KA01 Port1 Port2
C01 Port1 N01 2.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.63e-01
C04 N03 N04 3.13e-08
R04 N03 N04 1.31e+02
C05 N04 N05 1.44e-07
R05 N04 N05 1.40e+00
C06 N05 N06 8.37e-08
R06 N05 N06 2.98e-01
C07 N06 N07 3.82e-08
R07 N06 N07 7.92e-02
L08 N07 N08 3.97e-11
R08 N07 N08 3.09e-01
C09 N08 N09 2.65e-08
L09 N08 N09 5.99e-12
R09 N08 N09 5.39e-02
C10 N09 N10 2.08e-09
L10 N09 N10 2.80e-11
R10 N09 N10 2.00e-01
C11 N10 N11 1.97e-11
L11 N10 N11 1.30e-10
R11 N10 N11 2.59e+00
C12 N11 Port2 2.81e-12
L12 N11 Port2 1.11e-10
R12 N11 Port2 2.41e+01
.ENDS GCE188R71H222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCE188R71H223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H223KA01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.43e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.93e+00
C05 N04 N05 1.33e-06
R05 N04 N05 2.44e-01
C06 N05 N06 1.29e-06
R06 N05 N06 2.87e-02
L07 N06 N07 1.40e-10
R07 N06 N07 2.09e-01
C08 N07 N08 9.74e-08
L08 N07 N08 2.62e-11
R08 N07 N08 5.64e-02
C09 N08 N09 2.72e-08
L09 N08 N09 4.42e-11
R09 N08 N09 9.63e-02
C10 N09 N10 5.72e-11
L10 N09 N10 9.79e-12
R10 N09 N10 4.03e+00
C11 N10 Port2 2.34e-12
L11 N10 Port2 1.33e-10
R11 N10 Port2 2.48e+01
.ENDS GCE188R71H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCE188R71H223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H223MA01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.43e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.93e+00
C05 N04 N05 1.33e-06
R05 N04 N05 2.44e-01
C06 N05 N06 1.29e-06
R06 N05 N06 2.87e-02
L07 N06 N07 1.40e-10
R07 N06 N07 2.09e-01
C08 N07 N08 9.74e-08
L08 N07 N08 2.62e-11
R08 N07 N08 5.64e-02
C09 N08 N09 2.72e-08
L09 N08 N09 4.42e-11
R09 N08 N09 9.63e-02
C10 N09 N10 5.72e-11
L10 N09 N10 9.79e-12
R10 N09 N10 4.03e+00
C11 N10 Port2 2.34e-12
L11 N10 Port2 1.33e-10
R11 N10 Port2 2.48e+01
.ENDS GCE188R71H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCE188R71H272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H272KA01 Port1 Port2
C01 Port1 N01 2.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.41e-01
C04 N03 N04 5.37e-08
R04 N03 N04 5.65e+01
C05 N04 N05 2.12e-07
R05 N04 N05 9.15e-01
C06 N05 N06 1.24e-07
R06 N05 N06 2.55e-01
C07 N06 N07 6.08e-08
R07 N06 N07 6.89e-02
L08 N07 N08 7.57e-11
R08 N07 N08 3.97e-01
C09 N08 N09 1.42e-08
L09 N08 N09 1.57e-11
R09 N08 N09 6.33e-02
C10 N09 N10 5.64e-09
L10 N09 N10 1.69e-11
R10 N09 N10 9.78e-02
C11 N10 N11 2.70e-11
L11 N10 N11 8.25e-11
R11 N10 N11 1.85e+00
C12 N11 Port2 3.51e-12
L12 N11 Port2 9.41e-11
R12 N11 Port2 1.23e+01
.ENDS GCE188R71H272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCE188R71H332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H332KA01 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 2.29e-01
C04 N03 N04 6.10e-08
R04 N03 N04 7.93e+01
C05 N04 N05 1.96e-07
R05 N04 N05 1.17e+00
C06 N05 N06 8.66e-08
R06 N05 N06 1.85e-01
L07 N06 N07 1.41e-10
R07 N06 N07 2.77e+00
C08 N07 N08 3.13e-08
L08 N07 N08 8.77e-12
R08 N07 N08 4.92e-02
C09 N08 N09 3.35e-09
L09 N08 N09 2.97e-11
R09 N08 N09 1.56e-01
C10 N09 N10 2.91e-11
L10 N09 N10 9.92e-11
R10 N09 N10 1.96e+00
C11 N10 Port2 4.00e-12
L11 N10 Port2 8.72e-11
R11 N10 Port2 2.75e+01
.ENDS GCE188R71H332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCE188R71H332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H332MA01 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 2.29e-01
C04 N03 N04 6.10e-08
R04 N03 N04 7.93e+01
C05 N04 N05 1.96e-07
R05 N04 N05 1.17e+00
C06 N05 N06 8.66e-08
R06 N05 N06 1.85e-01
L07 N06 N07 1.41e-10
R07 N06 N07 2.77e+00
C08 N07 N08 3.13e-08
L08 N07 N08 8.77e-12
R08 N07 N08 4.92e-02
C09 N08 N09 3.35e-09
L09 N08 N09 2.97e-11
R09 N08 N09 1.56e-01
C10 N09 N10 2.91e-11
L10 N09 N10 9.92e-11
R10 N09 N10 1.96e+00
C11 N10 Port2 4.00e-12
L11 N10 Port2 8.72e-11
R11 N10 Port2 2.75e+01
.ENDS GCE188R71H332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GCE188R71H392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H392KA01 Port1 Port2
C01 Port1 N01 3.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 1.53e-01
C04 N03 N04 1.11e-07
R04 N03 N04 2.02e+01
C05 N04 N05 2.09e-07
R05 N04 N05 5.75e-01
C06 N05 N06 1.39e-07
R06 N05 N06 8.71e-02
C07 N06 N07 9.76e-08
R07 N06 N07 1.38e-02
L08 N07 N08 9.88e-11
R08 N07 N08 8.43e-01
C09 N08 N09 6.52e-08
L09 N08 N09 5.34e-12
R09 N08 N09 2.87e-02
C10 N09 N10 3.31e-09
L10 N09 N10 4.12e-11
R10 N09 N10 1.79e-01
C11 N10 N11 3.62e-11
L11 N10 N11 6.65e-11
R11 N10 N11 1.66e+00
C12 N11 Port2 2.87e-12
L12 N11 Port2 1.06e-10
R12 N11 Port2 1.34e+01
.ENDS GCE188R71H392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCE188R71H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H472KA01 Port1 Port2
C01 Port1 N01 4.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.08e-01
C04 N03 N04 1.05e-07
R04 N03 N04 4.27e+01
C05 N04 N05 3.20e-07
R05 N04 N05 6.98e-01
C06 N05 N06 3.37e-07
R06 N05 N06 9.21e-02
C07 N06 N07 1.90e-07
R07 N06 N07 5.56e-02
L08 N07 N08 9.54e-11
R08 N07 N08 4.35e-01
C09 N08 N09 4.03e-08
L09 N08 N09 1.15e-11
R09 N08 N09 5.49e-02
C10 N09 N10 8.47e-09
L10 N09 N10 2.42e-11
R10 N09 N10 1.18e-01
C11 N10 N11 5.06e-11
L11 N10 N11 5.12e-11
R11 N10 N11 1.21e+00
C12 N11 Port2 3.35e-12
L12 N11 Port2 1.04e-10
R12 N11 Port2 3.21e+01
.ENDS GCE188R71H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCE188R71H472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H472MA01 Port1 Port2
C01 Port1 N01 4.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.08e-01
C04 N03 N04 1.05e-07
R04 N03 N04 4.27e+01
C05 N04 N05 3.20e-07
R05 N04 N05 6.98e-01
C06 N05 N06 3.37e-07
R06 N05 N06 9.21e-02
C07 N06 N07 1.90e-07
R07 N06 N07 5.56e-02
L08 N07 N08 9.54e-11
R08 N07 N08 4.35e-01
C09 N08 N09 4.03e-08
L09 N08 N09 1.15e-11
R09 N08 N09 5.49e-02
C10 N09 N10 8.47e-09
L10 N09 N10 2.42e-11
R10 N09 N10 1.18e-01
C11 N10 N11 5.06e-11
L11 N10 N11 5.12e-11
R11 N10 N11 1.21e+00
C12 N11 Port2 3.35e-12
L12 N11 Port2 1.04e-10
R12 N11 Port2 3.21e+01
.ENDS GCE188R71H472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCE188R71H562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H562KA01 Port1 Port2
C01 Port1 N01 5.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 6.91e-02
C04 N03 N04 2.11e-07
R04 N03 N04 7.91e+00
C05 N04 N05 4.21e-07
R05 N04 N05 3.17e-01
C06 N05 N06 4.95e-07
R06 N05 N06 6.38e-02
C07 N06 N07 7.84e-07
R07 N06 N07 3.69e-03
L08 N07 N08 7.22e-11
R08 N07 N08 2.15e-01
C09 N08 N09 3.91e-08
L09 N08 N09 1.47e-11
R09 N08 N09 4.70e-02
C10 N09 N10 8.75e-09
L10 N09 N10 2.53e-11
R10 N09 N10 1.25e-01
C11 N10 N11 5.20e-12
L11 N10 N11 1.46e-10
R11 N10 N11 2.05e+01
C12 N11 Port2 1.86e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 2.86e+01
.ENDS GCE188R71H562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCE188R71H562MA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H562MA01 Port1 Port2
C01 Port1 N01 5.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 6.91e-02
C04 N03 N04 2.11e-07
R04 N03 N04 7.91e+00
C05 N04 N05 4.21e-07
R05 N04 N05 3.17e-01
C06 N05 N06 4.95e-07
R06 N05 N06 6.38e-02
C07 N06 N07 7.84e-07
R07 N06 N07 3.69e-03
L08 N07 N08 7.22e-11
R08 N07 N08 2.15e-01
C09 N08 N09 3.91e-08
L09 N08 N09 1.47e-11
R09 N08 N09 4.70e-02
C10 N09 N10 8.75e-09
L10 N09 N10 2.53e-11
R10 N09 N10 1.25e-01
C11 N10 N11 5.20e-12
L11 N10 N11 1.46e-10
R11 N10 N11 2.05e+01
C12 N11 Port2 1.86e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 2.86e+01
.ENDS GCE188R71H562MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCE188R71H682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H682KA01 Port1 Port2
C01 Port1 N01 6.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 6.90e-02
C04 N03 N04 3.09e-07
R04 N03 N04 8.17e+00
C05 N04 N05 6.97e-07
R05 N04 N05 6.73e-01
C06 N05 N06 6.54e-07
R06 N05 N06 1.35e-01
C07 N06 N07 4.93e-07
R07 N06 N07 4.85e-02
L08 N07 N08 7.15e-11
R08 N07 N08 2.40e-01
C09 N08 N09 5.75e-08
L09 N08 N09 1.18e-11
R09 N08 N09 5.00e-02
C10 N09 N10 1.09e-08
L10 N09 N10 2.56e-11
R10 N09 N10 1.22e-01
C11 N10 N11 6.66e-12
L11 N10 N11 1.05e-10
R11 N10 N11 1.41e+01
C12 N11 Port2 4.91e-12
L12 N11 Port2 6.54e-11
R12 N11 Port2 1.34e+01
.ENDS GCE188R71H682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCE188R71H682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H682MA01 Port1 Port2
C01 Port1 N01 6.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 6.90e-02
C04 N03 N04 3.09e-07
R04 N03 N04 8.17e+00
C05 N04 N05 6.97e-07
R05 N04 N05 6.73e-01
C06 N05 N06 6.54e-07
R06 N05 N06 1.35e-01
C07 N06 N07 4.93e-07
R07 N06 N07 4.85e-02
L08 N07 N08 7.15e-11
R08 N07 N08 2.40e-01
C09 N08 N09 5.75e-08
L09 N08 N09 1.18e-11
R09 N08 N09 5.00e-02
C10 N09 N10 1.09e-08
L10 N09 N10 2.56e-11
R10 N09 N10 1.22e-01
C11 N10 N11 6.66e-12
L11 N10 N11 1.05e-10
R11 N10 N11 1.41e+01
C12 N11 Port2 4.91e-12
L12 N11 Port2 6.54e-11
R12 N11 Port2 1.34e+01
.ENDS GCE188R71H682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H822KA01 Port1 Port2
C01 Port1 N01 8.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 5.63e-02
C04 N03 N04 5.02e-07
R04 N03 N04 6.18e+00
C05 N04 N05 1.04e-06
R05 N04 N05 7.14e-01
C06 N05 N06 7.99e-07
R06 N05 N06 1.96e-01
C07 N06 N07 6.06e-07
R07 N06 N07 5.68e-02
L08 N07 N08 6.89e-11
R08 N07 N08 1.97e-01
C09 N08 N09 6.20e-08
L09 N08 N09 1.56e-11
R09 N08 N09 5.66e-02
C10 N09 N10 1.43e-08
L10 N09 N10 2.92e-11
R10 N09 N10 1.20e-01
C11 N10 N11 9.46e-09
L11 N10 N11 1.29e-11
R11 N10 N11 5.20e-02
C12 N11 N12 5.65e-12
L12 N11 N12 9.90e-11
R12 N11 N12 1.25e+01
C13 N12 Port2 4.58e-12
L13 N12 Port2 7.02e-11
R13 N12 Port2 1.66e+01
.ENDS GCE188R71H822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H822MA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H822MA01 Port1 Port2
C01 Port1 N01 8.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 5.63e-02
C04 N03 N04 5.02e-07
R04 N03 N04 6.18e+00
C05 N04 N05 1.04e-06
R05 N04 N05 7.14e-01
C06 N05 N06 7.99e-07
R06 N05 N06 1.96e-01
C07 N06 N07 6.06e-07
R07 N06 N07 5.68e-02
L08 N07 N08 6.89e-11
R08 N07 N08 1.97e-01
C09 N08 N09 6.20e-08
L09 N08 N09 1.56e-11
R09 N08 N09 5.66e-02
C10 N09 N10 1.43e-08
L10 N09 N10 2.92e-11
R10 N09 N10 1.20e-01
C11 N10 N11 9.46e-09
L11 N10 N11 1.29e-11
R11 N10 N11 5.20e-02
C12 N11 N12 5.65e-12
L12 N11 N12 9.90e-11
R12 N11 N12 1.25e+01
C13 N12 Port2 4.58e-12
L13 N12 Port2 7.02e-11
R13 N12 Port2 1.66e+01
.ENDS GCE188R71H822MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCE188R72A102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A102KA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.52e-11
R03 N02 N03 3.16e-01
C04 N03 N04 8.06e-09
R04 N03 N04 5.00e+02
C05 N04 N05 5.21e-08
R05 N04 N05 2.50e+00
C06 N05 N06 2.69e-08
R06 N05 N06 4.24e-01
C07 N06 N07 1.08e-08
R07 N06 N07 1.48e-01
C08 N07 N08 1.45e-11
L08 N07 N08 2.59e-10
R08 N07 N08 4.89e+00
C09 N08 Port2 1.08e-12
L09 N08 Port2 2.54e-10
R09 N08 Port2 3.92e+01
.ENDS GCE188R72A102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCE188R72A102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A102MA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.52e-11
R03 N02 N03 3.16e-01
C04 N03 N04 8.06e-09
R04 N03 N04 5.00e+02
C05 N04 N05 5.21e-08
R05 N04 N05 2.50e+00
C06 N05 N06 2.69e-08
R06 N05 N06 4.24e-01
C07 N06 N07 1.08e-08
R07 N06 N07 1.48e-01
C08 N07 N08 1.45e-11
L08 N07 N08 2.59e-10
R08 N07 N08 4.89e+00
C09 N08 Port2 1.08e-12
L09 N08 Port2 2.54e-10
R09 N08 Port2 3.92e+01
.ENDS GCE188R72A102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE188R72A103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A103KA01 Port1 Port2
C01 Port1 N01 9.37e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.01e-02
C04 N03 N04 3.13e-07
R04 N03 N04 1.24e+01
C05 N04 N05 6.53e-07
R05 N04 N05 4.07e-01
C06 N05 N06 4.99e-07
R06 N05 N06 5.79e-02
L07 N06 N07 1.37e-10
R07 N06 N07 2.63e-01
C08 N07 N08 7.80e-08
L08 N07 N08 1.48e-11
R08 N07 N08 5.19e-02
C09 N08 N09 1.61e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.37e-02
C10 N09 N10 7.59e-12
L10 N09 N10 6.68e-11
R10 N09 N10 1.35e+01
C11 N10 Port2 2.19e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 3.81e+01
.ENDS GCE188R72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE188R72A103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A103MA01 Port1 Port2
C01 Port1 N01 9.37e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.01e-02
C04 N03 N04 3.13e-07
R04 N03 N04 1.24e+01
C05 N04 N05 6.53e-07
R05 N04 N05 4.07e-01
C06 N05 N06 4.99e-07
R06 N05 N06 5.79e-02
L07 N06 N07 1.37e-10
R07 N06 N07 2.63e-01
C08 N07 N08 7.80e-08
L08 N07 N08 1.48e-11
R08 N07 N08 5.19e-02
C09 N08 N09 1.61e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.37e-02
C10 N09 N10 7.59e-12
L10 N09 N10 6.68e-11
R10 N09 N10 1.35e+01
C11 N10 Port2 2.19e-12
L11 N10 Port2 1.46e-10
R11 N10 Port2 3.81e+01
.ENDS GCE188R72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A122KA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A122KA01 Port1 Port2
C01 Port1 N01 1.31e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.96e-01
C04 N03 N04 1.46e-08
R04 N03 N04 2.21e+02
C05 N04 N05 1.13e-07
R05 N04 N05 8.51e+00
C06 N05 N06 5.31e-08
R06 N05 N06 1.18e+00
C07 N06 N07 1.96e-08
R07 N06 N07 2.70e-01
C08 N07 N08 4.67e-08
R08 N07 N08 7.83e-03
C09 N08 N09 1.08e-09
L09 N08 N09 1.51e-11
R09 N08 N09 1.44e-01
C10 N09 N10 1.26e-11
L10 N09 N10 2.54e-10
R10 N09 N10 5.37e+00
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.31e-10
R11 N10 Port2 1.40e+01
.ENDS GCE188R72A122KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A122MA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A122MA01 Port1 Port2
C01 Port1 N01 1.31e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.96e-01
C04 N03 N04 1.46e-08
R04 N03 N04 2.21e+02
C05 N04 N05 1.13e-07
R05 N04 N05 8.51e+00
C06 N05 N06 5.31e-08
R06 N05 N06 1.18e+00
C07 N06 N07 1.96e-08
R07 N06 N07 2.70e-01
C08 N07 N08 4.67e-08
R08 N07 N08 7.83e-03
C09 N08 N09 1.08e-09
L09 N08 N09 1.51e-11
R09 N08 N09 1.44e-01
C10 N09 N10 1.26e-11
L10 N09 N10 2.54e-10
R10 N09 N10 5.37e+00
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.31e-10
R11 N10 Port2 1.40e+01
.ENDS GCE188R72A122MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCE188R72A123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A123KA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 5.91e-02
C04 N03 N04 4.13e-07
R04 N03 N04 1.93e+01
C05 N04 N05 1.04e-06
R05 N04 N05 6.12e-01
C06 N05 N06 1.16e-06
R06 N05 N06 1.08e-01
C07 N06 N07 8.12e-07
R07 N06 N07 3.66e-02
L08 N07 N08 1.05e-10
R08 N07 N08 1.72e-01
C09 N08 N09 1.36e-07
L09 N08 N09 9.35e-12
R09 N08 N09 3.14e-02
C10 N09 N10 2.46e-08
L10 N09 N10 2.32e-11
R10 N09 N10 8.10e-02
C11 N10 N11 3.62e-12
L11 N10 N11 1.74e-10
R11 N10 N11 2.09e+01
C12 N11 Port2 5.35e-12
L12 N11 Port2 6.93e-11
R12 N11 Port2 2.32e+01
.ENDS GCE188R72A123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCE188R72A123MA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A123MA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 5.91e-02
C04 N03 N04 4.13e-07
R04 N03 N04 1.93e+01
C05 N04 N05 1.04e-06
R05 N04 N05 6.12e-01
C06 N05 N06 1.16e-06
R06 N05 N06 1.08e-01
C07 N06 N07 8.12e-07
R07 N06 N07 3.66e-02
L08 N07 N08 1.05e-10
R08 N07 N08 1.72e-01
C09 N08 N09 1.36e-07
L09 N08 N09 9.35e-12
R09 N08 N09 3.14e-02
C10 N09 N10 2.46e-08
L10 N09 N10 2.32e-11
R10 N09 N10 8.10e-02
C11 N10 N11 3.62e-12
L11 N10 N11 1.74e-10
R11 N10 N11 2.09e+01
C12 N11 Port2 5.35e-12
L12 N11 Port2 6.93e-11
R12 N11 Port2 2.32e+01
.ENDS GCE188R72A123MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE188R72A152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A152KA01 Port1 Port2
C01 Port1 N01 1.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 2.10e-01
C04 N03 N04 1.77e-08
R04 N03 N04 2.37e+02
C05 N04 N05 1.16e-07
R05 N04 N05 1.87e+00
C06 N05 N06 6.29e-08
R06 N05 N06 4.53e-01
C07 N06 N07 1.92e-08
R07 N06 N07 1.40e-01
L08 N07 N08 1.58e-11
R08 N07 N08 1.12e-01
C09 N08 N09 2.48e-09
L09 N08 N09 1.26e-11
R09 N08 N09 1.88e-01
C10 N09 N10 1.40e-11
L10 N09 N10 2.24e-10
R10 N09 N10 4.51e+00
C11 N10 Port2 1.77e-12
L11 N10 Port2 1.87e-10
R11 N10 Port2 2.43e+01
.ENDS GCE188R72A152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE188R72A152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A152MA01 Port1 Port2
C01 Port1 N01 1.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 2.10e-01
C04 N03 N04 1.77e-08
R04 N03 N04 2.37e+02
C05 N04 N05 1.16e-07
R05 N04 N05 1.87e+00
C06 N05 N06 6.29e-08
R06 N05 N06 4.53e-01
C07 N06 N07 1.92e-08
R07 N06 N07 1.40e-01
L08 N07 N08 1.58e-11
R08 N07 N08 1.12e-01
C09 N08 N09 2.48e-09
L09 N08 N09 1.26e-11
R09 N08 N09 1.88e-01
C10 N09 N10 1.40e-11
L10 N09 N10 2.24e-10
R10 N09 N10 4.51e+00
C11 N10 Port2 1.77e-12
L11 N10 Port2 1.87e-10
R11 N10 Port2 2.43e+01
.ENDS GCE188R72A152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCE188R72A153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A153KA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 4.78e-02
C04 N03 N04 6.89e-07
R04 N03 N04 1.46e+01
C05 N04 N05 1.69e-06
R05 N04 N05 9.20e-01
C06 N05 N06 1.28e-06
R06 N05 N06 2.38e-01
C07 N06 N07 1.25e-06
R07 N06 N07 4.94e-02
L08 N07 N08 9.14e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.10e-07
L09 N08 N09 1.66e-11
R09 N08 N09 4.72e-02
C10 N09 N10 2.54e-08
L10 N09 N10 3.30e-11
R10 N09 N10 9.64e-02
C11 N10 N11 4.59e-08
L11 N10 N11 5.67e-12
R11 N10 N11 2.58e-02
C12 N11 N12 8.37e-12
L12 N11 N12 7.06e-11
R12 N11 N12 1.14e+01
C13 N12 Port2 3.50e-12
L13 N12 Port2 8.98e-11
R13 N12 Port2 1.77e+01
.ENDS GCE188R72A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCE188R72A153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A153MA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 4.78e-02
C04 N03 N04 6.89e-07
R04 N03 N04 1.46e+01
C05 N04 N05 1.69e-06
R05 N04 N05 9.20e-01
C06 N05 N06 1.28e-06
R06 N05 N06 2.38e-01
C07 N06 N07 1.25e-06
R07 N06 N07 4.94e-02
L08 N07 N08 9.14e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.10e-07
L09 N08 N09 1.66e-11
R09 N08 N09 4.72e-02
C10 N09 N10 2.54e-08
L10 N09 N10 3.30e-11
R10 N09 N10 9.64e-02
C11 N10 N11 4.59e-08
L11 N10 N11 5.67e-12
R11 N10 N11 2.58e-02
C12 N11 N12 8.37e-12
L12 N11 N12 7.06e-11
R12 N11 N12 1.14e+01
C13 N12 Port2 3.50e-12
L13 N12 Port2 8.98e-11
R13 N12 Port2 1.77e+01
.ENDS GCE188R72A153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCE188R72A182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A182KA01 Port1 Port2
C01 Port1 N01 1.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 2.18e-01
C04 N03 N04 2.92e-08
R04 N03 N04 8.63e+01
C05 N04 N05 1.92e-07
R05 N04 N05 1.16e+00
C06 N05 N06 5.72e-08
R06 N05 N06 5.18e-01
C07 N06 N07 3.36e-08
R07 N06 N07 1.05e-01
C08 N07 N08 1.42e-07
R08 N07 N08 3.31e-03
C09 N08 N09 1.19e-09
L09 N08 N09 3.36e-11
R09 N08 N09 2.48e-01
C10 N09 N10 1.07e-11
L10 N09 N10 2.04e-10
R10 N09 N10 3.43e+00
C11 N10 Port2 3.48e-12
L11 N10 Port2 1.14e-10
R11 N10 Port2 1.45e+01
.ENDS GCE188R72A182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCE188R72A182MA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A182MA01 Port1 Port2
C01 Port1 N01 1.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 2.18e-01
C04 N03 N04 2.92e-08
R04 N03 N04 8.63e+01
C05 N04 N05 1.92e-07
R05 N04 N05 1.16e+00
C06 N05 N06 5.72e-08
R06 N05 N06 5.18e-01
C07 N06 N07 3.36e-08
R07 N06 N07 1.05e-01
C08 N07 N08 1.42e-07
R08 N07 N08 3.31e-03
C09 N08 N09 1.19e-09
L09 N08 N09 3.36e-11
R09 N08 N09 2.48e-01
C10 N09 N10 1.07e-11
L10 N09 N10 2.04e-10
R10 N09 N10 3.43e+00
C11 N10 Port2 3.48e-12
L11 N10 Port2 1.14e-10
R11 N10 Port2 1.45e+01
.ENDS GCE188R72A182MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCE188R72A183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A183KA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 4.00e-02
C04 N03 N04 8.78e-07
R04 N03 N04 8.40e+00
C05 N04 N05 1.80e-06
R05 N04 N05 4.92e-01
C06 N05 N06 1.69e-06
R06 N05 N06 1.17e-01
C07 N06 N07 1.59e-06
R07 N06 N07 3.29e-02
L08 N07 N08 1.09e-10
R08 N07 N08 1.86e-01
C09 N08 N09 1.14e-07
L09 N08 N09 2.03e-11
R09 N08 N09 5.52e-02
C10 N09 N10 2.80e-08
L10 N09 N10 3.89e-11
R10 N09 N10 9.99e-02
C11 N10 Port2 4.40e-12
L11 N10 Port2 8.64e-11
R11 N10 Port2 1.08e+01
.ENDS GCE188R72A183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCE188R72A183MA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A183MA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 4.00e-02
C04 N03 N04 8.78e-07
R04 N03 N04 8.40e+00
C05 N04 N05 1.80e-06
R05 N04 N05 4.92e-01
C06 N05 N06 1.69e-06
R06 N05 N06 1.17e-01
C07 N06 N07 1.59e-06
R07 N06 N07 3.29e-02
L08 N07 N08 1.09e-10
R08 N07 N08 1.86e-01
C09 N08 N09 1.14e-07
L09 N08 N09 2.03e-11
R09 N08 N09 5.52e-02
C10 N09 N10 2.80e-08
L10 N09 N10 3.89e-11
R10 N09 N10 9.99e-02
C11 N10 Port2 4.40e-12
L11 N10 Port2 8.64e-11
R11 N10 Port2 1.08e+01
.ENDS GCE188R72A183MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A222KA01 Port1 Port2
C01 Port1 N01 2.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.63e-01
C04 N03 N04 3.13e-08
R04 N03 N04 1.31e+02
C05 N04 N05 1.44e-07
R05 N04 N05 1.40e+00
C06 N05 N06 8.37e-08
R06 N05 N06 2.98e-01
C07 N06 N07 3.82e-08
R07 N06 N07 7.92e-02
L08 N07 N08 3.97e-11
R08 N07 N08 3.09e-01
C09 N08 N09 2.65e-08
L09 N08 N09 5.99e-12
R09 N08 N09 5.39e-02
C10 N09 N10 2.08e-09
L10 N09 N10 2.80e-11
R10 N09 N10 2.00e-01
C11 N10 N11 1.97e-11
L11 N10 N11 1.30e-10
R11 N10 N11 2.59e+00
C12 N11 Port2 2.81e-12
L12 N11 Port2 1.11e-10
R12 N11 Port2 2.41e+01
.ENDS GCE188R72A222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A222MA01 Port1 Port2
C01 Port1 N01 2.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.63e-01
C04 N03 N04 3.13e-08
R04 N03 N04 1.31e+02
C05 N04 N05 1.44e-07
R05 N04 N05 1.40e+00
C06 N05 N06 8.37e-08
R06 N05 N06 2.98e-01
C07 N06 N07 3.82e-08
R07 N06 N07 7.92e-02
L08 N07 N08 3.97e-11
R08 N07 N08 3.09e-01
C09 N08 N09 2.65e-08
L09 N08 N09 5.99e-12
R09 N08 N09 5.39e-02
C10 N09 N10 2.08e-09
L10 N09 N10 2.80e-11
R10 N09 N10 2.00e-01
C11 N10 N11 1.97e-11
L11 N10 N11 1.30e-10
R11 N10 N11 2.59e+00
C12 N11 Port2 2.81e-12
L12 N11 Port2 1.11e-10
R12 N11 Port2 2.41e+01
.ENDS GCE188R72A222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCE188R72A223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A223KA01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.43e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.93e+00
C05 N04 N05 1.33e-06
R05 N04 N05 2.44e-01
C06 N05 N06 1.29e-06
R06 N05 N06 2.87e-02
L07 N06 N07 1.40e-10
R07 N06 N07 2.09e-01
C08 N07 N08 9.74e-08
L08 N07 N08 2.62e-11
R08 N07 N08 5.64e-02
C09 N08 N09 2.72e-08
L09 N08 N09 4.42e-11
R09 N08 N09 9.63e-02
C10 N09 N10 5.72e-11
L10 N09 N10 9.79e-12
R10 N09 N10 4.03e+00
C11 N10 Port2 2.34e-12
L11 N10 Port2 1.33e-10
R11 N10 Port2 2.48e+01
.ENDS GCE188R72A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCE188R72A223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A223MA01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.43e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.93e+00
C05 N04 N05 1.33e-06
R05 N04 N05 2.44e-01
C06 N05 N06 1.29e-06
R06 N05 N06 2.87e-02
L07 N06 N07 1.40e-10
R07 N06 N07 2.09e-01
C08 N07 N08 9.74e-08
L08 N07 N08 2.62e-11
R08 N07 N08 5.64e-02
C09 N08 N09 2.72e-08
L09 N08 N09 4.42e-11
R09 N08 N09 9.63e-02
C10 N09 N10 5.72e-11
L10 N09 N10 9.79e-12
R10 N09 N10 4.03e+00
C11 N10 Port2 2.34e-12
L11 N10 Port2 1.33e-10
R11 N10 Port2 2.48e+01
.ENDS GCE188R72A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCE188R72A272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A272KA01 Port1 Port2
C01 Port1 N01 2.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.41e-01
C04 N03 N04 5.37e-08
R04 N03 N04 5.65e+01
C05 N04 N05 2.12e-07
R05 N04 N05 9.15e-01
C06 N05 N06 1.24e-07
R06 N05 N06 2.55e-01
C07 N06 N07 6.08e-08
R07 N06 N07 6.89e-02
L08 N07 N08 7.57e-11
R08 N07 N08 3.97e-01
C09 N08 N09 1.42e-08
L09 N08 N09 1.57e-11
R09 N08 N09 6.33e-02
C10 N09 N10 5.64e-09
L10 N09 N10 1.69e-11
R10 N09 N10 9.78e-02
C11 N10 N11 2.70e-11
L11 N10 N11 8.25e-11
R11 N10 N11 1.85e+00
C12 N11 Port2 3.51e-12
L12 N11 Port2 9.41e-11
R12 N11 Port2 1.23e+01
.ENDS GCE188R72A272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCE188R72A272MA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A272MA01 Port1 Port2
C01 Port1 N01 2.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.41e-01
C04 N03 N04 5.37e-08
R04 N03 N04 5.65e+01
C05 N04 N05 2.12e-07
R05 N04 N05 9.15e-01
C06 N05 N06 1.24e-07
R06 N05 N06 2.55e-01
C07 N06 N07 6.08e-08
R07 N06 N07 6.89e-02
L08 N07 N08 7.57e-11
R08 N07 N08 3.97e-01
C09 N08 N09 1.42e-08
L09 N08 N09 1.57e-11
R09 N08 N09 6.33e-02
C10 N09 N10 5.64e-09
L10 N09 N10 1.69e-11
R10 N09 N10 9.78e-02
C11 N10 N11 2.70e-11
L11 N10 N11 8.25e-11
R11 N10 N11 1.85e+00
C12 N11 Port2 3.51e-12
L12 N11 Port2 9.41e-11
R12 N11 Port2 1.23e+01
.ENDS GCE188R72A272MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCE188R72A332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A332KA01 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 2.29e-01
C04 N03 N04 6.10e-08
R04 N03 N04 7.93e+01
C05 N04 N05 1.96e-07
R05 N04 N05 1.17e+00
C06 N05 N06 8.66e-08
R06 N05 N06 1.85e-01
L07 N06 N07 1.41e-10
R07 N06 N07 2.77e+00
C08 N07 N08 3.13e-08
L08 N07 N08 8.77e-12
R08 N07 N08 4.92e-02
C09 N08 N09 3.35e-09
L09 N08 N09 2.97e-11
R09 N08 N09 1.56e-01
C10 N09 N10 2.91e-11
L10 N09 N10 9.92e-11
R10 N09 N10 1.96e+00
C11 N10 Port2 4.00e-12
L11 N10 Port2 8.72e-11
R11 N10 Port2 2.75e+01
.ENDS GCE188R72A332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCE188R72A332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A332MA01 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 2.29e-01
C04 N03 N04 6.10e-08
R04 N03 N04 7.93e+01
C05 N04 N05 1.96e-07
R05 N04 N05 1.17e+00
C06 N05 N06 8.66e-08
R06 N05 N06 1.85e-01
L07 N06 N07 1.41e-10
R07 N06 N07 2.77e+00
C08 N07 N08 3.13e-08
L08 N07 N08 8.77e-12
R08 N07 N08 4.92e-02
C09 N08 N09 3.35e-09
L09 N08 N09 2.97e-11
R09 N08 N09 1.56e-01
C10 N09 N10 2.91e-11
L10 N09 N10 9.92e-11
R10 N09 N10 1.96e+00
C11 N10 Port2 4.00e-12
L11 N10 Port2 8.72e-11
R11 N10 Port2 2.75e+01
.ENDS GCE188R72A332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCE188R72A392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A392KA01 Port1 Port2
C01 Port1 N01 3.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 1.53e-01
C04 N03 N04 1.11e-07
R04 N03 N04 2.02e+01
C05 N04 N05 2.09e-07
R05 N04 N05 5.75e-01
C06 N05 N06 1.39e-07
R06 N05 N06 8.71e-02
C07 N06 N07 9.76e-08
R07 N06 N07 1.38e-02
L08 N07 N08 9.88e-11
R08 N07 N08 8.43e-01
C09 N08 N09 6.52e-08
L09 N08 N09 5.34e-12
R09 N08 N09 2.87e-02
C10 N09 N10 3.31e-09
L10 N09 N10 4.12e-11
R10 N09 N10 1.79e-01
C11 N10 N11 3.62e-11
L11 N10 N11 6.65e-11
R11 N10 N11 1.66e+00
C12 N11 Port2 2.87e-12
L12 N11 Port2 1.06e-10
R12 N11 Port2 1.34e+01
.ENDS GCE188R72A392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCE188R72A392MA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A392MA01 Port1 Port2
C01 Port1 N01 3.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 1.53e-01
C04 N03 N04 1.11e-07
R04 N03 N04 2.02e+01
C05 N04 N05 2.09e-07
R05 N04 N05 5.75e-01
C06 N05 N06 1.39e-07
R06 N05 N06 8.71e-02
C07 N06 N07 9.76e-08
R07 N06 N07 1.38e-02
L08 N07 N08 9.88e-11
R08 N07 N08 8.43e-01
C09 N08 N09 6.52e-08
L09 N08 N09 5.34e-12
R09 N08 N09 2.87e-02
C10 N09 N10 3.31e-09
L10 N09 N10 4.12e-11
R10 N09 N10 1.79e-01
C11 N10 N11 3.62e-11
L11 N10 N11 6.65e-11
R11 N10 N11 1.66e+00
C12 N11 Port2 2.87e-12
L12 N11 Port2 1.06e-10
R12 N11 Port2 1.34e+01
.ENDS GCE188R72A392MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCE188R72A472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A472KA01 Port1 Port2
C01 Port1 N01 4.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.08e-01
C04 N03 N04 1.05e-07
R04 N03 N04 4.27e+01
C05 N04 N05 3.20e-07
R05 N04 N05 6.98e-01
C06 N05 N06 3.37e-07
R06 N05 N06 9.21e-02
C07 N06 N07 1.90e-07
R07 N06 N07 5.56e-02
L08 N07 N08 9.54e-11
R08 N07 N08 4.35e-01
C09 N08 N09 4.03e-08
L09 N08 N09 1.15e-11
R09 N08 N09 5.49e-02
C10 N09 N10 8.47e-09
L10 N09 N10 2.42e-11
R10 N09 N10 1.18e-01
C11 N10 N11 5.06e-11
L11 N10 N11 5.12e-11
R11 N10 N11 1.21e+00
C12 N11 Port2 3.35e-12
L12 N11 Port2 1.04e-10
R12 N11 Port2 3.21e+01
.ENDS GCE188R72A472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCE188R72A472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A472MA01 Port1 Port2
C01 Port1 N01 4.91e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.08e-01
C04 N03 N04 1.05e-07
R04 N03 N04 4.27e+01
C05 N04 N05 3.20e-07
R05 N04 N05 6.98e-01
C06 N05 N06 3.37e-07
R06 N05 N06 9.21e-02
C07 N06 N07 1.90e-07
R07 N06 N07 5.56e-02
L08 N07 N08 9.54e-11
R08 N07 N08 4.35e-01
C09 N08 N09 4.03e-08
L09 N08 N09 1.15e-11
R09 N08 N09 5.49e-02
C10 N09 N10 8.47e-09
L10 N09 N10 2.42e-11
R10 N09 N10 1.18e-01
C11 N10 N11 5.06e-11
L11 N10 N11 5.12e-11
R11 N10 N11 1.21e+00
C12 N11 Port2 3.35e-12
L12 N11 Port2 1.04e-10
R12 N11 Port2 3.21e+01
.ENDS GCE188R72A472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCE188R72A562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A562KA01 Port1 Port2
C01 Port1 N01 5.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 6.91e-02
C04 N03 N04 2.11e-07
R04 N03 N04 7.91e+00
C05 N04 N05 4.21e-07
R05 N04 N05 3.17e-01
C06 N05 N06 4.95e-07
R06 N05 N06 6.38e-02
C07 N06 N07 7.84e-07
R07 N06 N07 3.69e-03
L08 N07 N08 7.22e-11
R08 N07 N08 2.15e-01
C09 N08 N09 3.91e-08
L09 N08 N09 1.47e-11
R09 N08 N09 4.70e-02
C10 N09 N10 8.75e-09
L10 N09 N10 2.53e-11
R10 N09 N10 1.25e-01
C11 N10 N11 5.20e-12
L11 N10 N11 1.46e-10
R11 N10 N11 2.05e+01
C12 N11 Port2 1.86e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 2.86e+01
.ENDS GCE188R72A562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCE188R72A562MA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A562MA01 Port1 Port2
C01 Port1 N01 5.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 6.91e-02
C04 N03 N04 2.11e-07
R04 N03 N04 7.91e+00
C05 N04 N05 4.21e-07
R05 N04 N05 3.17e-01
C06 N05 N06 4.95e-07
R06 N05 N06 6.38e-02
C07 N06 N07 7.84e-07
R07 N06 N07 3.69e-03
L08 N07 N08 7.22e-11
R08 N07 N08 2.15e-01
C09 N08 N09 3.91e-08
L09 N08 N09 1.47e-11
R09 N08 N09 4.70e-02
C10 N09 N10 8.75e-09
L10 N09 N10 2.53e-11
R10 N09 N10 1.25e-01
C11 N10 N11 5.20e-12
L11 N10 N11 1.46e-10
R11 N10 N11 2.05e+01
C12 N11 Port2 1.86e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 2.86e+01
.ENDS GCE188R72A562MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCE188R72A682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A682KA01 Port1 Port2
C01 Port1 N01 6.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 6.90e-02
C04 N03 N04 3.09e-07
R04 N03 N04 8.17e+00
C05 N04 N05 6.97e-07
R05 N04 N05 6.73e-01
C06 N05 N06 6.54e-07
R06 N05 N06 1.35e-01
C07 N06 N07 4.93e-07
R07 N06 N07 4.85e-02
L08 N07 N08 7.15e-11
R08 N07 N08 2.40e-01
C09 N08 N09 5.75e-08
L09 N08 N09 1.18e-11
R09 N08 N09 5.00e-02
C10 N09 N10 1.09e-08
L10 N09 N10 2.56e-11
R10 N09 N10 1.22e-01
C11 N10 N11 6.66e-12
L11 N10 N11 1.05e-10
R11 N10 N11 1.41e+01
C12 N11 Port2 4.91e-12
L12 N11 Port2 6.54e-11
R12 N11 Port2 1.34e+01
.ENDS GCE188R72A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCE188R72A682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A682MA01 Port1 Port2
C01 Port1 N01 6.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 6.90e-02
C04 N03 N04 3.09e-07
R04 N03 N04 8.17e+00
C05 N04 N05 6.97e-07
R05 N04 N05 6.73e-01
C06 N05 N06 6.54e-07
R06 N05 N06 1.35e-01
C07 N06 N07 4.93e-07
R07 N06 N07 4.85e-02
L08 N07 N08 7.15e-11
R08 N07 N08 2.40e-01
C09 N08 N09 5.75e-08
L09 N08 N09 1.18e-11
R09 N08 N09 5.00e-02
C10 N09 N10 1.09e-08
L10 N09 N10 2.56e-11
R10 N09 N10 1.22e-01
C11 N10 N11 6.66e-12
L11 N10 N11 1.05e-10
R11 N10 N11 1.41e+01
C12 N11 Port2 4.91e-12
L12 N11 Port2 6.54e-11
R12 N11 Port2 1.34e+01
.ENDS GCE188R72A682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A822KA01 Port1 Port2
C01 Port1 N01 8.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 5.63e-02
C04 N03 N04 5.02e-07
R04 N03 N04 6.18e+00
C05 N04 N05 1.04e-06
R05 N04 N05 7.14e-01
C06 N05 N06 7.99e-07
R06 N05 N06 1.96e-01
C07 N06 N07 6.06e-07
R07 N06 N07 5.68e-02
L08 N07 N08 6.89e-11
R08 N07 N08 1.97e-01
C09 N08 N09 6.20e-08
L09 N08 N09 1.56e-11
R09 N08 N09 5.66e-02
C10 N09 N10 1.43e-08
L10 N09 N10 2.92e-11
R10 N09 N10 1.20e-01
C11 N10 N11 9.46e-09
L11 N10 N11 1.29e-11
R11 N10 N11 5.20e-02
C12 N11 N12 5.65e-12
L12 N11 N12 9.90e-11
R12 N11 N12 1.25e+01
C13 N12 Port2 4.58e-12
L13 N12 Port2 7.02e-11
R13 N12 Port2 1.66e+01
.ENDS GCE188R72A822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A822MA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A822MA01 Port1 Port2
C01 Port1 N01 8.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 5.63e-02
C04 N03 N04 5.02e-07
R04 N03 N04 6.18e+00
C05 N04 N05 1.04e-06
R05 N04 N05 7.14e-01
C06 N05 N06 7.99e-07
R06 N05 N06 1.96e-01
C07 N06 N07 6.06e-07
R07 N06 N07 5.68e-02
L08 N07 N08 6.89e-11
R08 N07 N08 1.97e-01
C09 N08 N09 6.20e-08
L09 N08 N09 1.56e-11
R09 N08 N09 5.66e-02
C10 N09 N10 1.43e-08
L10 N09 N10 2.92e-11
R10 N09 N10 1.20e-01
C11 N10 N11 9.46e-09
L11 N10 N11 1.29e-11
R11 N10 N11 5.20e-02
C12 N11 N12 5.65e-12
L12 N11 N12 9.90e-11
R12 N11 N12 1.25e+01
C13 N12 Port2 4.58e-12
L13 N12 Port2 7.02e-11
R13 N12 Port2 1.66e+01
.ENDS GCE188R72A822MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCE216R71H102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H102KA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-11
R03 N02 N03 3.11e-01
C04 N03 N04 1.05e-08
R04 N03 N04 2.88e+02
C05 N04 N05 6.21e-08
R05 N04 N05 2.00e+00
C06 N05 N06 6.35e-08
R06 N05 N06 4.05e-01
C07 N06 N07 1.17e-08
R07 N06 N07 2.79e-01
L08 N07 N08 5.08e-11
R08 N07 N08 2.88e+00
C09 N08 N09 1.78e-11
L09 N08 N09 1.84e-10
R09 N08 N09 3.29e+00
C10 N09 N10 6.07e-12
L10 N09 N10 1.34e-10
R10 N09 N10 1.40e+01
C11 N10 Port2 1.74e-12
L11 N10 Port2 1.77e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R71H102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GCE216R71H122KA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H122KA01 Port1 Port2
C01 Port1 N01 1.32e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.87e-01
C04 N03 N04 1.64e-08
R04 N03 N04 1.54e+02
C05 N04 N05 9.58e-08
R05 N04 N05 2.02e+00
C06 N05 N06 4.52e-08
R06 N05 N06 5.55e-01
C07 N06 N07 1.70e-08
R07 N06 N07 1.52e-01
C08 N07 N08 2.70e-10
L08 N07 N08 7.25e-11
R08 N07 N08 4.76e-01
C09 N08 N09 3.55e-11
L09 N08 N09 9.40e-11
R09 N08 N09 2.34e+00
C10 N09 Port2 1.80e-12
L10 N09 Port2 3.15e-10
R10 N09 Port2 2.27e+01
.ENDS GCE216R71H122KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCE216R71H152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.18e-11
R03 N02 N03 2.63e-01
C04 N03 N04 2.30e-08
R04 N03 N04 1.18e+02
C05 N04 N05 6.62e-08
R05 N04 N05 1.32e+00
C06 N05 N06 2.67e-08
R06 N05 N06 2.36e-01
C07 N06 N07 7.31e-09
L07 N06 N07 9.27e-12
R07 N06 N07 6.65e-02
C08 N07 N08 7.49e-10
L08 N07 N08 4.29e-11
R08 N07 N08 3.20e-01
C09 N08 N09 4.21e-11
L09 N08 N09 8.52e-11
R09 N08 N09 1.97e+00
C10 N09 N10 4.72e-12
L10 N09 N10 1.50e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 2.14e-12
L11 N10 Port2 1.80e-10
R11 N10 Port2 1.91e+01
.ENDS GCE216R71H152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GCE216R71H182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H182KA01 Port1 Port2
C01 Port1 N01 1.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.19e-11
R03 N02 N03 1.93e-01
C04 N03 N04 2.99e-08
R04 N03 N04 1.24e+02
C05 N04 N05 1.22e-07
R05 N04 N05 2.51e+00
C06 N05 N06 8.73e-08
R06 N05 N06 4.50e-01
C07 N06 N07 2.59e-08
R07 N06 N07 1.67e-01
C08 N07 N08 9.98e-10
L08 N07 N08 2.32e-11
R08 N07 N08 2.22e-01
C09 N08 N09 2.88e-11
L09 N08 N09 1.47e-10
R09 N08 N09 2.49e+00
C10 N09 Port2 1.62e-12
L10 N09 Port2 3.12e-10
R10 N09 Port2 2.74e+01
.ENDS GCE216R71H182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCE216R71H222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H222KA01 Port1 Port2
C01 Port1 N01 2.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.06e-12
R03 N02 N03 1.46e-01
C04 N03 N04 2.93e-08
R04 N03 N04 2.17e+02
C05 N04 N05 2.24e-07
R05 N04 N05 5.35e+00
C06 N05 N06 1.67e-07
R06 N05 N06 9.60e-01
C07 N06 N07 1.07e-07
R07 N06 N07 2.77e-01
C08 N07 N08 3.00e-08
R08 N07 N08 1.18e-01
L09 N08 N09 1.75e-10
R09 N08 N09 1.67e+00
C10 N09 N10 2.09e-09
L10 N09 N10 2.09e-11
R10 N09 N10 1.90e-01
C11 N10 N11 7.83e-12
L11 N10 N11 7.83e-11
R11 N10 N11 1.18e+01
C12 N11 Port2 1.34e-12
L12 N11 Port2 2.30e-10
R12 N11 Port2 4.22e+01
.ENDS GCE216R71H222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCE216R71H272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H272KA01 Port1 Port2
C01 Port1 N01 2.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.09e-11
R03 N02 N03 1.75e-01
C04 N03 N04 5.87e-08
R04 N03 N04 4.36e+01
C05 N04 N05 1.44e-07
R05 N04 N05 1.03e+00
C06 N05 N06 8.58e-08
R06 N05 N06 1.41e-01
C07 N06 N07 9.24e-08
R07 N06 N07 1.19e-02
C08 N07 N08 1.35e-08
L08 N07 N08 1.47e-11
R08 N07 N08 7.29e-02
C09 N08 N09 1.53e-09
L09 N08 N09 4.17e-11
R09 N08 N09 2.71e-01
C10 N09 N10 5.25e-11
L10 N09 N10 7.62e-11
R10 N09 N10 9.67e-01
C11 N10 Port2 1.53e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 2.85e+01
.ENDS GCE216R71H272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCE216R71H332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H332KA01 Port1 Port2
C01 Port1 N01 3.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 1.46e-01
C04 N03 N04 8.76e-08
R04 N03 N04 3.23e+01
C05 N04 N05 2.10e-07
R05 N04 N05 8.94e-01
C06 N05 N06 1.63e-07
R06 N05 N06 1.43e-01
C07 N06 N07 1.54e-07
R07 N06 N07 4.95e-02
C08 N07 N08 1.04e-08
L08 N07 N08 1.77e-11
R08 N07 N08 7.96e-02
C09 N08 N09 1.81e-09
L09 N08 N09 3.30e-11
R09 N08 N09 2.32e-01
C10 N09 N10 3.49e-11
L10 N09 N10 1.08e-10
R10 N09 N10 1.39e+00
C11 N10 Port2 3.11e-12
L11 N10 Port2 1.38e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R71H332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GCE216R71H392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H392KA01 Port1 Port2
C01 Port1 N01 4.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 2.04e-01
C04 N03 N04 1.04e-07
R04 N03 N04 3.04e+01
C05 N04 N05 2.58e-07
R05 N04 N05 9.73e-01
C06 N05 N06 1.31e-07
R06 N05 N06 2.08e-01
C07 N06 N07 1.66e-07
R07 N06 N07 1.35e-02
C08 N07 N08 1.21e-08
L08 N07 N08 2.18e-11
R08 N07 N08 8.46e-02
C09 N08 N09 2.20e-09
L09 N08 N09 3.70e-11
R09 N08 N09 2.20e-01
C10 N09 N10 4.17e-11
L10 N09 N10 9.52e-11
R10 N09 N10 1.21e+00
C11 N10 Port2 2.29e-12
L11 N10 Port2 1.84e-10
R11 N10 Port2 2.45e+01
.ENDS GCE216R71H392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCE216R71H472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H472KA01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.59e-07
R04 N03 N04 1.26e+01
C05 N04 N05 3.63e-07
R05 N04 N05 4.38e-01
C06 N05 N06 2.14e-07
R06 N05 N06 1.17e-01
C07 N06 N07 1.16e-07
R07 N06 N07 2.55e-02
L08 N07 N08 1.21e-10
R08 N07 N08 1.04e+00
C09 N08 N09 2.28e-08
L09 N08 N09 1.24e-11
R09 N08 N09 7.35e-02
C10 N09 N10 3.47e-09
L10 N09 N10 2.80e-11
R10 N09 N10 1.86e-01
C11 N10 N11 7.02e-10
L11 N10 N11 6.85e-12
R11 N10 N11 1.59e-01
C12 N11 Port2 3.69e-12
L12 N11 Port2 1.17e-10
R12 N11 Port2 1.61e+01
.ENDS GCE216R71H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCE216R71H472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H472MA01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.59e-07
R04 N03 N04 1.26e+01
C05 N04 N05 3.63e-07
R05 N04 N05 4.38e-01
C06 N05 N06 2.14e-07
R06 N05 N06 1.17e-01
C07 N06 N07 1.16e-07
R07 N06 N07 2.55e-02
L08 N07 N08 1.21e-10
R08 N07 N08 1.04e+00
C09 N08 N09 2.28e-08
L09 N08 N09 1.24e-11
R09 N08 N09 7.35e-02
C10 N09 N10 3.47e-09
L10 N09 N10 2.80e-11
R10 N09 N10 1.86e-01
C11 N10 N11 7.02e-10
L11 N10 N11 6.85e-12
R11 N10 N11 1.59e-01
C12 N11 Port2 3.69e-12
L12 N11 Port2 1.17e-10
R12 N11 Port2 1.61e+01
.ENDS GCE216R71H472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCE216R71H562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R71H562KA01 Port1 Port2
C01 Port1 N01 5.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 1.04e-01
C04 N03 N04 1.69e-07
R04 N03 N04 1.97e+01
C05 N04 N05 3.32e-07
R05 N04 N05 5.81e-01
C06 N05 N06 3.28e-07
R06 N05 N06 7.65e-02
C07 N06 N07 2.36e-07
R07 N06 N07 4.09e-02
L08 N07 N08 4.44e-11
R08 N07 N08 2.45e-01
C09 N08 N09 1.26e-08
L09 N08 N09 3.03e-11
R09 N08 N09 8.27e-02
C10 N09 N10 4.62e-09
L10 N09 N10 2.82e-11
R10 N09 N10 1.58e-01
C11 N10 N11 5.62e-11
L11 N10 N11 7.27e-11
R11 N10 N11 8.67e-01
C12 N11 Port2 3.49e-12
L12 N11 Port2 9.80e-11
R12 N11 Port2 1.19e+01
.ENDS GCE216R71H562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCE216R72A102KA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A102KA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-11
R03 N02 N03 3.11e-01
C04 N03 N04 1.05e-08
R04 N03 N04 2.88e+02
C05 N04 N05 6.21e-08
R05 N04 N05 2.00e+00
C06 N05 N06 6.35e-08
R06 N05 N06 4.05e-01
C07 N06 N07 1.17e-08
R07 N06 N07 2.79e-01
L08 N07 N08 5.08e-11
R08 N07 N08 2.88e+00
C09 N08 N09 1.78e-11
L09 N08 N09 1.84e-10
R09 N08 N09 3.29e+00
C10 N09 N10 6.07e-12
L10 N09 N10 1.34e-10
R10 N09 N10 1.40e+01
C11 N10 Port2 1.74e-12
L11 N10 Port2 1.77e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R72A102KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCE216R72A102MA01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A102MA01 Port1 Port2
C01 Port1 N01 1.09e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-11
R03 N02 N03 3.11e-01
C04 N03 N04 1.05e-08
R04 N03 N04 2.88e+02
C05 N04 N05 6.21e-08
R05 N04 N05 2.00e+00
C06 N05 N06 6.35e-08
R06 N05 N06 4.05e-01
C07 N06 N07 1.17e-08
R07 N06 N07 2.79e-01
L08 N07 N08 5.08e-11
R08 N07 N08 2.88e+00
C09 N08 N09 1.78e-11
L09 N08 N09 1.84e-10
R09 N08 N09 3.29e+00
C10 N09 N10 6.07e-12
L10 N09 N10 1.34e-10
R10 N09 N10 1.40e+01
C11 N10 Port2 1.74e-12
L11 N10 Port2 1.77e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R72A102MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCE216R72A122KA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A122KA01 Port1 Port2
C01 Port1 N01 1.32e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.87e-01
C04 N03 N04 1.64e-08
R04 N03 N04 1.54e+02
C05 N04 N05 9.58e-08
R05 N04 N05 2.02e+00
C06 N05 N06 4.52e-08
R06 N05 N06 5.55e-01
C07 N06 N07 1.70e-08
R07 N06 N07 1.52e-01
C08 N07 N08 2.70e-10
L08 N07 N08 7.25e-11
R08 N07 N08 4.76e-01
C09 N08 N09 3.55e-11
L09 N08 N09 9.40e-11
R09 N08 N09 2.34e+00
C10 N09 Port2 1.80e-12
L10 N09 Port2 3.15e-10
R10 N09 Port2 2.27e+01
.ENDS GCE216R72A122KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCE216R72A122MA01
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A122MA01 Port1 Port2
C01 Port1 N01 1.32e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.87e-01
C04 N03 N04 1.64e-08
R04 N03 N04 1.54e+02
C05 N04 N05 9.58e-08
R05 N04 N05 2.02e+00
C06 N05 N06 4.52e-08
R06 N05 N06 5.55e-01
C07 N06 N07 1.70e-08
R07 N06 N07 1.52e-01
C08 N07 N08 2.70e-10
L08 N07 N08 7.25e-11
R08 N07 N08 4.76e-01
C09 N08 N09 3.55e-11
L09 N08 N09 9.40e-11
R09 N08 N09 2.34e+00
C10 N09 Port2 1.80e-12
L10 N09 Port2 3.15e-10
R10 N09 Port2 2.27e+01
.ENDS GCE216R72A122MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE216R72A152KA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.18e-11
R03 N02 N03 2.63e-01
C04 N03 N04 2.30e-08
R04 N03 N04 1.18e+02
C05 N04 N05 6.62e-08
R05 N04 N05 1.32e+00
C06 N05 N06 2.67e-08
R06 N05 N06 2.36e-01
C07 N06 N07 7.31e-09
L07 N06 N07 9.27e-12
R07 N06 N07 6.65e-02
C08 N07 N08 7.49e-10
L08 N07 N08 4.29e-11
R08 N07 N08 3.20e-01
C09 N08 N09 4.21e-11
L09 N08 N09 8.52e-11
R09 N08 N09 1.97e+00
C10 N09 N10 4.72e-12
L10 N09 N10 1.50e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 2.14e-12
L11 N10 Port2 1.80e-10
R11 N10 Port2 1.91e+01
.ENDS GCE216R72A152KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE216R72A152MA01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A152MA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.18e-11
R03 N02 N03 2.63e-01
C04 N03 N04 2.30e-08
R04 N03 N04 1.18e+02
C05 N04 N05 6.62e-08
R05 N04 N05 1.32e+00
C06 N05 N06 2.67e-08
R06 N05 N06 2.36e-01
C07 N06 N07 7.31e-09
L07 N06 N07 9.27e-12
R07 N06 N07 6.65e-02
C08 N07 N08 7.49e-10
L08 N07 N08 4.29e-11
R08 N07 N08 3.20e-01
C09 N08 N09 4.21e-11
L09 N08 N09 8.52e-11
R09 N08 N09 1.97e+00
C10 N09 N10 4.72e-12
L10 N09 N10 1.50e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 2.14e-12
L11 N10 Port2 1.80e-10
R11 N10 Port2 1.91e+01
.ENDS GCE216R72A152MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCE216R72A182KA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A182KA01 Port1 Port2
C01 Port1 N01 1.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.19e-11
R03 N02 N03 1.93e-01
C04 N03 N04 2.99e-08
R04 N03 N04 1.24e+02
C05 N04 N05 1.22e-07
R05 N04 N05 2.51e+00
C06 N05 N06 8.73e-08
R06 N05 N06 4.50e-01
C07 N06 N07 2.59e-08
R07 N06 N07 1.67e-01
C08 N07 N08 9.98e-10
L08 N07 N08 2.32e-11
R08 N07 N08 2.22e-01
C09 N08 N09 2.88e-11
L09 N08 N09 1.47e-10
R09 N08 N09 2.49e+00
C10 N09 Port2 1.62e-12
L10 N09 Port2 3.12e-10
R10 N09 Port2 2.74e+01
.ENDS GCE216R72A182KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCE216R72A182MA01
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A182MA01 Port1 Port2
C01 Port1 N01 1.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.19e-11
R03 N02 N03 1.93e-01
C04 N03 N04 2.99e-08
R04 N03 N04 1.24e+02
C05 N04 N05 1.22e-07
R05 N04 N05 2.51e+00
C06 N05 N06 8.73e-08
R06 N05 N06 4.50e-01
C07 N06 N07 2.59e-08
R07 N06 N07 1.67e-01
C08 N07 N08 9.98e-10
L08 N07 N08 2.32e-11
R08 N07 N08 2.22e-01
C09 N08 N09 2.88e-11
L09 N08 N09 1.47e-10
R09 N08 N09 2.49e+00
C10 N09 Port2 1.62e-12
L10 N09 Port2 3.12e-10
R10 N09 Port2 2.74e+01
.ENDS GCE216R72A182MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE216R72A222KA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A222KA01 Port1 Port2
C01 Port1 N01 2.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.06e-12
R03 N02 N03 1.46e-01
C04 N03 N04 2.93e-08
R04 N03 N04 2.17e+02
C05 N04 N05 2.24e-07
R05 N04 N05 5.35e+00
C06 N05 N06 1.67e-07
R06 N05 N06 9.60e-01
C07 N06 N07 1.07e-07
R07 N06 N07 2.77e-01
C08 N07 N08 3.00e-08
R08 N07 N08 1.18e-01
L09 N08 N09 1.75e-10
R09 N08 N09 1.67e+00
C10 N09 N10 2.09e-09
L10 N09 N10 2.09e-11
R10 N09 N10 1.90e-01
C11 N10 N11 7.83e-12
L11 N10 N11 7.83e-11
R11 N10 N11 1.18e+01
C12 N11 Port2 1.34e-12
L12 N11 Port2 2.30e-10
R12 N11 Port2 4.22e+01
.ENDS GCE216R72A222KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE216R72A222MA01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A222MA01 Port1 Port2
C01 Port1 N01 2.33e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.06e-12
R03 N02 N03 1.46e-01
C04 N03 N04 2.93e-08
R04 N03 N04 2.17e+02
C05 N04 N05 2.24e-07
R05 N04 N05 5.35e+00
C06 N05 N06 1.67e-07
R06 N05 N06 9.60e-01
C07 N06 N07 1.07e-07
R07 N06 N07 2.77e-01
C08 N07 N08 3.00e-08
R08 N07 N08 1.18e-01
L09 N08 N09 1.75e-10
R09 N08 N09 1.67e+00
C10 N09 N10 2.09e-09
L10 N09 N10 2.09e-11
R10 N09 N10 1.90e-01
C11 N10 N11 7.83e-12
L11 N10 N11 7.83e-11
R11 N10 N11 1.18e+01
C12 N11 Port2 1.34e-12
L12 N11 Port2 2.30e-10
R12 N11 Port2 4.22e+01
.ENDS GCE216R72A222MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCE216R72A272KA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A272KA01 Port1 Port2
C01 Port1 N01 2.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.09e-11
R03 N02 N03 1.75e-01
C04 N03 N04 5.87e-08
R04 N03 N04 4.36e+01
C05 N04 N05 1.44e-07
R05 N04 N05 1.03e+00
C06 N05 N06 8.58e-08
R06 N05 N06 1.41e-01
C07 N06 N07 9.24e-08
R07 N06 N07 1.19e-02
C08 N07 N08 1.35e-08
L08 N07 N08 1.47e-11
R08 N07 N08 7.29e-02
C09 N08 N09 1.53e-09
L09 N08 N09 4.17e-11
R09 N08 N09 2.71e-01
C10 N09 N10 5.25e-11
L10 N09 N10 7.62e-11
R10 N09 N10 9.67e-01
C11 N10 Port2 1.53e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 2.85e+01
.ENDS GCE216R72A272KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCE216R72A272MA01
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A272MA01 Port1 Port2
C01 Port1 N01 2.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.09e-11
R03 N02 N03 1.75e-01
C04 N03 N04 5.87e-08
R04 N03 N04 4.36e+01
C05 N04 N05 1.44e-07
R05 N04 N05 1.03e+00
C06 N05 N06 8.58e-08
R06 N05 N06 1.41e-01
C07 N06 N07 9.24e-08
R07 N06 N07 1.19e-02
C08 N07 N08 1.35e-08
L08 N07 N08 1.47e-11
R08 N07 N08 7.29e-02
C09 N08 N09 1.53e-09
L09 N08 N09 4.17e-11
R09 N08 N09 2.71e-01
C10 N09 N10 5.25e-11
L10 N09 N10 7.62e-11
R10 N09 N10 9.67e-01
C11 N10 Port2 1.53e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 2.85e+01
.ENDS GCE216R72A272MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCE216R72A332KA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A332KA01 Port1 Port2
C01 Port1 N01 3.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 1.46e-01
C04 N03 N04 8.76e-08
R04 N03 N04 3.23e+01
C05 N04 N05 2.10e-07
R05 N04 N05 8.94e-01
C06 N05 N06 1.63e-07
R06 N05 N06 1.43e-01
C07 N06 N07 1.54e-07
R07 N06 N07 4.95e-02
C08 N07 N08 1.04e-08
L08 N07 N08 1.77e-11
R08 N07 N08 7.96e-02
C09 N08 N09 1.81e-09
L09 N08 N09 3.30e-11
R09 N08 N09 2.32e-01
C10 N09 N10 3.49e-11
L10 N09 N10 1.08e-10
R10 N09 N10 1.39e+00
C11 N10 Port2 3.11e-12
L11 N10 Port2 1.38e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R72A332KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCE216R72A332MA01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A332MA01 Port1 Port2
C01 Port1 N01 3.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 1.46e-01
C04 N03 N04 8.76e-08
R04 N03 N04 3.23e+01
C05 N04 N05 2.10e-07
R05 N04 N05 8.94e-01
C06 N05 N06 1.63e-07
R06 N05 N06 1.43e-01
C07 N06 N07 1.54e-07
R07 N06 N07 4.95e-02
C08 N07 N08 1.04e-08
L08 N07 N08 1.77e-11
R08 N07 N08 7.96e-02
C09 N08 N09 1.81e-09
L09 N08 N09 3.30e-11
R09 N08 N09 2.32e-01
C10 N09 N10 3.49e-11
L10 N09 N10 1.08e-10
R10 N09 N10 1.39e+00
C11 N10 Port2 3.11e-12
L11 N10 Port2 1.38e-10
R11 N10 Port2 1.86e+01
.ENDS GCE216R72A332MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCE216R72A392KA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A392KA01 Port1 Port2
C01 Port1 N01 4.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 2.04e-01
C04 N03 N04 1.04e-07
R04 N03 N04 3.04e+01
C05 N04 N05 2.58e-07
R05 N04 N05 9.73e-01
C06 N05 N06 1.31e-07
R06 N05 N06 2.08e-01
C07 N06 N07 1.66e-07
R07 N06 N07 1.35e-02
C08 N07 N08 1.21e-08
L08 N07 N08 2.18e-11
R08 N07 N08 8.46e-02
C09 N08 N09 2.20e-09
L09 N08 N09 3.70e-11
R09 N08 N09 2.20e-01
C10 N09 N10 4.17e-11
L10 N09 N10 9.52e-11
R10 N09 N10 1.21e+00
C11 N10 Port2 2.29e-12
L11 N10 Port2 1.84e-10
R11 N10 Port2 2.45e+01
.ENDS GCE216R72A392KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCE216R72A392MA01
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A392MA01 Port1 Port2
C01 Port1 N01 4.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 2.04e-01
C04 N03 N04 1.04e-07
R04 N03 N04 3.04e+01
C05 N04 N05 2.58e-07
R05 N04 N05 9.73e-01
C06 N05 N06 1.31e-07
R06 N05 N06 2.08e-01
C07 N06 N07 1.66e-07
R07 N06 N07 1.35e-02
C08 N07 N08 1.21e-08
L08 N07 N08 2.18e-11
R08 N07 N08 8.46e-02
C09 N08 N09 2.20e-09
L09 N08 N09 3.70e-11
R09 N08 N09 2.20e-01
C10 N09 N10 4.17e-11
L10 N09 N10 9.52e-11
R10 N09 N10 1.21e+00
C11 N10 Port2 2.29e-12
L11 N10 Port2 1.84e-10
R11 N10 Port2 2.45e+01
.ENDS GCE216R72A392MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCE216R72A472KA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A472KA01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.59e-07
R04 N03 N04 1.26e+01
C05 N04 N05 3.63e-07
R05 N04 N05 4.38e-01
C06 N05 N06 2.14e-07
R06 N05 N06 1.17e-01
C07 N06 N07 1.16e-07
R07 N06 N07 2.55e-02
L08 N07 N08 1.21e-10
R08 N07 N08 1.04e+00
C09 N08 N09 2.28e-08
L09 N08 N09 1.24e-11
R09 N08 N09 7.35e-02
C10 N09 N10 3.47e-09
L10 N09 N10 2.80e-11
R10 N09 N10 1.86e-01
C11 N10 N11 7.02e-10
L11 N10 N11 6.85e-12
R11 N10 N11 1.59e-01
C12 N11 Port2 3.69e-12
L12 N11 Port2 1.17e-10
R12 N11 Port2 1.61e+01
.ENDS GCE216R72A472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCE216R72A472MA01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A472MA01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.59e-07
R04 N03 N04 1.26e+01
C05 N04 N05 3.63e-07
R05 N04 N05 4.38e-01
C06 N05 N06 2.14e-07
R06 N05 N06 1.17e-01
C07 N06 N07 1.16e-07
R07 N06 N07 2.55e-02
L08 N07 N08 1.21e-10
R08 N07 N08 1.04e+00
C09 N08 N09 2.28e-08
L09 N08 N09 1.24e-11
R09 N08 N09 7.35e-02
C10 N09 N10 3.47e-09
L10 N09 N10 2.80e-11
R10 N09 N10 1.86e-01
C11 N10 N11 7.02e-10
L11 N10 N11 6.85e-12
R11 N10 N11 1.59e-01
C12 N11 Port2 3.69e-12
L12 N11 Port2 1.17e-10
R12 N11 Port2 1.61e+01
.ENDS GCE216R72A472MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCE216R72A562KA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A562KA01 Port1 Port2
C01 Port1 N01 5.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 1.04e-01
C04 N03 N04 1.69e-07
R04 N03 N04 1.97e+01
C05 N04 N05 3.32e-07
R05 N04 N05 5.81e-01
C06 N05 N06 3.28e-07
R06 N05 N06 7.65e-02
C07 N06 N07 2.36e-07
R07 N06 N07 4.09e-02
L08 N07 N08 4.44e-11
R08 N07 N08 2.45e-01
C09 N08 N09 1.26e-08
L09 N08 N09 3.03e-11
R09 N08 N09 8.27e-02
C10 N09 N10 4.62e-09
L10 N09 N10 2.82e-11
R10 N09 N10 1.58e-01
C11 N10 N11 5.62e-11
L11 N10 N11 7.27e-11
R11 N10 N11 8.67e-01
C12 N11 Port2 3.49e-12
L12 N11 Port2 9.80e-11
R12 N11 Port2 1.19e+01
.ENDS GCE216R72A562KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCE216R72A562MA01
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A562MA01 Port1 Port2
C01 Port1 N01 5.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 1.04e-01
C04 N03 N04 1.69e-07
R04 N03 N04 1.97e+01
C05 N04 N05 3.32e-07
R05 N04 N05 5.81e-01
C06 N05 N06 3.28e-07
R06 N05 N06 7.65e-02
C07 N06 N07 2.36e-07
R07 N06 N07 4.09e-02
L08 N07 N08 4.44e-11
R08 N07 N08 2.45e-01
C09 N08 N09 1.26e-08
L09 N08 N09 3.03e-11
R09 N08 N09 8.27e-02
C10 N09 N10 4.62e-09
L10 N09 N10 2.82e-11
R10 N09 N10 1.58e-01
C11 N10 N11 5.62e-11
L11 N10 N11 7.27e-11
R11 N10 N11 8.67e-01
C12 N11 Port2 3.49e-12
L12 N11 Port2 9.80e-11
R12 N11 Port2 1.19e+01
.ENDS GCE216R72A562MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCE219R72A221KA01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A221KA01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GCE219R72A221KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCE219R72A221MA01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A221MA01 Port1 Port2
C01 Port1 N01 2.31e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 4.90e-09
R04 N03 N04 6.89e+01
C05 N04 N05 1.62e-08
R05 N04 N05 3.28e+00
C06 N05 N06 8.66e-09
R06 N05 N06 9.17e-01
C07 N06 N07 4.09e-09
R07 N06 N07 6.51e-01
C08 N07 N08 1.52e-09
R08 N07 N08 4.79e-01
C09 N08 N09 5.00e-12
L09 N08 N09 2.72e-10
R09 N08 N09 1.70e+01
C10 N09 Port2 4.88e-13
L10 N09 Port2 3.06e-10
R10 N09 Port2 2.18e+01
.ENDS GCE219R72A221MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GCE219R72A271KA01
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A271KA01 Port1 Port2
C01 Port1 N01 2.73e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-11
R03 N02 N03 4.25e-01
C04 N03 N04 6.93e-09
R04 N03 N04 2.62e+01
C05 N04 N05 1.60e-08
R05 N04 N05 1.56e+00
C06 N05 N06 1.46e-09
R06 N05 N06 7.46e-01
C07 N06 N07 7.79e-09
R07 N06 N07 6.94e-01
C08 N07 N08 6.15e-09
R08 N07 N08 8.93e-02
C09 N08 N09 3.02e-09
L09 N08 N09 2.60e-12
R09 N08 N09 2.01e-01
C10 N09 N10 6.34e-12
L10 N09 N10 2.47e-10
R10 N09 N10 1.21e+01
C11 N10 Port2 6.95e-13
L11 N10 Port2 3.35e-10
R11 N10 Port2 1.58e+01
.ENDS GCE219R72A271KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GCE219R72A271MA01
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A271MA01 Port1 Port2
C01 Port1 N01 2.73e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-11
R03 N02 N03 4.25e-01
C04 N03 N04 6.93e-09
R04 N03 N04 2.62e+01
C05 N04 N05 1.60e-08
R05 N04 N05 1.56e+00
C06 N05 N06 1.46e-09
R06 N05 N06 7.46e-01
C07 N06 N07 7.79e-09
R07 N06 N07 6.94e-01
C08 N07 N08 6.15e-09
R08 N07 N08 8.93e-02
C09 N08 N09 3.02e-09
L09 N08 N09 2.60e-12
R09 N08 N09 2.01e-01
C10 N09 N10 6.34e-12
L10 N09 N10 2.47e-10
R10 N09 N10 1.21e+01
C11 N10 Port2 6.95e-13
L11 N10 Port2 3.35e-10
R11 N10 Port2 1.58e+01
.ENDS GCE219R72A271MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCE219R72A331KA01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A331KA01 Port1 Port2
C01 Port1 N01 3.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.41e-11
R03 N02 N03 3.84e-01
C04 N03 N04 1.15e-08
R04 N03 N04 1.28e+01
C05 N04 N05 1.54e-08
R05 N04 N05 1.00e+00
C06 N05 N06 3.94e-09
R06 N05 N06 6.20e-01
C07 N06 N07 1.63e-09
R07 N06 N07 2.83e-01
C08 N07 N08 2.85e-09
L08 N07 N08 9.43e-12
R08 N07 N08 1.92e-01
C09 N08 N09 3.62e-10
L09 N08 N09 3.12e-11
R09 N08 N09 6.31e-01
C10 N09 N10 2.70e-12
L10 N09 N10 3.38e-10
R10 N09 N10 1.42e+01
C11 N10 Port2 2.12e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 2.43e+01
.ENDS GCE219R72A331KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCE219R72A331MA01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A331MA01 Port1 Port2
C01 Port1 N01 3.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.41e-11
R03 N02 N03 3.84e-01
C04 N03 N04 1.15e-08
R04 N03 N04 1.28e+01
C05 N04 N05 1.54e-08
R05 N04 N05 1.00e+00
C06 N05 N06 3.94e-09
R06 N05 N06 6.20e-01
C07 N06 N07 1.63e-09
R07 N06 N07 2.83e-01
C08 N07 N08 2.85e-09
L08 N07 N08 9.43e-12
R08 N07 N08 1.92e-01
C09 N08 N09 3.62e-10
L09 N08 N09 3.12e-11
R09 N08 N09 6.31e-01
C10 N09 N10 2.70e-12
L10 N09 N10 3.38e-10
R10 N09 N10 1.42e+01
C11 N10 Port2 2.12e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 2.43e+01
.ENDS GCE219R72A331MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GCE219R72A391KA01
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A391KA01 Port1 Port2
C01 Port1 N01 3.97e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.10e-11
R03 N02 N03 3.72e-01
C04 N03 N04 1.05e-08
R04 N03 N04 4.29e+01
C05 N04 N05 3.35e-08
R05 N04 N05 3.54e+00
C06 N05 N06 1.50e-08
R06 N05 N06 1.09e+00
C07 N06 N07 4.45e-09
R07 N06 N07 5.17e-01
C08 N07 N08 2.90e-09
R08 N07 N08 2.18e-01
C09 N08 N09 1.89e-09
L09 N08 N09 1.55e-11
R09 N08 N09 2.73e-01
C10 N09 N10 4.69e-10
L10 N09 N10 2.92e-11
R10 N09 N10 5.56e-01
C11 N10 N11 5.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.13e+01
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.38e-10
R12 N11 Port2 2.05e+01
.ENDS GCE219R72A391KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GCE219R72A391MA01
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A391MA01 Port1 Port2
C01 Port1 N01 3.97e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.10e-11
R03 N02 N03 3.72e-01
C04 N03 N04 1.05e-08
R04 N03 N04 4.29e+01
C05 N04 N05 3.35e-08
R05 N04 N05 3.54e+00
C06 N05 N06 1.50e-08
R06 N05 N06 1.09e+00
C07 N06 N07 4.45e-09
R07 N06 N07 5.17e-01
C08 N07 N08 2.90e-09
R08 N07 N08 2.18e-01
C09 N08 N09 1.89e-09
L09 N08 N09 1.55e-11
R09 N08 N09 2.73e-01
C10 N09 N10 4.69e-10
L10 N09 N10 2.92e-11
R10 N09 N10 5.56e-01
C11 N10 N11 5.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.13e+01
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.38e-10
R12 N11 Port2 2.05e+01
.ENDS GCE219R72A391MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCE219R72A471KA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A471KA01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GCE219R72A471KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCE219R72A471MA01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A471MA01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 1.13e-08
R04 N03 N04 4.69e+01
C05 N04 N05 5.26e-08
R05 N04 N05 1.59e+00
C06 N05 N06 1.69e-08
R06 N05 N06 7.32e-01
C07 N06 N07 4.05e-09
R07 N06 N07 4.15e-01
C08 N07 N08 3.03e-09
L08 N07 N08 1.05e-11
R08 N07 N08 1.81e-01
C09 N08 N09 3.72e-10
L09 N08 N09 3.51e-11
R09 N08 N09 5.21e-01
C10 N09 Port2 1.47e-12
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.82e+01
.ENDS GCE219R72A471MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GCE219R72A561KA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A561KA01 Port1 Port2
C01 Port1 N01 5.67e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-11
R03 N02 N03 4.19e-01
C04 N03 N04 1.60e-08
R04 N03 N04 2.55e+01
C05 N04 N05 8.39e-08
R05 N04 N05 1.13e+00
C06 N05 N06 2.51e-08
R06 N05 N06 8.17e-01
C07 N06 N07 7.07e-09
R07 N06 N07 4.22e-01
C08 N07 N08 9.79e-09
R08 N07 N08 7.65e-02
C09 N08 N09 7.72e-12
L09 N08 N09 1.58e-10
R09 N08 N09 1.43e+01
C10 N09 Port2 1.06e-12
L10 N09 Port2 3.40e-10
R10 N09 Port2 2.22e+01
.ENDS GCE219R72A561KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GCE219R72A561MA01
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A561MA01 Port1 Port2
C01 Port1 N01 5.67e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-11
R03 N02 N03 4.19e-01
C04 N03 N04 1.60e-08
R04 N03 N04 2.55e+01
C05 N04 N05 8.39e-08
R05 N04 N05 1.13e+00
C06 N05 N06 2.51e-08
R06 N05 N06 8.17e-01
C07 N06 N07 7.07e-09
R07 N06 N07 4.22e-01
C08 N07 N08 9.79e-09
R08 N07 N08 7.65e-02
C09 N08 N09 7.72e-12
L09 N08 N09 1.58e-10
R09 N08 N09 1.43e+01
C10 N09 Port2 1.06e-12
L10 N09 Port2 3.40e-10
R10 N09 Port2 2.22e+01
.ENDS GCE219R72A561MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCE219R72A681KA01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A681KA01 Port1 Port2
C01 Port1 N01 6.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.09e-11
R03 N02 N03 2.51e-01
C04 N03 N04 3.40e-08
R04 N03 N04 1.59e+01
C05 N04 N05 4.77e-08
R05 N04 N05 3.41e+00
C06 N05 N06 2.29e-08
R06 N05 N06 6.85e-01
C07 N06 N07 7.81e-09
R07 N06 N07 2.47e-01
C08 N07 N08 6.70e-09
R08 N07 N08 9.79e-02
C09 N08 N09 2.98e-09
L09 N08 N09 1.72e-11
R09 N08 N09 1.76e-01
C10 N09 N10 4.62e-10
L10 N09 N10 4.05e-11
R10 N09 N10 4.72e-01
C11 N10 N11 7.36e-12
L11 N10 N11 1.26e-10
R11 N10 N11 1.17e+01
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 2.35e+01
.ENDS GCE219R72A681KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCE219R72A681MA01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A681MA01 Port1 Port2
C01 Port1 N01 6.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.09e-11
R03 N02 N03 2.51e-01
C04 N03 N04 3.40e-08
R04 N03 N04 1.59e+01
C05 N04 N05 4.77e-08
R05 N04 N05 3.41e+00
C06 N05 N06 2.29e-08
R06 N05 N06 6.85e-01
C07 N06 N07 7.81e-09
R07 N06 N07 2.47e-01
C08 N07 N08 6.70e-09
R08 N07 N08 9.79e-02
C09 N08 N09 2.98e-09
L09 N08 N09 1.72e-11
R09 N08 N09 1.76e-01
C10 N09 N10 4.62e-10
L10 N09 N10 4.05e-11
R10 N09 N10 4.72e-01
C11 N10 N11 7.36e-12
L11 N10 N11 1.26e-10
R11 N10 N11 1.17e+01
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.62e-10
R12 N11 Port2 2.35e+01
.ENDS GCE219R72A681MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCE219R72A682KA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A682KA01 Port1 Port2
C01 Port1 N01 6.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 7.65e-02
C04 N03 N04 2.01e-07
R04 N03 N04 2.68e+01
C05 N04 N05 9.54e-07
R05 N04 N05 7.83e-01
C06 N05 N06 4.23e-07
R06 N05 N06 3.34e-01
C07 N06 N07 7.39e-07
R07 N06 N07 4.40e-02
C08 N07 N08 1.89e-07
R08 N07 N08 3.96e-02
C09 N08 N09 2.41e-08
L09 N08 N09 2.32e-11
R09 N08 N09 7.55e-02
C10 N09 N10 4.99e-09
L10 N09 N10 3.88e-11
R10 N09 N10 1.69e-01
C11 N10 N11 2.72e-09
L11 N10 N11 1.85e-11
R11 N10 N11 1.20e-01
C12 N11 N12 3.32e-11
L12 N11 N12 1.31e-10
R12 N11 N12 1.76e+00
C13 N12 Port2 1.63e-12
L13 N12 Port2 1.91e-10
R13 N12 Port2 2.55e+01
.ENDS GCE219R72A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCE219R72A682MA01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A682MA01 Port1 Port2
C01 Port1 N01 6.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 7.65e-02
C04 N03 N04 2.01e-07
R04 N03 N04 2.68e+01
C05 N04 N05 9.54e-07
R05 N04 N05 7.83e-01
C06 N05 N06 4.23e-07
R06 N05 N06 3.34e-01
C07 N06 N07 7.39e-07
R07 N06 N07 4.40e-02
C08 N07 N08 1.89e-07
R08 N07 N08 3.96e-02
C09 N08 N09 2.41e-08
L09 N08 N09 2.32e-11
R09 N08 N09 7.55e-02
C10 N09 N10 4.99e-09
L10 N09 N10 3.88e-11
R10 N09 N10 1.69e-01
C11 N10 N11 2.72e-09
L11 N10 N11 1.85e-11
R11 N10 N11 1.20e-01
C12 N11 N12 3.32e-11
L12 N11 N12 1.31e-10
R12 N11 N12 1.76e+00
C13 N12 Port2 1.63e-12
L13 N12 Port2 1.91e-10
R13 N12 Port2 2.55e+01
.ENDS GCE219R72A682MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GCE219R72A821KA01
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A821KA01 Port1 Port2
C01 Port1 N01 8.25e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.65e-11
R03 N02 N03 2.54e-01
C04 N03 N04 1.60e-08
R04 N03 N04 7.70e+01
C05 N04 N05 6.89e-08
R05 N04 N05 1.99e+00
C06 N05 N06 5.15e-07
R06 N05 N06 9.05e-01
C07 N06 N07 4.34e-08
R07 N06 N07 5.66e-01
C08 N07 N08 1.49e-08
R08 N07 N08 2.74e-01
C09 N08 N09 6.24e-09
R09 N08 N09 1.49e-01
C10 N09 N10 7.00e-09
L10 N09 N10 9.14e-12
R10 N09 N10 1.58e-01
C11 N10 N11 5.34e-10
L11 N10 N11 4.20e-11
R11 N10 N11 4.87e-01
C12 N11 N12 5.49e-12
L12 N11 N12 1.92e-10
R12 N11 N12 1.58e+01
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.40e-10
R13 N12 Port2 1.78e+01
.ENDS GCE219R72A821KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GCE219R72A821MA01
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE219R72A821MA01 Port1 Port2
C01 Port1 N01 8.25e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.65e-11
R03 N02 N03 2.54e-01
C04 N03 N04 1.60e-08
R04 N03 N04 7.70e+01
C05 N04 N05 6.89e-08
R05 N04 N05 1.99e+00
C06 N05 N06 5.15e-07
R06 N05 N06 9.05e-01
C07 N06 N07 4.34e-08
R07 N06 N07 5.66e-01
C08 N07 N08 1.49e-08
R08 N07 N08 2.74e-01
C09 N08 N09 6.24e-09
R09 N08 N09 1.49e-01
C10 N09 N10 7.00e-09
L10 N09 N10 9.14e-12
R10 N09 N10 1.58e-01
C11 N10 N11 5.34e-10
L11 N10 N11 4.20e-11
R11 N10 N11 4.87e-01
C12 N11 N12 5.49e-12
L12 N11 N12 1.92e-10
R12 N11 N12 1.58e+01
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.40e-10
R13 N12 Port2 1.78e+01
.ENDS GCE219R72A821MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCE21BR71H104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H104KA01 Port1 Port2
C01 Port1 N01 9.47e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.31e-11
R03 N02 N03 3.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 6.64e-01
C05 N04 N05 7.34e-06
R05 N04 N05 3.23e-02
C06 N05 N06 1.08e-05
R06 N05 N06 6.06e-03
L07 N06 N07 1.16e-10
R07 N06 N07 1.19e-01
C08 N07 N08 3.38e-07
L08 N07 N08 4.53e-11
R08 N07 N08 6.19e-02
C09 N08 N09 1.45e-07
L09 N08 N09 4.77e-11
R09 N08 N09 6.47e-02
C10 N09 N10 2.53e-08
L10 N09 N10 7.04e-11
R10 N09 N10 4.48e-02
C11 N10 N11 4.79e-11
L11 N10 N11 2.04e-11
R11 N10 N11 3.81e+00
C12 N11 N12 8.34e-12
L12 N11 N12 7.18e-11
R12 N11 N12 6.61e+00
C13 N12 Port2 1.97e-12
L13 N12 Port2 1.69e-10
R13 N12 Port2 5.73e+01
.ENDS GCE21BR71H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCE21BR71H104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H104MA01 Port1 Port2
C01 Port1 N01 9.47e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.31e-11
R03 N02 N03 3.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 6.64e-01
C05 N04 N05 7.34e-06
R05 N04 N05 3.23e-02
C06 N05 N06 1.08e-05
R06 N05 N06 6.06e-03
L07 N06 N07 1.16e-10
R07 N06 N07 1.19e-01
C08 N07 N08 3.38e-07
L08 N07 N08 4.53e-11
R08 N07 N08 6.19e-02
C09 N08 N09 1.45e-07
L09 N08 N09 4.77e-11
R09 N08 N09 6.47e-02
C10 N09 N10 2.53e-08
L10 N09 N10 7.04e-11
R10 N09 N10 4.48e-02
C11 N10 N11 4.79e-11
L11 N10 N11 2.04e-11
R11 N10 N11 3.81e+00
C12 N11 N12 8.34e-12
L12 N11 N12 7.18e-11
R12 N11 N12 6.61e+00
C13 N12 Port2 1.97e-12
L13 N12 Port2 1.69e-10
R13 N12 Port2 5.73e+01
.ENDS GCE21BR71H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCE21BR71H153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H153KA01 Port1 Port2
C01 Port1 N01 1.44e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 8.09e-02
C04 N03 N04 5.79e-07
R04 N03 N04 1.18e+01
C05 N04 N05 1.03e-06
R05 N04 N05 6.41e-01
C06 N05 N06 7.36e-07
R06 N05 N06 1.13e-01
L07 N06 N07 3.06e-11
R07 N06 N07 1.04e-01
C08 N07 N08 7.32e-08
L08 N07 N08 1.40e-11
R08 N07 N08 3.21e-02
C09 N08 N09 7.11e-09
L09 N08 N09 4.17e-11
R09 N08 N09 9.80e-02
C10 N09 N10 1.09e-11
L10 N09 N10 2.04e-10
R10 N09 N10 1.60e+01
C11 N10 N11 4.54e-12
L11 N10 N11 1.98e-10
R11 N10 N11 1.48e+01
C12 N11 Port2 4.43e-12
L12 N11 Port2 7.10e-11
R12 N11 Port2 9.78e+00
.ENDS GCE21BR71H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCE21BR71H153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H153MA01 Port1 Port2
C01 Port1 N01 1.44e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 8.09e-02
C04 N03 N04 5.79e-07
R04 N03 N04 1.18e+01
C05 N04 N05 1.03e-06
R05 N04 N05 6.41e-01
C06 N05 N06 7.36e-07
R06 N05 N06 1.13e-01
L07 N06 N07 3.06e-11
R07 N06 N07 1.04e-01
C08 N07 N08 7.32e-08
L08 N07 N08 1.40e-11
R08 N07 N08 3.21e-02
C09 N08 N09 7.11e-09
L09 N08 N09 4.17e-11
R09 N08 N09 9.80e-02
C10 N09 N10 1.09e-11
L10 N09 N10 2.04e-10
R10 N09 N10 1.60e+01
C11 N10 N11 4.54e-12
L11 N10 N11 1.98e-10
R11 N10 N11 1.48e+01
C12 N11 Port2 4.43e-12
L12 N11 Port2 7.10e-11
R12 N11 Port2 9.78e+00
.ENDS GCE21BR71H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCE21BR71H183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H183KA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.93e-10
R03 N02 N03 3.75e-02
C04 N03 N04 8.13e-07
R04 N03 N04 7.54e+00
C05 N04 N05 1.37e-06
R05 N04 N05 4.46e-01
C06 N05 N06 1.01e-06
R06 N05 N06 7.20e-02
L07 N06 N07 8.58e-11
R07 N06 N07 1.05e-01
C08 N07 N08 1.74e-07
L08 N07 N08 8.15e-12
R08 N07 N08 2.43e-02
C09 N08 N09 2.43e-08
L09 N08 N09 2.09e-11
R09 N08 N09 5.99e-02
C10 N09 N10 9.88e-12
L10 N09 N10 1.84e-10
R10 N09 N10 1.73e+01
C11 N10 N11 5.21e-12
L11 N10 N11 1.48e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 6.82e-12
L12 N11 Port2 4.33e-11
R12 N11 Port2 7.75e+00
.ENDS GCE21BR71H183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCE21BR71H183MA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H183MA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.93e-10
R03 N02 N03 3.75e-02
C04 N03 N04 8.13e-07
R04 N03 N04 7.54e+00
C05 N04 N05 1.37e-06
R05 N04 N05 4.46e-01
C06 N05 N06 1.01e-06
R06 N05 N06 7.20e-02
L07 N06 N07 8.58e-11
R07 N06 N07 1.05e-01
C08 N07 N08 1.74e-07
L08 N07 N08 8.15e-12
R08 N07 N08 2.43e-02
C09 N08 N09 2.43e-08
L09 N08 N09 2.09e-11
R09 N08 N09 5.99e-02
C10 N09 N10 9.88e-12
L10 N09 N10 1.84e-10
R10 N09 N10 1.73e+01
C11 N10 N11 5.21e-12
L11 N10 N11 1.48e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 6.82e-12
L12 N11 Port2 4.33e-11
R12 N11 Port2 7.75e+00
.ENDS GCE21BR71H183MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCE21BR71H223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H223KA01 Port1 Port2
C01 Port1 N01 2.14e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.86e-12
R03 N02 N03 3.74e-02
C04 N03 N04 1.24e-06
R04 N03 N04 1.91e+00
C05 N04 N05 1.86e-06
R05 N04 N05 1.83e-01
C06 N05 N06 1.29e-06
R06 N05 N06 5.70e-02
L07 N06 N07 6.36e-11
R07 N06 N07 1.22e-01
C08 N07 N08 9.19e-08
L08 N07 N08 2.02e-11
R08 N07 N08 3.53e-02
C09 N08 N09 2.22e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.54e-02
C10 N09 N10 1.04e-11
L10 N09 N10 1.64e-10
R10 N09 N10 1.77e+01
C11 N10 N11 4.38e-12
L11 N10 N11 1.85e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 9.89e-13
L12 N11 Port2 2.03e-10
R12 N11 Port2 3.70e+01
.ENDS GCE21BR71H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCE21BR71H223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H223MA01 Port1 Port2
C01 Port1 N01 2.14e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.86e-12
R03 N02 N03 3.74e-02
C04 N03 N04 1.24e-06
R04 N03 N04 1.91e+00
C05 N04 N05 1.86e-06
R05 N04 N05 1.83e-01
C06 N05 N06 1.29e-06
R06 N05 N06 5.70e-02
L07 N06 N07 6.36e-11
R07 N06 N07 1.22e-01
C08 N07 N08 9.19e-08
L08 N07 N08 2.02e-11
R08 N07 N08 3.53e-02
C09 N08 N09 2.22e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.54e-02
C10 N09 N10 1.04e-11
L10 N09 N10 1.64e-10
R10 N09 N10 1.77e+01
C11 N10 N11 4.38e-12
L11 N10 N11 1.85e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 9.89e-13
L12 N11 Port2 2.03e-10
R12 N11 Port2 3.70e+01
.ENDS GCE21BR71H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCE21BR71H273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H273KA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 2.97e-02
C04 N03 N04 1.75e-06
R04 N03 N04 2.88e+00
C05 N04 N05 3.00e-06
R05 N04 N05 3.15e-01
C06 N05 N06 2.33e-06
R06 N05 N06 9.70e-02
C07 N06 N07 2.49e-06
R07 N06 N07 2.04e-02
L08 N07 N08 9.32e-11
R08 N07 N08 1.15e-01
C09 N08 N09 1.29e-07
L09 N08 N09 2.24e-11
R09 N08 N09 4.34e-02
C10 N09 N10 4.28e-08
L10 N09 N10 2.58e-11
R10 N09 N10 6.96e-02
C11 N10 N11 1.02e-11
L11 N10 N11 1.62e-10
R11 N10 N11 1.98e+01
C12 N11 Port2 2.38e-12
L12 N11 Port2 2.34e-10
R12 N11 Port2 2.38e+01
.ENDS GCE21BR71H273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCE21BR71H273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H273MA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 2.97e-02
C04 N03 N04 1.75e-06
R04 N03 N04 2.88e+00
C05 N04 N05 3.00e-06
R05 N04 N05 3.15e-01
C06 N05 N06 2.33e-06
R06 N05 N06 9.70e-02
C07 N06 N07 2.49e-06
R07 N06 N07 2.04e-02
L08 N07 N08 9.32e-11
R08 N07 N08 1.15e-01
C09 N08 N09 1.29e-07
L09 N08 N09 2.24e-11
R09 N08 N09 4.34e-02
C10 N09 N10 4.28e-08
L10 N09 N10 2.58e-11
R10 N09 N10 6.96e-02
C11 N10 N11 1.02e-11
L11 N10 N11 1.62e-10
R11 N10 N11 1.98e+01
C12 N11 Port2 2.38e-12
L12 N11 Port2 2.34e-10
R12 N11 Port2 2.38e+01
.ENDS GCE21BR71H273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCE21BR71H333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H333KA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.28e-11
R03 N02 N03 3.36e-02
C04 N03 N04 1.71e-06
R04 N03 N04 1.66e+00
C05 N04 N05 2.56e-06
R05 N04 N05 1.12e-01
C06 N05 N06 2.27e-06
R06 N05 N06 2.27e-02
L07 N06 N07 1.08e-10
R07 N06 N07 1.20e-01
C08 N07 N08 2.16e-07
L08 N07 N08 1.88e-11
R08 N07 N08 4.85e-02
C09 N08 N09 3.57e-08
L09 N08 N09 4.41e-11
R09 N08 N09 7.81e-02
C10 N09 N10 1.07e-11
L10 N09 N10 1.20e-10
R10 N09 N10 1.40e+01
C11 N10 N11 1.05e-11
L11 N10 N11 6.38e-11
R11 N10 N11 9.83e+00
C12 N11 Port2 2.19e-12
L12 N11 Port2 1.94e-10
R12 N11 Port2 2.57e+01
.ENDS GCE21BR71H333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCE21BR71H333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.28e-11
R03 N02 N03 3.36e-02
C04 N03 N04 1.71e-06
R04 N03 N04 1.66e+00
C05 N04 N05 2.56e-06
R05 N04 N05 1.12e-01
C06 N05 N06 2.27e-06
R06 N05 N06 2.27e-02
L07 N06 N07 1.08e-10
R07 N06 N07 1.20e-01
C08 N07 N08 2.16e-07
L08 N07 N08 1.88e-11
R08 N07 N08 4.85e-02
C09 N08 N09 3.57e-08
L09 N08 N09 4.41e-11
R09 N08 N09 7.81e-02
C10 N09 N10 1.07e-11
L10 N09 N10 1.20e-10
R10 N09 N10 1.40e+01
C11 N10 N11 1.05e-11
L11 N10 N11 6.38e-11
R11 N10 N11 9.83e+00
C12 N11 Port2 2.19e-12
L12 N11 Port2 1.94e-10
R12 N11 Port2 2.57e+01
.ENDS GCE21BR71H333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCE21BR71H393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H393KA01 Port1 Port2
C01 Port1 N01 3.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.23e-02
C04 N03 N04 1.83e-06
R04 N03 N04 3.85e+00
C05 N04 N05 3.28e-06
R05 N04 N05 2.28e-01
C06 N05 N06 2.46e-06
R06 N05 N06 4.04e-02
L07 N06 N07 1.19e-10
R07 N06 N07 1.23e-01
C08 N07 N08 1.38e-07
L08 N07 N08 3.60e-11
R08 N07 N08 6.03e-02
C09 N08 N09 5.36e-08
L09 N08 N09 3.78e-11
R09 N08 N09 8.17e-02
C10 N09 N10 1.17e-11
L10 N09 N10 9.68e-11
R10 N09 N10 1.26e+01
C11 N10 Port2 2.61e-12
L11 N10 Port2 2.05e-10
R11 N10 Port2 2.89e+01
.ENDS GCE21BR71H393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCE21BR71H393MA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H393MA01 Port1 Port2
C01 Port1 N01 3.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.23e-02
C04 N03 N04 1.83e-06
R04 N03 N04 3.85e+00
C05 N04 N05 3.28e-06
R05 N04 N05 2.28e-01
C06 N05 N06 2.46e-06
R06 N05 N06 4.04e-02
L07 N06 N07 1.19e-10
R07 N06 N07 1.23e-01
C08 N07 N08 1.38e-07
L08 N07 N08 3.60e-11
R08 N07 N08 6.03e-02
C09 N08 N09 5.36e-08
L09 N08 N09 3.78e-11
R09 N08 N09 8.17e-02
C10 N09 N10 1.17e-11
L10 N09 N10 9.68e-11
R10 N09 N10 1.26e+01
C11 N10 Port2 2.61e-12
L11 N10 Port2 2.05e-10
R11 N10 Port2 2.89e+01
.ENDS GCE21BR71H393MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCE21BR71H473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H473KA01 Port1 Port2
C01 Port1 N01 4.74e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.57e-11
R03 N02 N03 3.82e-02
C04 N03 N04 3.05e-06
R04 N03 N04 9.76e-01
C05 N04 N05 3.48e-06
R05 N04 N05 1.13e-01
C06 N05 N06 2.81e-06
R06 N05 N06 1.40e-02
L07 N06 N07 7.26e-11
R07 N06 N07 1.25e-01
C08 N07 N08 1.48e-07
L08 N07 N08 4.35e-11
R08 N07 N08 6.81e-02
C09 N08 N09 7.58e-08
L09 N08 N09 3.63e-11
R09 N08 N09 6.84e-02
C10 N09 N10 9.43e-09
L10 N09 N10 8.78e-11
R10 N09 N10 6.69e-02
C11 N10 N11 1.06e-11
L11 N10 N11 9.70e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.77e-12
L12 N11 Port2 1.99e-10
R12 N11 Port2 3.58e+01
.ENDS GCE21BR71H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCE21BR71H473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H473MA01 Port1 Port2
C01 Port1 N01 4.74e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.57e-11
R03 N02 N03 3.82e-02
C04 N03 N04 3.05e-06
R04 N03 N04 9.76e-01
C05 N04 N05 3.48e-06
R05 N04 N05 1.13e-01
C06 N05 N06 2.81e-06
R06 N05 N06 1.40e-02
L07 N06 N07 7.26e-11
R07 N06 N07 1.25e-01
C08 N07 N08 1.48e-07
L08 N07 N08 4.35e-11
R08 N07 N08 6.81e-02
C09 N08 N09 7.58e-08
L09 N08 N09 3.63e-11
R09 N08 N09 6.84e-02
C10 N09 N10 9.43e-09
L10 N09 N10 8.78e-11
R10 N09 N10 6.69e-02
C11 N10 N11 1.06e-11
L11 N10 N11 9.70e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.77e-12
L12 N11 Port2 1.99e-10
R12 N11 Port2 3.58e+01
.ENDS GCE21BR71H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCE21BR71H563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H563KA01 Port1 Port2
C01 Port1 N01 5.59e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.84e-10
R03 N02 N03 2.06e-02
C04 N03 N04 2.47e-06
R04 N03 N04 2.57e+00
C05 N04 N05 4.40e-06
R05 N04 N05 1.35e-01
C06 N05 N06 4.38e-06
R06 N05 N06 2.36e-02
L07 N06 N07 1.12e-10
R07 N06 N07 9.20e-02
C08 N07 N08 2.93e-07
L08 N07 N08 2.20e-11
R08 N07 N08 3.79e-02
C09 N08 N09 6.95e-08
L09 N08 N09 3.92e-11
R09 N08 N09 6.64e-02
C10 N09 N10 1.09e-11
L10 N09 N10 1.29e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 3.27e-12
L11 N10 Port2 1.69e-10
R11 N10 Port2 1.93e+01
.ENDS GCE21BR71H563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCE21BR71H563MA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H563MA01 Port1 Port2
C01 Port1 N01 5.59e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.84e-10
R03 N02 N03 2.06e-02
C04 N03 N04 2.47e-06
R04 N03 N04 2.57e+00
C05 N04 N05 4.40e-06
R05 N04 N05 1.35e-01
C06 N05 N06 4.38e-06
R06 N05 N06 2.36e-02
L07 N06 N07 1.12e-10
R07 N06 N07 9.20e-02
C08 N07 N08 2.93e-07
L08 N07 N08 2.20e-11
R08 N07 N08 3.79e-02
C09 N08 N09 6.95e-08
L09 N08 N09 3.92e-11
R09 N08 N09 6.64e-02
C10 N09 N10 1.09e-11
L10 N09 N10 1.29e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 3.27e-12
L11 N10 Port2 1.69e-10
R11 N10 Port2 1.93e+01
.ENDS GCE21BR71H563MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCE21BR71H683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H683KA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.16e-10
R03 N02 N03 1.97e-02
C04 N03 N04 4.30e-06
R04 N03 N04 1.54e+00
C05 N04 N05 6.97e-06
R05 N04 N05 1.55e-01
C06 N05 N06 6.68e-06
R06 N05 N06 3.25e-02
C07 N06 N07 8.99e-06
R07 N06 N07 1.07e-02
L08 N07 N08 8.09e-11
R08 N07 N08 6.65e-02
C09 N08 N09 2.97e-07
L09 N08 N09 2.84e-11
R09 N08 N09 4.18e-02
C10 N09 N10 9.59e-08
L10 N09 N10 3.64e-11
R10 N09 N10 5.80e-02
C11 N10 N11 3.31e-08
L11 N10 N11 2.91e-11
R11 N10 N11 3.29e-02
C12 N11 N12 9.74e-12
L12 N11 N12 1.32e-10
R12 N11 N12 1.30e+01
C13 N12 Port2 2.05e-12
L13 N12 Port2 1.88e-10
R13 N12 Port2 2.77e+01
.ENDS GCE21BR71H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCE21BR71H683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.16e-10
R03 N02 N03 1.97e-02
C04 N03 N04 4.30e-06
R04 N03 N04 1.54e+00
C05 N04 N05 6.97e-06
R05 N04 N05 1.55e-01
C06 N05 N06 6.68e-06
R06 N05 N06 3.25e-02
C07 N06 N07 8.99e-06
R07 N06 N07 1.07e-02
L08 N07 N08 8.09e-11
R08 N07 N08 6.65e-02
C09 N08 N09 2.97e-07
L09 N08 N09 2.84e-11
R09 N08 N09 4.18e-02
C10 N09 N10 9.59e-08
L10 N09 N10 3.64e-11
R10 N09 N10 5.80e-02
C11 N10 N11 3.31e-08
L11 N10 N11 2.91e-11
R11 N10 N11 3.29e-02
C12 N11 N12 9.74e-12
L12 N11 N12 1.32e-10
R12 N11 N12 1.30e+01
C13 N12 Port2 2.05e-12
L13 N12 Port2 1.88e-10
R13 N12 Port2 2.77e+01
.ENDS GCE21BR71H683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCE21BR71H823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 7.22e-11
R03 N02 N03 1.71e-02
C04 N03 N04 4.46e-06
R04 N03 N04 8.42e-01
C05 N04 N05 7.92e-06
R05 N04 N05 5.89e-02
C06 N05 N06 7.39e-06
R06 N05 N06 1.67e-02
L07 N06 N07 8.83e-11
R07 N06 N07 1.12e-01
C08 N07 N08 2.59e-07
L08 N07 N08 4.63e-11
R08 N07 N08 5.44e-02
C09 N08 N09 1.27e-07
L09 N08 N09 4.20e-11
R09 N08 N09 6.41e-02
C10 N09 N10 3.60e-08
L10 N09 N10 4.94e-11
R10 N09 N10 4.30e-02
C11 N10 N11 1.10e-11
L11 N10 N11 9.74e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.52e-12
L12 N11 Port2 2.12e-10
R12 N11 Port2 3.28e+01
.ENDS GCE21BR71H823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCE21BR71H823MA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H823MA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 7.22e-11
R03 N02 N03 1.71e-02
C04 N03 N04 4.46e-06
R04 N03 N04 8.42e-01
C05 N04 N05 7.92e-06
R05 N04 N05 5.89e-02
C06 N05 N06 7.39e-06
R06 N05 N06 1.67e-02
L07 N06 N07 8.83e-11
R07 N06 N07 1.12e-01
C08 N07 N08 2.59e-07
L08 N07 N08 4.63e-11
R08 N07 N08 5.44e-02
C09 N08 N09 1.27e-07
L09 N08 N09 4.20e-11
R09 N08 N09 6.41e-02
C10 N09 N10 3.60e-08
L10 N09 N10 4.94e-11
R10 N09 N10 4.30e-02
C11 N10 N11 1.10e-11
L11 N10 N11 9.74e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.52e-12
L12 N11 Port2 2.12e-10
R12 N11 Port2 3.28e+01
.ENDS GCE21BR71H823MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE21BR72A103KA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A103KA01 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.76e-11
R03 N02 N03 8.37e-02
C04 N03 N04 5.38e-07
R04 N03 N04 4.25e+00
C05 N04 N05 7.40e-07
R05 N04 N05 3.27e-01
C06 N05 N06 5.10e-07
R06 N05 N06 6.10e-02
L07 N06 N07 5.98e-11
R07 N06 N07 1.37e-01
C08 N07 N08 5.75e-08
L08 N07 N08 1.88e-11
R08 N07 N08 7.58e-02
C09 N08 N09 9.85e-09
L09 N08 N09 4.11e-11
R09 N08 N09 1.12e-01
C10 N09 N10 2.92e-11
L10 N09 N10 1.77e-10
R10 N09 N10 3.20e+00
C11 N10 Port2 1.68e-12
L11 N10 Port2 2.46e-10
R11 N10 Port2 3.24e+01
.ENDS GCE21BR72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE21BR72A103MA01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A103MA01 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.76e-11
R03 N02 N03 8.37e-02
C04 N03 N04 5.38e-07
R04 N03 N04 4.25e+00
C05 N04 N05 7.40e-07
R05 N04 N05 3.27e-01
C06 N05 N06 5.10e-07
R06 N05 N06 6.10e-02
L07 N06 N07 5.98e-11
R07 N06 N07 1.37e-01
C08 N07 N08 5.75e-08
L08 N07 N08 1.88e-11
R08 N07 N08 7.58e-02
C09 N08 N09 9.85e-09
L09 N08 N09 4.11e-11
R09 N08 N09 1.12e-01
C10 N09 N10 2.92e-11
L10 N09 N10 1.77e-10
R10 N09 N10 3.20e+00
C11 N10 Port2 1.68e-12
L11 N10 Port2 2.46e-10
R11 N10 Port2 3.24e+01
.ENDS GCE21BR72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCE21BR72A104KA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A104KA01 Port1 Port2
C01 Port1 N01 9.47e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.31e-11
R03 N02 N03 3.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 6.64e-01
C05 N04 N05 7.34e-06
R05 N04 N05 3.23e-02
C06 N05 N06 1.08e-05
R06 N05 N06 6.06e-03
L07 N06 N07 1.16e-10
R07 N06 N07 1.19e-01
C08 N07 N08 3.38e-07
L08 N07 N08 4.53e-11
R08 N07 N08 6.19e-02
C09 N08 N09 1.45e-07
L09 N08 N09 4.77e-11
R09 N08 N09 6.47e-02
C10 N09 N10 2.53e-08
L10 N09 N10 7.04e-11
R10 N09 N10 4.48e-02
C11 N10 N11 4.79e-11
L11 N10 N11 2.04e-11
R11 N10 N11 3.81e+00
C12 N11 N12 8.34e-12
L12 N11 N12 7.18e-11
R12 N11 N12 6.61e+00
C13 N12 Port2 1.97e-12
L13 N12 Port2 1.69e-10
R13 N12 Port2 5.73e+01
.ENDS GCE21BR72A104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCE21BR72A104MA01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A104MA01 Port1 Port2
C01 Port1 N01 9.47e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.31e-11
R03 N02 N03 3.16e-02
C04 N03 N04 4.74e-06
R04 N03 N04 6.64e-01
C05 N04 N05 7.34e-06
R05 N04 N05 3.23e-02
C06 N05 N06 1.08e-05
R06 N05 N06 6.06e-03
L07 N06 N07 1.16e-10
R07 N06 N07 1.19e-01
C08 N07 N08 3.38e-07
L08 N07 N08 4.53e-11
R08 N07 N08 6.19e-02
C09 N08 N09 1.45e-07
L09 N08 N09 4.77e-11
R09 N08 N09 6.47e-02
C10 N09 N10 2.53e-08
L10 N09 N10 7.04e-11
R10 N09 N10 4.48e-02
C11 N10 N11 4.79e-11
L11 N10 N11 2.04e-11
R11 N10 N11 3.81e+00
C12 N11 N12 8.34e-12
L12 N11 N12 7.18e-11
R12 N11 N12 6.61e+00
C13 N12 Port2 1.97e-12
L13 N12 Port2 1.69e-10
R13 N12 Port2 5.73e+01
.ENDS GCE21BR72A104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A123KA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A123KA01 Port1 Port2
C01 Port1 N01 1.25e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 5.56e-02
C04 N03 N04 5.67e-07
R04 N03 N04 5.51e+00
C05 N04 N05 1.25e-06
R05 N04 N05 2.29e-01
C06 N05 N06 1.22e-06
R06 N05 N06 4.55e-02
C07 N06 N07 7.35e-07
R07 N06 N07 2.60e-02
L08 N07 N08 1.30e-10
R08 N07 N08 2.42e-01
C09 N08 N09 3.92e-08
L09 N08 N09 3.98e-11
R09 N08 N09 1.07e-01
C10 N09 N10 2.13e-08
L10 N09 N10 2.62e-11
R10 N09 N10 9.63e-02
C11 N10 N11 1.11e-11
L11 N10 N11 7.12e-11
R11 N10 N11 1.07e+01
C12 N11 Port2 1.69e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 3.97e+01
.ENDS GCE21BR72A123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A123MA01
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A123MA01 Port1 Port2
C01 Port1 N01 1.25e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 5.56e-02
C04 N03 N04 5.67e-07
R04 N03 N04 5.51e+00
C05 N04 N05 1.25e-06
R05 N04 N05 2.29e-01
C06 N05 N06 1.22e-06
R06 N05 N06 4.55e-02
C07 N06 N07 7.35e-07
R07 N06 N07 2.60e-02
L08 N07 N08 1.30e-10
R08 N07 N08 2.42e-01
C09 N08 N09 3.92e-08
L09 N08 N09 3.98e-11
R09 N08 N09 1.07e-01
C10 N09 N10 2.13e-08
L10 N09 N10 2.62e-11
R10 N09 N10 9.63e-02
C11 N10 N11 1.11e-11
L11 N10 N11 7.12e-11
R11 N10 N11 1.07e+01
C12 N11 Port2 1.69e-12
L12 N11 Port2 1.62e-10
R12 N11 Port2 3.97e+01
.ENDS GCE21BR72A123MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCE21BR72A153KA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A153KA01 Port1 Port2
C01 Port1 N01 1.44e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 8.09e-02
C04 N03 N04 5.79e-07
R04 N03 N04 1.18e+01
C05 N04 N05 1.03e-06
R05 N04 N05 6.41e-01
C06 N05 N06 7.36e-07
R06 N05 N06 1.13e-01
L07 N06 N07 3.06e-11
R07 N06 N07 1.04e-01
C08 N07 N08 7.32e-08
L08 N07 N08 1.40e-11
R08 N07 N08 3.21e-02
C09 N08 N09 7.11e-09
L09 N08 N09 4.17e-11
R09 N08 N09 9.80e-02
C10 N09 N10 1.09e-11
L10 N09 N10 2.04e-10
R10 N09 N10 1.60e+01
C11 N10 N11 4.54e-12
L11 N10 N11 1.98e-10
R11 N10 N11 1.48e+01
C12 N11 Port2 4.43e-12
L12 N11 Port2 7.10e-11
R12 N11 Port2 9.78e+00
.ENDS GCE21BR72A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCE21BR72A153MA01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A153MA01 Port1 Port2
C01 Port1 N01 1.44e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 8.09e-02
C04 N03 N04 5.79e-07
R04 N03 N04 1.18e+01
C05 N04 N05 1.03e-06
R05 N04 N05 6.41e-01
C06 N05 N06 7.36e-07
R06 N05 N06 1.13e-01
L07 N06 N07 3.06e-11
R07 N06 N07 1.04e-01
C08 N07 N08 7.32e-08
L08 N07 N08 1.40e-11
R08 N07 N08 3.21e-02
C09 N08 N09 7.11e-09
L09 N08 N09 4.17e-11
R09 N08 N09 9.80e-02
C10 N09 N10 1.09e-11
L10 N09 N10 2.04e-10
R10 N09 N10 1.60e+01
C11 N10 N11 4.54e-12
L11 N10 N11 1.98e-10
R11 N10 N11 1.48e+01
C12 N11 Port2 4.43e-12
L12 N11 Port2 7.10e-11
R12 N11 Port2 9.78e+00
.ENDS GCE21BR72A153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCE21BR72A183KA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A183KA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.93e-10
R03 N02 N03 3.75e-02
C04 N03 N04 8.13e-07
R04 N03 N04 7.54e+00
C05 N04 N05 1.37e-06
R05 N04 N05 4.46e-01
C06 N05 N06 1.01e-06
R06 N05 N06 7.20e-02
L07 N06 N07 8.58e-11
R07 N06 N07 1.05e-01
C08 N07 N08 1.74e-07
L08 N07 N08 8.15e-12
R08 N07 N08 2.43e-02
C09 N08 N09 2.43e-08
L09 N08 N09 2.09e-11
R09 N08 N09 5.99e-02
C10 N09 N10 9.88e-12
L10 N09 N10 1.84e-10
R10 N09 N10 1.73e+01
C11 N10 N11 5.21e-12
L11 N10 N11 1.48e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 6.82e-12
L12 N11 Port2 4.33e-11
R12 N11 Port2 7.75e+00
.ENDS GCE21BR72A183KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCE21BR72A183MA01
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A183MA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.93e-10
R03 N02 N03 3.75e-02
C04 N03 N04 8.13e-07
R04 N03 N04 7.54e+00
C05 N04 N05 1.37e-06
R05 N04 N05 4.46e-01
C06 N05 N06 1.01e-06
R06 N05 N06 7.20e-02
L07 N06 N07 8.58e-11
R07 N06 N07 1.05e-01
C08 N07 N08 1.74e-07
L08 N07 N08 8.15e-12
R08 N07 N08 2.43e-02
C09 N08 N09 2.43e-08
L09 N08 N09 2.09e-11
R09 N08 N09 5.99e-02
C10 N09 N10 9.88e-12
L10 N09 N10 1.84e-10
R10 N09 N10 1.73e+01
C11 N10 N11 5.21e-12
L11 N10 N11 1.48e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 6.82e-12
L12 N11 Port2 4.33e-11
R12 N11 Port2 7.75e+00
.ENDS GCE21BR72A183MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A223KA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A223KA01 Port1 Port2
C01 Port1 N01 2.14e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.86e-12
R03 N02 N03 3.74e-02
C04 N03 N04 1.24e-06
R04 N03 N04 1.91e+00
C05 N04 N05 1.86e-06
R05 N04 N05 1.83e-01
C06 N05 N06 1.29e-06
R06 N05 N06 5.70e-02
L07 N06 N07 6.36e-11
R07 N06 N07 1.22e-01
C08 N07 N08 9.19e-08
L08 N07 N08 2.02e-11
R08 N07 N08 3.53e-02
C09 N08 N09 2.22e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.54e-02
C10 N09 N10 1.04e-11
L10 N09 N10 1.64e-10
R10 N09 N10 1.77e+01
C11 N10 N11 4.38e-12
L11 N10 N11 1.85e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 9.89e-13
L12 N11 Port2 2.03e-10
R12 N11 Port2 3.70e+01
.ENDS GCE21BR72A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A223MA01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A223MA01 Port1 Port2
C01 Port1 N01 2.14e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.86e-12
R03 N02 N03 3.74e-02
C04 N03 N04 1.24e-06
R04 N03 N04 1.91e+00
C05 N04 N05 1.86e-06
R05 N04 N05 1.83e-01
C06 N05 N06 1.29e-06
R06 N05 N06 5.70e-02
L07 N06 N07 6.36e-11
R07 N06 N07 1.22e-01
C08 N07 N08 9.19e-08
L08 N07 N08 2.02e-11
R08 N07 N08 3.53e-02
C09 N08 N09 2.22e-08
L09 N08 N09 3.25e-11
R09 N08 N09 9.54e-02
C10 N09 N10 1.04e-11
L10 N09 N10 1.64e-10
R10 N09 N10 1.77e+01
C11 N10 N11 4.38e-12
L11 N10 N11 1.85e-10
R11 N10 N11 1.53e+01
C12 N11 Port2 9.89e-13
L12 N11 Port2 2.03e-10
R12 N11 Port2 3.70e+01
.ENDS GCE21BR72A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCE21BR72A273KA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A273KA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 2.97e-02
C04 N03 N04 1.75e-06
R04 N03 N04 2.88e+00
C05 N04 N05 3.00e-06
R05 N04 N05 3.15e-01
C06 N05 N06 2.33e-06
R06 N05 N06 9.70e-02
C07 N06 N07 2.49e-06
R07 N06 N07 2.04e-02
L08 N07 N08 9.32e-11
R08 N07 N08 1.15e-01
C09 N08 N09 1.29e-07
L09 N08 N09 2.24e-11
R09 N08 N09 4.34e-02
C10 N09 N10 4.28e-08
L10 N09 N10 2.58e-11
R10 N09 N10 6.96e-02
C11 N10 N11 1.02e-11
L11 N10 N11 1.62e-10
R11 N10 N11 1.98e+01
C12 N11 Port2 2.38e-12
L12 N11 Port2 2.34e-10
R12 N11 Port2 2.38e+01
.ENDS GCE21BR72A273KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCE21BR72A273MA01
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A273MA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 2.97e-02
C04 N03 N04 1.75e-06
R04 N03 N04 2.88e+00
C05 N04 N05 3.00e-06
R05 N04 N05 3.15e-01
C06 N05 N06 2.33e-06
R06 N05 N06 9.70e-02
C07 N06 N07 2.49e-06
R07 N06 N07 2.04e-02
L08 N07 N08 9.32e-11
R08 N07 N08 1.15e-01
C09 N08 N09 1.29e-07
L09 N08 N09 2.24e-11
R09 N08 N09 4.34e-02
C10 N09 N10 4.28e-08
L10 N09 N10 2.58e-11
R10 N09 N10 6.96e-02
C11 N10 N11 1.02e-11
L11 N10 N11 1.62e-10
R11 N10 N11 1.98e+01
C12 N11 Port2 2.38e-12
L12 N11 Port2 2.34e-10
R12 N11 Port2 2.38e+01
.ENDS GCE21BR72A273MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCE21BR72A333KA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A333KA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.28e-11
R03 N02 N03 3.36e-02
C04 N03 N04 1.71e-06
R04 N03 N04 1.66e+00
C05 N04 N05 2.56e-06
R05 N04 N05 1.12e-01
C06 N05 N06 2.27e-06
R06 N05 N06 2.27e-02
L07 N06 N07 1.08e-10
R07 N06 N07 1.20e-01
C08 N07 N08 2.16e-07
L08 N07 N08 1.88e-11
R08 N07 N08 4.85e-02
C09 N08 N09 3.57e-08
L09 N08 N09 4.41e-11
R09 N08 N09 7.81e-02
C10 N09 N10 1.07e-11
L10 N09 N10 1.20e-10
R10 N09 N10 1.40e+01
C11 N10 N11 1.05e-11
L11 N10 N11 6.38e-11
R11 N10 N11 9.83e+00
C12 N11 Port2 2.19e-12
L12 N11 Port2 1.94e-10
R12 N11 Port2 2.57e+01
.ENDS GCE21BR72A333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCE21BR72A333MA01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.28e-11
R03 N02 N03 3.36e-02
C04 N03 N04 1.71e-06
R04 N03 N04 1.66e+00
C05 N04 N05 2.56e-06
R05 N04 N05 1.12e-01
C06 N05 N06 2.27e-06
R06 N05 N06 2.27e-02
L07 N06 N07 1.08e-10
R07 N06 N07 1.20e-01
C08 N07 N08 2.16e-07
L08 N07 N08 1.88e-11
R08 N07 N08 4.85e-02
C09 N08 N09 3.57e-08
L09 N08 N09 4.41e-11
R09 N08 N09 7.81e-02
C10 N09 N10 1.07e-11
L10 N09 N10 1.20e-10
R10 N09 N10 1.40e+01
C11 N10 N11 1.05e-11
L11 N10 N11 6.38e-11
R11 N10 N11 9.83e+00
C12 N11 Port2 2.19e-12
L12 N11 Port2 1.94e-10
R12 N11 Port2 2.57e+01
.ENDS GCE21BR72A333MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCE21BR72A393KA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A393KA01 Port1 Port2
C01 Port1 N01 3.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.23e-02
C04 N03 N04 1.83e-06
R04 N03 N04 3.85e+00
C05 N04 N05 3.28e-06
R05 N04 N05 2.28e-01
C06 N05 N06 2.46e-06
R06 N05 N06 4.04e-02
L07 N06 N07 1.19e-10
R07 N06 N07 1.23e-01
C08 N07 N08 1.38e-07
L08 N07 N08 3.60e-11
R08 N07 N08 6.03e-02
C09 N08 N09 5.36e-08
L09 N08 N09 3.78e-11
R09 N08 N09 8.17e-02
C10 N09 N10 1.17e-11
L10 N09 N10 9.68e-11
R10 N09 N10 1.26e+01
C11 N10 Port2 2.61e-12
L11 N10 Port2 2.05e-10
R11 N10 Port2 2.89e+01
.ENDS GCE21BR72A393KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCE21BR72A393MA01
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A393MA01 Port1 Port2
C01 Port1 N01 3.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 2.23e-02
C04 N03 N04 1.83e-06
R04 N03 N04 3.85e+00
C05 N04 N05 3.28e-06
R05 N04 N05 2.28e-01
C06 N05 N06 2.46e-06
R06 N05 N06 4.04e-02
L07 N06 N07 1.19e-10
R07 N06 N07 1.23e-01
C08 N07 N08 1.38e-07
L08 N07 N08 3.60e-11
R08 N07 N08 6.03e-02
C09 N08 N09 5.36e-08
L09 N08 N09 3.78e-11
R09 N08 N09 8.17e-02
C10 N09 N10 1.17e-11
L10 N09 N10 9.68e-11
R10 N09 N10 1.26e+01
C11 N10 Port2 2.61e-12
L11 N10 Port2 2.05e-10
R11 N10 Port2 2.89e+01
.ENDS GCE21BR72A393MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCE21BR72A473KA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A473KA01 Port1 Port2
C01 Port1 N01 4.74e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.57e-11
R03 N02 N03 3.82e-02
C04 N03 N04 3.05e-06
R04 N03 N04 9.76e-01
C05 N04 N05 3.48e-06
R05 N04 N05 1.13e-01
C06 N05 N06 2.81e-06
R06 N05 N06 1.40e-02
L07 N06 N07 7.26e-11
R07 N06 N07 1.25e-01
C08 N07 N08 1.48e-07
L08 N07 N08 4.35e-11
R08 N07 N08 6.81e-02
C09 N08 N09 7.58e-08
L09 N08 N09 3.63e-11
R09 N08 N09 6.84e-02
C10 N09 N10 9.43e-09
L10 N09 N10 8.78e-11
R10 N09 N10 6.69e-02
C11 N10 N11 1.06e-11
L11 N10 N11 9.70e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.77e-12
L12 N11 Port2 1.99e-10
R12 N11 Port2 3.58e+01
.ENDS GCE21BR72A473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCE21BR72A473MA01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A473MA01 Port1 Port2
C01 Port1 N01 4.74e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.57e-11
R03 N02 N03 3.82e-02
C04 N03 N04 3.05e-06
R04 N03 N04 9.76e-01
C05 N04 N05 3.48e-06
R05 N04 N05 1.13e-01
C06 N05 N06 2.81e-06
R06 N05 N06 1.40e-02
L07 N06 N07 7.26e-11
R07 N06 N07 1.25e-01
C08 N07 N08 1.48e-07
L08 N07 N08 4.35e-11
R08 N07 N08 6.81e-02
C09 N08 N09 7.58e-08
L09 N08 N09 3.63e-11
R09 N08 N09 6.84e-02
C10 N09 N10 9.43e-09
L10 N09 N10 8.78e-11
R10 N09 N10 6.69e-02
C11 N10 N11 1.06e-11
L11 N10 N11 9.70e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.77e-12
L12 N11 Port2 1.99e-10
R12 N11 Port2 3.58e+01
.ENDS GCE21BR72A473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/100[V]
* Murata P/N :GCE21BR72A563KA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A563KA01 Port1 Port2
C01 Port1 N01 5.59e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.84e-10
R03 N02 N03 2.06e-02
C04 N03 N04 2.47e-06
R04 N03 N04 2.57e+00
C05 N04 N05 4.40e-06
R05 N04 N05 1.35e-01
C06 N05 N06 4.38e-06
R06 N05 N06 2.36e-02
L07 N06 N07 1.12e-10
R07 N06 N07 9.20e-02
C08 N07 N08 2.93e-07
L08 N07 N08 2.20e-11
R08 N07 N08 3.79e-02
C09 N08 N09 6.95e-08
L09 N08 N09 3.92e-11
R09 N08 N09 6.64e-02
C10 N09 N10 1.09e-11
L10 N09 N10 1.29e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 3.27e-12
L11 N10 Port2 1.69e-10
R11 N10 Port2 1.93e+01
.ENDS GCE21BR72A563KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/100[V]
* Murata P/N :GCE21BR72A563MA01
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A563MA01 Port1 Port2
C01 Port1 N01 5.59e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.84e-10
R03 N02 N03 2.06e-02
C04 N03 N04 2.47e-06
R04 N03 N04 2.57e+00
C05 N04 N05 4.40e-06
R05 N04 N05 1.35e-01
C06 N05 N06 4.38e-06
R06 N05 N06 2.36e-02
L07 N06 N07 1.12e-10
R07 N06 N07 9.20e-02
C08 N07 N08 2.93e-07
L08 N07 N08 2.20e-11
R08 N07 N08 3.79e-02
C09 N08 N09 6.95e-08
L09 N08 N09 3.92e-11
R09 N08 N09 6.64e-02
C10 N09 N10 1.09e-11
L10 N09 N10 1.29e-10
R10 N09 N10 1.46e+01
C11 N10 Port2 3.27e-12
L11 N10 Port2 1.69e-10
R11 N10 Port2 1.93e+01
.ENDS GCE21BR72A563MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCE21BR72A683KA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A683KA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.16e-10
R03 N02 N03 1.97e-02
C04 N03 N04 4.30e-06
R04 N03 N04 1.54e+00
C05 N04 N05 6.97e-06
R05 N04 N05 1.55e-01
C06 N05 N06 6.68e-06
R06 N05 N06 3.25e-02
C07 N06 N07 8.99e-06
R07 N06 N07 1.07e-02
L08 N07 N08 8.09e-11
R08 N07 N08 6.65e-02
C09 N08 N09 2.97e-07
L09 N08 N09 2.84e-11
R09 N08 N09 4.18e-02
C10 N09 N10 9.59e-08
L10 N09 N10 3.64e-11
R10 N09 N10 5.80e-02
C11 N10 N11 3.31e-08
L11 N10 N11 2.91e-11
R11 N10 N11 3.29e-02
C12 N11 N12 9.74e-12
L12 N11 N12 1.32e-10
R12 N11 N12 1.30e+01
C13 N12 Port2 2.05e-12
L13 N12 Port2 1.88e-10
R13 N12 Port2 2.77e+01
.ENDS GCE21BR72A683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCE21BR72A683MA01
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.16e-10
R03 N02 N03 1.97e-02
C04 N03 N04 4.30e-06
R04 N03 N04 1.54e+00
C05 N04 N05 6.97e-06
R05 N04 N05 1.55e-01
C06 N05 N06 6.68e-06
R06 N05 N06 3.25e-02
C07 N06 N07 8.99e-06
R07 N06 N07 1.07e-02
L08 N07 N08 8.09e-11
R08 N07 N08 6.65e-02
C09 N08 N09 2.97e-07
L09 N08 N09 2.84e-11
R09 N08 N09 4.18e-02
C10 N09 N10 9.59e-08
L10 N09 N10 3.64e-11
R10 N09 N10 5.80e-02
C11 N10 N11 3.31e-08
L11 N10 N11 2.91e-11
R11 N10 N11 3.29e-02
C12 N11 N12 9.74e-12
L12 N11 N12 1.32e-10
R12 N11 N12 1.30e+01
C13 N12 Port2 2.05e-12
L13 N12 Port2 1.88e-10
R13 N12 Port2 2.77e+01
.ENDS GCE21BR72A683MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCE21BR72A822KA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A822KA01 Port1 Port2
C01 Port1 N01 8.32e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.74e-11
R03 N02 N03 6.75e-02
C04 N03 N04 2.78e-07
R04 N03 N04 1.56e+01
C05 N04 N05 5.83e-07
R05 N04 N05 4.88e-01
C06 N05 N06 5.15e-07
R06 N05 N06 6.55e-02
C07 N06 N07 7.86e-07
R07 N06 N07 1.82e-02
L08 N07 N08 6.90e-11
R08 N07 N08 2.09e-01
C09 N08 N09 2.60e-08
L09 N08 N09 4.34e-11
R09 N08 N09 1.51e-01
C10 N09 N10 1.24e-08
L10 N09 N10 3.02e-11
R10 N09 N10 1.17e-01
C11 N10 N11 4.20e-09
L11 N10 N11 2.60e-11
R11 N10 N11 7.41e-02
C12 N11 N12 8.52e-12
L12 N11 N12 8.93e-11
R12 N11 N12 1.56e+01
C13 N12 Port2 1.71e-12
L13 N12 Port2 2.13e-10
R13 N12 Port2 3.78e+01
.ENDS GCE21BR72A822KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCE21BR72A822MA01
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A822MA01 Port1 Port2
C01 Port1 N01 8.32e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.74e-11
R03 N02 N03 6.75e-02
C04 N03 N04 2.78e-07
R04 N03 N04 1.56e+01
C05 N04 N05 5.83e-07
R05 N04 N05 4.88e-01
C06 N05 N06 5.15e-07
R06 N05 N06 6.55e-02
C07 N06 N07 7.86e-07
R07 N06 N07 1.82e-02
L08 N07 N08 6.90e-11
R08 N07 N08 2.09e-01
C09 N08 N09 2.60e-08
L09 N08 N09 4.34e-11
R09 N08 N09 1.51e-01
C10 N09 N10 1.24e-08
L10 N09 N10 3.02e-11
R10 N09 N10 1.17e-01
C11 N10 N11 4.20e-09
L11 N10 N11 2.60e-11
R11 N10 N11 7.41e-02
C12 N11 N12 8.52e-12
L12 N11 N12 8.93e-11
R12 N11 N12 1.56e+01
C13 N12 Port2 1.71e-12
L13 N12 Port2 2.13e-10
R13 N12 Port2 3.78e+01
.ENDS GCE21BR72A822MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A823KA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 7.22e-11
R03 N02 N03 1.71e-02
C04 N03 N04 4.46e-06
R04 N03 N04 8.42e-01
C05 N04 N05 7.92e-06
R05 N04 N05 5.89e-02
C06 N05 N06 7.39e-06
R06 N05 N06 1.67e-02
L07 N06 N07 8.83e-11
R07 N06 N07 1.12e-01
C08 N07 N08 2.59e-07
L08 N07 N08 4.63e-11
R08 N07 N08 5.44e-02
C09 N08 N09 1.27e-07
L09 N08 N09 4.20e-11
R09 N08 N09 6.41e-02
C10 N09 N10 3.60e-08
L10 N09 N10 4.94e-11
R10 N09 N10 4.30e-02
C11 N10 N11 1.10e-11
L11 N10 N11 9.74e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.52e-12
L12 N11 Port2 2.12e-10
R12 N11 Port2 3.28e+01
.ENDS GCE21BR72A823KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A823MA01
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A823MA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 7.22e-11
R03 N02 N03 1.71e-02
C04 N03 N04 4.46e-06
R04 N03 N04 8.42e-01
C05 N04 N05 7.92e-06
R05 N04 N05 5.89e-02
C06 N05 N06 7.39e-06
R06 N05 N06 1.67e-02
L07 N06 N07 8.83e-11
R07 N06 N07 1.12e-01
C08 N07 N08 2.59e-07
L08 N07 N08 4.63e-11
R08 N07 N08 5.44e-02
C09 N08 N09 1.27e-07
L09 N08 N09 4.20e-11
R09 N08 N09 6.41e-02
C10 N09 N10 3.60e-08
L10 N09 N10 4.94e-11
R10 N09 N10 4.30e-02
C11 N10 N11 1.10e-11
L11 N10 N11 9.74e-11
R11 N10 N11 1.15e+01
C12 N11 Port2 1.52e-12
L12 N11 Port2 2.12e-10
R12 N11 Port2 3.28e+01
.ENDS GCE21BR72A823MA01
