*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N6B02 port1 port2
C1 port1 port2 3.21e-15
L2 port1 1 7.57e-10
R2 1 port2 1.18e-2
R3 port1 port2 6.82e+3
L4 port1 2 2.81e-6
R4 2 port2 1.53e+4
L5 port1 3 1.56e-8
R5 3 port2 20.9
L6 port1 4 4.69e-10
R6 4 port2 1.09e-2
L7 port1 5 2.26e-8
C7 5 6 5.17e-15
R7 6 port2 77.3
.ENDS LQP03TQ0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N6C02 port1 port2
C1 port1 port2 3.21e-15
L2 port1 1 7.57e-10
R2 1 port2 1.18e-2
R3 port1 port2 6.82e+3
L4 port1 2 2.81e-6
R4 2 port2 1.53e+4
L5 port1 3 1.56e-8
R5 3 port2 20.9
L6 port1 4 4.69e-10
R6 4 port2 1.09e-2
L7 port1 5 2.26e-8
C7 5 6 5.17e-15
R7 6 port2 77.3
.ENDS LQP03TQ0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N6W02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N6W02 port1 port2
C1 port1 port2 3.21e-15
L2 port1 1 7.57e-10
R2 1 port2 1.18e-2
R3 port1 port2 6.82e+3
L4 port1 2 2.81e-6
R4 2 port2 1.53e+4
L5 port1 3 1.56e-8
R5 3 port2 20.9
L6 port1 4 4.69e-10
R6 4 port2 1.09e-2
L7 port1 5 2.26e-8
C7 5 6 5.17e-15
R7 6 port2 77.3
.ENDS LQP03TQ0N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N7B02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 7.92e-10
R2 1 port2 1.35e-2
R3 port1 port2 1.16e+4
L4 port1 2 1.62e-6
R4 2 port2 9.02e+3
L5 port1 3 1.01e-7
R5 3 port2 209
L6 port1 4 6.33e-10
R6 4 port2 1.48e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N7C02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 7.92e-10
R2 1 port2 1.35e-2
R3 port1 port2 1.16e+4
L4 port1 2 1.62e-6
R4 2 port2 9.02e+3
L5 port1 3 1.01e-7
R5 3 port2 209
L6 port1 4 6.33e-10
R6 4 port2 1.48e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N7W02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N7W02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 7.92e-10
R2 1 port2 1.35e-2
R3 port1 port2 1.16e+4
L4 port1 2 1.62e-6
R4 2 port2 9.02e+3
L5 port1 3 1.01e-7
R5 3 port2 209
L6 port1 4 6.33e-10
R6 4 port2 1.48e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N8B02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.36e-10
R2 1 port2 2.14e-2
R3 port1 port2 4.83e+3
L4 port1 2 2.18e-7
R4 2 port2 1.14e+3
L5 port1 3 5.06e-8
R5 3 port2 105
L6 port1 4 3.10e-9
R6 4 port2 3.71e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N8C02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.36e-10
R2 1 port2 2.14e-2
R3 port1 port2 4.83e+3
L4 port1 2 2.18e-7
R4 2 port2 1.14e+3
L5 port1 3 5.06e-8
R5 3 port2 105
L6 port1 4 3.10e-9
R6 4 port2 3.71e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N8W02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N8W02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.36e-10
R2 1 port2 2.14e-2
R3 port1 port2 4.83e+3
L4 port1 2 2.18e-7
R4 2 port2 1.14e+3
L5 port1 3 5.06e-8
R5 3 port2 105
L6 port1 4 3.10e-9
R6 4 port2 3.71e-2
L7 port1 5 3.59e-8
C7 5 6 3.26e-15
R7 6 port2 123
.ENDS LQP03TQ0N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N9B02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.61e-10
R2 1 port2 2.69e-2
R3 port1 port2 4.02e+3
L4 port1 2 6.14e-8
R4 2 port2 320
L5 port1 3 2.66e-8
R5 3 port2 31.0
L6 port1 4 3.81e-8
R6 4 port2 1.82
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N9C02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.61e-10
R2 1 port2 2.69e-2
R3 port1 port2 4.02e+3
L4 port1 2 6.14e-8
R4 2 port2 320
L5 port1 3 2.66e-8
R5 3 port2 31.0
L6 port1 4 3.81e-8
R6 4 port2 1.82
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ0N9W02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ0N9W02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 5.61e-10
R2 1 port2 2.69e-2
R3 port1 port2 4.02e+3
L4 port1 2 6.14e-8
R4 2 port2 320
L5 port1 3 2.66e-8
R5 3 port2 31.0
L6 port1 4 3.81e-8
R6 4 port2 1.82
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ0N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ10NH02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.09e-8
R2 1 port2 3.72e-1
R3 port1 port2 1.24e+4
L4 port1 2 1.90e-7
R4 2 port2 473
L5 port1 3 1.49e-7
R5 3 port2 57.7
L6 port1 4 1.55e-6
R6 4 port2 50.0
.ENDS LQP03TQ10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ10NJ02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 1.09e-8
R2 1 port2 3.72e-1
R3 port1 port2 1.24e+4
L4 port1 2 1.90e-7
R4 2 port2 473
L5 port1 3 1.49e-7
R5 3 port2 57.7
L6 port1 4 1.55e-6
R6 4 port2 50.0
.ENDS LQP03TQ10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ11NH02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 1.23e-8
R2 1 port2 3.24e-1
R3 port1 port2 1.27e+4
L4 port1 2 2.08e-7
R4 2 port2 507
L5 port1 3 1.33e-7
R5 3 port2 60.4
L6 port1 4 3.90e-7
R6 4 port2 4.46
.ENDS LQP03TQ11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ11NJ02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 1.23e-8
R2 1 port2 3.24e-1
R3 port1 port2 1.27e+4
L4 port1 2 2.08e-7
R4 2 port2 507
L5 port1 3 1.33e-7
R5 3 port2 60.4
L6 port1 4 3.90e-7
R6 4 port2 4.46
.ENDS LQP03TQ11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ12NH02 port1 port2
C1 port1 port2 8.63e-14
L2 port1 1 1.32e-8
R2 1 port2 3.24e-1
R3 port1 port2 1.27e+4
L4 port1 2 2.18e-7
R4 2 port2 531
L5 port1 3 1.43e-7
R5 3 port2 64.7
L6 port1 4 8.15e-4
R6 4 port2 9.10e+3
L7 port1 5 2.61e-8
C7 5 6 3.10e-15
R7 6 port2 16.2
.ENDS LQP03TQ12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ12NJ02 port1 port2
C1 port1 port2 8.63e-14
L2 port1 1 1.32e-8
R2 1 port2 3.24e-1
R3 port1 port2 1.27e+4
L4 port1 2 2.18e-7
R4 2 port2 531
L5 port1 3 1.43e-7
R5 3 port2 64.7
L6 port1 4 8.15e-4
R6 4 port2 9.10e+3
L7 port1 5 2.61e-8
C7 5 6 3.10e-15
R7 6 port2 16.2
.ENDS LQP03TQ12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ13NH02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 1.44e-8
R2 1 port2 4.17e-1
R3 port1 port2 1.42e+4
L4 port1 2 2.39e-7
R4 2 port2 582
L5 port1 3 1.68e-7
R5 3 port2 63.2
L6 port1 4 1.29e-6
R6 4 port2 9.10
L7 port1 5 8.81e-9
C7 5 6 9.62e-15
R7 6 port2 22.3
.ENDS LQP03TQ13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ13NJ02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 1.44e-8
R2 1 port2 4.17e-1
R3 port1 port2 1.42e+4
L4 port1 2 2.39e-7
R4 2 port2 582
L5 port1 3 1.68e-7
R5 3 port2 63.2
L6 port1 4 1.29e-6
R6 4 port2 9.10
L7 port1 5 8.81e-9
C7 5 6 9.62e-15
R7 6 port2 22.3
.ENDS LQP03TQ13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N0B02 port1 port2
C1 port1 port2 2.49e-14
L2 port1 1 6.74e-10
R2 1 port2 2.09e-2
R3 port1 port2 4.61e+3
L4 port1 2 8.10e-8
R4 2 port2 422
L5 port1 3 2.72e-8
R5 3 port2 33.2
L6 port1 4 1.35e-7
R6 4 port2 3.01
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N0C02 port1 port2
C1 port1 port2 2.49e-14
L2 port1 1 6.74e-10
R2 1 port2 2.09e-2
R3 port1 port2 4.61e+3
L4 port1 2 8.10e-8
R4 2 port2 422
L5 port1 3 2.72e-8
R5 3 port2 33.2
L6 port1 4 1.35e-7
R6 4 port2 3.01
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N0W02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N0W02 port1 port2
C1 port1 port2 2.49e-14
L2 port1 1 6.74e-10
R2 1 port2 2.09e-2
R3 port1 port2 4.61e+3
L4 port1 2 8.10e-8
R4 2 port2 422
L5 port1 3 2.72e-8
R5 3 port2 33.2
L6 port1 4 1.35e-7
R6 4 port2 3.01
L7 port1 5 5.31e-8
C7 5 6 2.10e-15
R7 6 port2 185
.ENDS LQP03TQ1N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N1B02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.75e-10
R2 1 port2 2.29e-2
R3 port1 port2 4.72e+3
L4 port1 2 8.10e-8
R4 2 port2 462
L5 port1 3 1.88e-8
R5 3 port2 22.4
L6 port1 4 4.18e-9
R6 4 port2 4.56e-1
L7 port1 5 7.67e-8
C7 5 6 1.60e-15
R7 6 port2 104
.ENDS LQP03TQ1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N1C02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.75e-10
R2 1 port2 2.29e-2
R3 port1 port2 4.72e+3
L4 port1 2 8.10e-8
R4 2 port2 462
L5 port1 3 1.88e-8
R5 3 port2 22.4
L6 port1 4 4.18e-9
R6 4 port2 4.56e-1
L7 port1 5 7.67e-8
C7 5 6 1.60e-15
R7 6 port2 104
.ENDS LQP03TQ1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N1W02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N1W02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.75e-10
R2 1 port2 2.29e-2
R3 port1 port2 4.72e+3
L4 port1 2 8.10e-8
R4 2 port2 462
L5 port1 3 1.88e-8
R5 3 port2 22.4
L6 port1 4 4.18e-9
R6 4 port2 4.56e-1
L7 port1 5 7.67e-8
C7 5 6 1.60e-15
R7 6 port2 104
.ENDS LQP03TQ1N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N2B02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.10e-10
R2 1 port2 3.63e-2
R3 port1 port2 4.72e+3
L4 port1 2 6.00e-8
R4 2 port2 216
L5 port1 3 3.19e-8
R5 3 port2 38.1
L6 port1 4 8.93e-8
R6 4 port2 7.75
L7 port1 5 4.73e-8
C7 5 6 2.71e-15
R7 6 port2 158
.ENDS LQP03TQ1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N2C02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.10e-10
R2 1 port2 3.63e-2
R3 port1 port2 4.72e+3
L4 port1 2 6.00e-8
R4 2 port2 216
L5 port1 3 3.19e-8
R5 3 port2 38.1
L6 port1 4 8.93e-8
R6 4 port2 7.75
L7 port1 5 4.73e-8
C7 5 6 2.71e-15
R7 6 port2 158
.ENDS LQP03TQ1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N2W02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N2W02 port1 port2
C1 port1 port2 2.61e-14
L2 port1 1 9.10e-10
R2 1 port2 3.63e-2
R3 port1 port2 4.72e+3
L4 port1 2 6.00e-8
R4 2 port2 216
L5 port1 3 3.19e-8
R5 3 port2 38.1
L6 port1 4 8.93e-8
R6 4 port2 7.75
L7 port1 5 4.73e-8
C7 5 6 2.71e-15
R7 6 port2 158
.ENDS LQP03TQ1N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N3B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 1.04e-9
R2 1 port2 3.39e-2
R3 port1 port2 8.59e+3
L4 port1 2 6.89e-8
R4 2 port2 422
L5 port1 3 2.54e-8
R5 3 port2 28.2
L6 port1 4 2.30e-8
R6 4 port2 2.23
.ENDS LQP03TQ1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N3C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 1.04e-9
R2 1 port2 3.39e-2
R3 port1 port2 8.59e+3
L4 port1 2 6.89e-8
R4 2 port2 422
L5 port1 3 2.54e-8
R5 3 port2 28.2
L6 port1 4 2.30e-8
R6 4 port2 2.23
.ENDS LQP03TQ1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N3W02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N3W02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 1.04e-9
R2 1 port2 3.39e-2
R3 port1 port2 8.59e+3
L4 port1 2 6.89e-8
R4 2 port2 422
L5 port1 3 2.54e-8
R5 3 port2 28.2
L6 port1 4 2.30e-8
R6 4 port2 2.23
.ENDS LQP03TQ1N3W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N4B02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 1.15e-9
R2 1 port2 3.55e-2
R3 port1 port2 8.59e+3
L4 port1 2 7.91e-8
R4 2 port2 556
L5 port1 3 2.72e-8
R5 3 port2 30.3
L6 port1 4 2.30e-8
R6 4 port2 5.61
.ENDS LQP03TQ1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N4C02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 1.15e-9
R2 1 port2 3.55e-2
R3 port1 port2 8.59e+3
L4 port1 2 7.91e-8
R4 2 port2 556
L5 port1 3 2.72e-8
R5 3 port2 30.3
L6 port1 4 2.30e-8
R6 4 port2 5.61
.ENDS LQP03TQ1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N4W02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N4W02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 1.15e-9
R2 1 port2 3.55e-2
R3 port1 port2 8.59e+3
L4 port1 2 7.91e-8
R4 2 port2 556
L5 port1 3 2.72e-8
R5 3 port2 30.3
L6 port1 4 2.30e-8
R6 4 port2 5.61
.ENDS LQP03TQ1N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N5B02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 1.20e-9
R2 1 port2 3.09e-2
R3 port1 port2 5.80e+3
L4 port1 2 6.89e-8
R4 2 port2 367
L5 port1 3 4.62e-8
R5 3 port2 40.8
L6 port1 4 2.46e-8
R6 4 port2 10.5
.ENDS LQP03TQ1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N5C02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 1.20e-9
R2 1 port2 3.09e-2
R3 port1 port2 5.80e+3
L4 port1 2 6.89e-8
R4 2 port2 367
L5 port1 3 4.62e-8
R5 3 port2 40.8
L6 port1 4 2.46e-8
R6 4 port2 10.5
.ENDS LQP03TQ1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N5W02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N5W02 port1 port2
C1 port1 port2 5.57e-14
L2 port1 1 1.20e-9
R2 1 port2 3.09e-2
R3 port1 port2 5.80e+3
L4 port1 2 6.89e-8
R4 2 port2 367
L5 port1 3 4.62e-8
R5 3 port2 40.8
L6 port1 4 2.46e-8
R6 4 port2 10.5
.ENDS LQP03TQ1N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N6B02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.35e-9
R2 1 port2 3.80e-2
R3 port1 port2 5.80e+3
L4 port1 2 8.10e-8
R4 2 port2 432
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 2.46e-8
R6 4 port2 10.5
.ENDS LQP03TQ1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N6C02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.35e-9
R2 1 port2 3.80e-2
R3 port1 port2 5.80e+3
L4 port1 2 8.10e-8
R4 2 port2 432
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 2.46e-8
R6 4 port2 10.5
.ENDS LQP03TQ1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N7B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.45e-9
R2 1 port2 3.55e-2
R3 port1 port2 4.83e+3
L4 port1 2 4.56e-8
R4 2 port2 153
L5 port1 3 4.94e-8
R5 3 port2 43.7
L6 port1 4 2.05e-8
R6 4 port2 4.46
.ENDS LQP03TQ1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N7C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.45e-9
R2 1 port2 3.55e-2
R3 port1 port2 4.83e+3
L4 port1 2 4.56e-8
R4 2 port2 153
L5 port1 3 4.94e-8
R5 3 port2 43.7
L6 port1 4 2.05e-8
R6 4 port2 4.46
.ENDS LQP03TQ1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N8B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.59e-9
R2 1 port2 3.02e-2
R3 port1 port2 5.06e+3
L4 port1 2 5.23e-8
R4 2 port2 176
L5 port1 3 8.79e-8
R5 3 port2 77.6
L6 port1 4 1.70e-8
R6 4 port2 5.00
.ENDS LQP03TQ1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N8C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.59e-9
R2 1 port2 3.02e-2
R3 port1 port2 5.06e+3
L4 port1 2 5.23e-8
R4 2 port2 176
L5 port1 3 8.79e-8
R5 3 port2 77.6
L6 port1 4 1.70e-8
R6 4 port2 5.00
.ENDS LQP03TQ1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N9B02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.74e-9
R2 1 port2 3.02e-2
R3 port1 port2 5.54e+3
L4 port1 2 5.87e-8
R4 2 port2 197
L5 port1 3 8.59e-8
R5 3 port2 75.9
L6 port1 4 1.95e-8
R6 4 port2 5.75
.ENDS LQP03TQ1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ1N9C02 port1 port2
C1 port1 port2 5.97e-14
L2 port1 1 1.74e-9
R2 1 port2 3.02e-2
R3 port1 port2 5.54e+3
L4 port1 2 5.87e-8
R4 2 port2 197
L5 port1 3 8.59e-8
R5 3 port2 75.9
L6 port1 4 1.95e-8
R6 4 port2 5.75
.ENDS LQP03TQ1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N0B02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 1.82e-9
R2 1 port2 3.80e-2
R3 port1 port2 5.54e+3
L4 port1 2 5.35e-8
R4 2 port2 180
L5 port1 3 9.00e-8
R5 3 port2 79.5
L6 port1 4 1.87e-8
R6 4 port2 5.49
.ENDS LQP03TQ2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N0C02 port1 port2
C1 port1 port2 5.32e-14
L2 port1 1 1.82e-9
R2 1 port2 3.80e-2
R3 port1 port2 5.54e+3
L4 port1 2 5.35e-8
R4 2 port2 180
L5 port1 3 9.00e-8
R5 3 port2 79.5
L6 port1 4 1.87e-8
R6 4 port2 5.49
.ENDS LQP03TQ2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N1B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 1.90e-9
R2 1 port2 3.02e-2
R3 port1 port2 8.20e+3
L4 port1 2 8.48e-8
R4 2 port2 496
L5 port1 3 4.31e-8
R5 3 port2 41.8
L6 port1 4 3.99e-8
R6 4 port2 13.5
.ENDS LQP03TQ2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N1C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 1.90e-9
R2 1 port2 3.02e-2
R3 port1 port2 8.20e+3
L4 port1 2 8.48e-8
R4 2 port2 496
L5 port1 3 4.31e-8
R5 3 port2 41.8
L6 port1 4 3.99e-8
R6 4 port2 13.5
.ENDS LQP03TQ2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N2B02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 2.08e-9
R2 1 port2 2.89e-2
R3 port1 port2 8.39e+3
L4 port1 2 8.88e-8
R4 2 port2 624
L5 port1 3 3.58e-8
R5 3 port2 34.0
L6 port1 4 3.10e-8
R6 4 port2 7.93
.ENDS LQP03TQ2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N2C02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 2.08e-9
R2 1 port2 2.89e-2
R3 port1 port2 8.39e+3
L4 port1 2 8.88e-8
R4 2 port2 624
L5 port1 3 3.58e-8
R5 3 port2 34.0
L6 port1 4 3.10e-8
R6 4 port2 7.93
.ENDS LQP03TQ2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N3B02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 2.18e-9
R2 1 port2 3.98e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 3.42e-8
R5 3 port2 33.2
L6 port1 4 5.14e-8
R6 4 port2 11.2
.ENDS LQP03TQ2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N3C02 port1 port2
C1 port1 port2 7.34e-14
L2 port1 1 2.18e-9
R2 1 port2 3.98e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 3.42e-8
R5 3 port2 33.2
L6 port1 4 5.14e-8
R6 4 port2 11.2
.ENDS LQP03TQ2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N4B02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.23e-9
R2 1 port2 4.08e-2
R3 port1 port2 8.39e+3
L4 port1 2 9.74e-8
R4 2 port2 556
L5 port1 3 4.21e-8
R5 3 port2 40.8
L6 port1 4 4.18e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N4C02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.23e-9
R2 1 port2 4.08e-2
R3 port1 port2 8.39e+3
L4 port1 2 9.74e-8
R4 2 port2 556
L5 port1 3 4.21e-8
R5 3 port2 40.8
L6 port1 4 4.18e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N5B02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.39e-9
R2 1 port2 5.13e-2
R3 port1 port2 6.98e+3
L4 port1 2 1.02e-7
R4 2 port2 432
L5 port1 3 5.81e-8
R5 3 port2 69.3
L6 port1 4 4.58e-8
R6 4 port2 11.2
.ENDS LQP03TQ2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N5C02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.39e-9
R2 1 port2 5.13e-2
R3 port1 port2 6.98e+3
L4 port1 2 1.02e-7
R4 2 port2 432
L5 port1 3 5.81e-8
R5 3 port2 69.3
L6 port1 4 4.58e-8
R6 4 port2 11.2
.ENDS LQP03TQ2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N6B02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.51e-9
R2 1 port2 5.13e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.31e-7
R4 2 port2 750
L5 port1 3 3.84e-8
R5 3 port2 37.2
L6 port1 4 5.51e-8
R6 4 port2 13.2
.ENDS LQP03TQ2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N6C02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 2.51e-9
R2 1 port2 5.13e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.31e-7
R4 2 port2 750
L5 port1 3 3.84e-8
R5 3 port2 37.2
L6 port1 4 5.51e-8
R6 4 port2 13.2
.ENDS LQP03TQ2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N7B02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 2.68e-9
R2 1 port2 4.47e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 3.42e-8
R5 3 port2 29.6
L6 port1 4 4.80e-8
R6 4 port2 11.5
.ENDS LQP03TQ2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N7C02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 2.68e-9
R2 1 port2 4.47e-2
R3 port1 port2 8.39e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 3.42e-8
R5 3 port2 29.6
L6 port1 4 4.80e-8
R6 4 port2 11.5
.ENDS LQP03TQ2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N8B02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 2.81e-9
R2 1 port2 5.02e-2
R3 port1 port2 7.83e+3
L4 port1 2 1.04e-7
R4 2 port2 507
L5 port1 3 3.75e-8
R5 3 port2 30.3
L6 port1 4 5.14e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N8C02 port1 port2
C1 port1 port2 6.11e-14
L2 port1 1 2.81e-9
R2 1 port2 5.02e-2
R3 port1 port2 7.83e+3
L4 port1 2 1.04e-7
R4 2 port2 507
L5 port1 3 3.75e-8
R5 3 port2 30.3
L6 port1 4 5.14e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N9B02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 2.94e-9
R2 1 port2 4.57e-2
R3 port1 port2 9.41e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 4.21e-8
R5 3 port2 34.7
L6 port1 4 5.14e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ2N9C02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 2.94e-9
R2 1 port2 4.57e-2
R3 port1 port2 9.41e+3
L4 port1 2 1.07e-7
R4 2 port2 610
L5 port1 3 4.21e-8
R5 3 port2 34.7
L6 port1 4 5.14e-8
R6 4 port2 12.3
.ENDS LQP03TQ2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N0B02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 2.94e-9
R2 1 port2 5.76e-2
R3 port1 port2 9.41e+3
L4 port1 2 1.14e-7
R4 2 port2 653
L5 port1 3 4.21e-8
R5 3 port2 36.4
L6 port1 4 6.62e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N0C02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 2.94e-9
R2 1 port2 5.76e-2
R3 port1 port2 9.41e+3
L4 port1 2 1.14e-7
R4 2 port2 653
L5 port1 3 4.21e-8
R5 3 port2 36.4
L6 port1 4 6.62e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N1B02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 3.08e-9
R2 1 port2 7.25e-2
R3 port1 port2 9.86e+3
L4 port1 2 1.28e-7
R4 2 port2 733
L5 port1 3 5.06e-8
R5 3 port2 43.7
L6 port1 4 6.62e-8
R6 4 port2 20.4
.ENDS LQP03TQ3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N1C02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 3.08e-9
R2 1 port2 7.25e-2
R3 port1 port2 9.86e+3
L4 port1 2 1.28e-7
R4 2 port2 733
L5 port1 3 5.06e-8
R5 3 port2 43.7
L6 port1 4 6.62e-8
R6 4 port2 20.4
.ENDS LQP03TQ3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N2B02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.23e-9
R2 1 port2 6.31e-2
R3 port1 port2 9.63e+3
L4 port1 2 1.31e-7
R4 2 port2 750
L5 port1 3 4.72e-8
R5 3 port2 40.8
L6 port1 4 6.62e-8
R6 4 port2 17.8
.ENDS LQP03TQ3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N2C02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.23e-9
R2 1 port2 6.31e-2
R3 port1 port2 9.63e+3
L4 port1 2 1.31e-7
R4 2 port2 750
L5 port1 3 4.72e-8
R5 3 port2 40.8
L6 port1 4 6.62e-8
R6 4 port2 17.8
.ENDS LQP03TQ3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N3B02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 3.30e-9
R2 1 port2 6.03e-2
R3 port1 port2 9.63e+3
L4 port1 2 1.31e-7
R4 2 port2 767
L5 port1 3 4.72e-8
R5 3 port2 39.9
L6 port1 4 5.77e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N3C02 port1 port2
C1 port1 port2 6.85e-14
L2 port1 1 3.30e-9
R2 1 port2 6.03e-2
R3 port1 port2 9.63e+3
L4 port1 2 1.31e-7
R4 2 port2 767
L5 port1 3 4.72e-8
R5 3 port2 39.9
L6 port1 4 5.77e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N4B02 port1 port2
C1 port1 port2 8.05e-14
L2 port1 1 3.46e-9
R2 1 port2 6.77e-2
R3 port1 port2 1.01e+4
L4 port1 2 1.47e-7
R4 2 port2 861
L5 port1 3 4.31e-8
R5 3 port2 37.2
L6 port1 4 6.47e-8
R6 4 port2 13.8
.ENDS LQP03TQ3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N4C02 port1 port2
C1 port1 port2 8.05e-14
L2 port1 1 3.46e-9
R2 1 port2 6.77e-2
R3 port1 port2 1.01e+4
L4 port1 2 1.47e-7
R4 2 port2 861
L5 port1 3 4.31e-8
R5 3 port2 37.2
L6 port1 4 6.47e-8
R6 4 port2 13.8
.ENDS LQP03TQ3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N5B02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 3.62e-9
R2 1 port2 7.08e-2
R3 port1 port2 1.06e+4
L4 port1 2 1.41e-7
R4 2 port2 804
L5 port1 3 5.06e-8
R5 3 port2 41.8
L6 port1 4 6.18e-8
R6 4 port2 15.5
.ENDS LQP03TQ3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N5C02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 3.62e-9
R2 1 port2 7.08e-2
R3 port1 port2 1.06e+4
L4 port1 2 1.41e-7
R4 2 port2 804
L5 port1 3 5.06e-8
R5 3 port2 41.8
L6 port1 4 6.18e-8
R6 4 port2 15.5
.ENDS LQP03TQ3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N6B02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 3.71e-9
R2 1 port2 8.32e-2
R3 port1 port2 1.03e+4
L4 port1 2 1.51e-7
R4 2 port2 861
L5 port1 3 5.30e-8
R5 3 port2 45.8
L6 port1 4 6.62e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N6C02 port1 port2
C1 port1 port2 7.51e-14
L2 port1 1 3.71e-9
R2 1 port2 8.32e-2
R3 port1 port2 1.03e+4
L4 port1 2 1.51e-7
R4 2 port2 861
L5 port1 3 5.30e-8
R5 3 port2 45.8
L6 port1 4 6.62e-8
R6 4 port2 15.8
.ENDS LQP03TQ3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N7B02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 3.71e-9
R2 1 port2 9.34e-2
R3 port1 port2 9.86e+3
L4 port1 2 1.54e-7
R4 2 port2 861
L5 port1 3 5.18e-8
R5 3 port2 44.8
L6 port1 4 1.10e-7
R6 4 port2 28.8
.ENDS LQP03TQ3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N7C02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 3.71e-9
R2 1 port2 9.34e-2
R3 port1 port2 9.86e+3
L4 port1 2 1.54e-7
R4 2 port2 861
L5 port1 3 5.18e-8
R5 3 port2 44.8
L6 port1 4 1.10e-7
R6 4 port2 28.8
.ENDS LQP03TQ3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N8B02 port1 port2
C1 port1 port2 7.69e-14
L2 port1 1 3.79e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.58e-7
R4 2 port2 902
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 1.91e-7
R6 4 port2 22.3
.ENDS LQP03TQ3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N8C02 port1 port2
C1 port1 port2 7.69e-14
L2 port1 1 3.79e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.58e-7
R4 2 port2 902
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 1.91e-7
R6 4 port2 22.3
.ENDS LQP03TQ3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N9B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 4.06e-9
R2 1 port2 8.92e-2
R3 port1 port2 1.03e+4
L4 port1 2 1.51e-7
R4 2 port2 861
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 7.78e-8
R6 4 port2 22.9
.ENDS LQP03TQ3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ3N9C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 4.06e-9
R2 1 port2 8.92e-2
R3 port1 port2 1.03e+4
L4 port1 2 1.51e-7
R4 2 port2 861
L5 port1 3 5.06e-8
R5 3 port2 44.8
L6 port1 4 7.78e-8
R6 4 port2 22.9
.ENDS LQP03TQ3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N0B02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.16e-9
R2 1 port2 1.02e-1
R3 port1 port2 1.11e+4
L4 port1 2 1.51e-7
R4 2 port2 822
L5 port1 3 5.18e-8
R5 3 port2 44.8
L6 port1 4 9.57e-8
R6 4 port2 25.1
.ENDS LQP03TQ4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N0C02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.16e-9
R2 1 port2 1.02e-1
R3 port1 port2 1.11e+4
L4 port1 2 1.51e-7
R4 2 port2 822
L5 port1 3 5.18e-8
R5 3 port2 44.8
L6 port1 4 9.57e-8
R6 4 port2 25.1
.ENDS LQP03TQ4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N1B02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 4.35e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.08e+4
L4 port1 2 1.44e-7
R4 2 port2 767
L5 port1 3 6.09e-8
R5 3 port2 52.6
L6 port1 4 8.53e-8
R6 4 port2 23.4
.ENDS LQP03TQ4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N1C02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 4.35e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.08e+4
L4 port1 2 1.44e-7
R4 2 port2 767
L5 port1 3 6.09e-8
R5 3 port2 52.6
L6 port1 4 8.53e-8
R6 4 port2 23.4
.ENDS LQP03TQ4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N2B02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.46e-9
R2 1 port2 1.20e-1
R3 port1 port2 9.86e+3
L4 port1 2 1.69e-7
R4 2 port2 902
L5 port1 3 6.09e-8
R5 3 port2 55.1
L6 port1 4 8.34e-8
R6 4 port2 23.9
.ENDS LQP03TQ4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N2C02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.46e-9
R2 1 port2 1.20e-1
R3 port1 port2 9.86e+3
L4 port1 2 1.69e-7
R4 2 port2 902
L5 port1 3 6.09e-8
R5 3 port2 55.1
L6 port1 4 8.34e-8
R6 4 port2 23.9
.ENDS LQP03TQ4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N3H02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.56e-9
R2 1 port2 1.10e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.54e-7
R4 2 port2 822
L5 port1 3 6.83e-8
R5 3 port2 61.8
L6 port1 4 8.53e-8
R6 4 port2 23.9
.ENDS LQP03TQ4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N3J02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 4.56e-9
R2 1 port2 1.10e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.54e-7
R4 2 port2 822
L5 port1 3 6.83e-8
R5 3 port2 61.8
L6 port1 4 8.53e-8
R6 4 port2 23.9
.ENDS LQP03TQ4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N7H02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 4.89e-9
R2 1 port2 1.20e-1
R3 port1 port2 1.03e+4
L4 port1 2 1.62e-7
R4 2 port2 733
L5 port1 3 6.83e-8
R5 3 port2 61.8
L6 port1 4 7.43e-8
R6 4 port2 16.2
.ENDS LQP03TQ4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ4N7J02 port1 port2
C1 port1 port2 7.87e-14
L2 port1 1 4.89e-9
R2 1 port2 1.20e-1
R3 port1 port2 1.03e+4
L4 port1 2 1.62e-7
R4 2 port2 733
L5 port1 3 6.83e-8
R5 3 port2 61.8
L6 port1 4 7.43e-8
R6 4 port2 16.2
.ENDS LQP03TQ4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ5N1H02 port1 port2
C1 port1 port2 7.01e-14
L2 port1 1 5.36e-9
R2 1 port2 1.51e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.77e-7
R4 2 port2 804
L5 port1 3 1.08e-7
R5 3 port2 87.3
L6 port1 4 8.34e-8
R6 4 port2 26.9
.ENDS LQP03TQ5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ5N1J02 port1 port2
C1 port1 port2 7.01e-14
L2 port1 1 5.36e-9
R2 1 port2 1.51e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.77e-7
R4 2 port2 804
L5 port1 3 1.08e-7
R5 3 port2 87.3
L6 port1 4 8.34e-8
R6 4 port2 26.9
.ENDS LQP03TQ5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ5N6H02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 6.01e-9
R2 1 port2 1.45e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.73e-7
R4 2 port2 750
L5 port1 3 9.64e-8
R5 3 port2 76.0
L6 port1 4 8.34e-8
R6 4 port2 24.5
.ENDS LQP03TQ5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ5N6J02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 6.01e-9
R2 1 port2 1.45e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.73e-7
R4 2 port2 750
L5 port1 3 9.64e-8
R5 3 port2 76.0
L6 port1 4 8.34e-8
R6 4 port2 24.5
.ENDS LQP03TQ5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ6N2H02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 6.44e-9
R2 1 port2 1.95e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.90e-7
R4 2 port2 716
L5 port1 3 6.67e-8
R5 3 port2 45.8
L6 port1 4 1.03e-6
R6 4 port2 12.3
.ENDS LQP03TQ6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ6N2J02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 6.44e-9
R2 1 port2 1.95e-1
R3 port1 port2 1.16e+4
L4 port1 2 1.90e-7
R4 2 port2 716
L5 port1 3 6.67e-8
R5 3 port2 45.8
L6 port1 4 1.03e-6
R6 4 port2 12.3
.ENDS LQP03TQ6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ6N8H02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 7.06e-9
R2 1 port2 2.29e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.90e-7
R4 2 port2 668
L5 port1 3 8.80e-8
R5 3 port2 60.4
L6 port1 4 1.03e-6
R6 4 port2 12.3
.ENDS LQP03TQ6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ6N8J02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 7.06e-9
R2 1 port2 2.29e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.90e-7
R4 2 port2 668
L5 port1 3 8.80e-8
R5 3 port2 60.4
L6 port1 4 1.03e-6
R6 4 port2 12.3
.ENDS LQP03TQ6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ7N5H02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 7.92e-9
R2 1 port2 2.19e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.62e-7
R4 2 port2 462
L5 port1 3 9.00e-8
R5 3 port2 45.8
L6 port1 4 5.77e-4
R6 4 port2 8.50e+4
.ENDS LQP03TQ7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ7N5J02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 7.92e-9
R2 1 port2 2.19e-1
R3 port1 port2 1.13e+4
L4 port1 2 1.62e-7
R4 2 port2 462
L5 port1 3 9.00e-8
R5 3 port2 45.8
L6 port1 4 5.77e-4
R6 4 port2 8.50e+4
.ENDS LQP03TQ7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ8N2H02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 8.69e-9
R2 1 port2 2.40e-1
R3 port1 port2 1.19e+4
L4 port1 2 1.69e-7
R4 2 port2 496
L5 port1 3 1.01e-7
R5 3 port2 50.2
L6 port1 4 1.95e-4
R6 4 port2 39.7
.ENDS LQP03TQ8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ8N2J02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 8.69e-9
R2 1 port2 2.40e-1
R3 port1 port2 1.19e+4
L4 port1 2 1.69e-7
R4 2 port2 496
L5 port1 3 1.01e-7
R5 3 port2 50.2
L6 port1 4 1.95e-4
R6 4 port2 39.7
.ENDS LQP03TQ8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ9N1H02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 9.75e-9
R2 1 port2 2.82e-1
R3 port1 port2 1.27e+4
L4 port1 2 1.94e-7
R4 2 port2 569
L5 port1 3 1.11e-7
R5 3 port2 55.1
L6 port1 4 6.33e-7
R6 4 port2 16.2
.ENDS LQP03TQ9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TQ9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TQ9N1J02 port1 port2
C1 port1 port2 6.54e-14
L2 port1 1 9.75e-9
R2 1 port2 2.82e-1
R3 port1 port2 1.27e+4
L4 port1 2 1.94e-7
R4 2 port2 569
L5 port1 3 1.11e-7
R5 3 port2 55.1
L6 port1 4 6.33e-7
R6 4 port2 16.2
.ENDS LQP03TQ9N1J02
*----------------------------------------------------------------------
