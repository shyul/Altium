*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GRT0335C1E100FA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E100FA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E100FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GRT0335C1E100GA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E100GA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E100GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GRT0335C1E100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GRT0335C1E101FA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E101FA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E101FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GRT0335C1E101GA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E101GA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E101GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GRT0335C1E101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT0335C1E102FA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E102FA02 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.77e-10
R03 N02 N03 9.26e-03
L04 N03 N04 5.22e-11
R04 N03 N04 4.33e-01
L05 N04 N05 2.70e-11
R05 N04 N05 2.70e-02
L06 N05 N06 6.87e-11
R06 N05 N06 1.01e-02
C07 N06 N07 1.77e-08
L07 N06 N07 3.33e-12
R07 N06 N07 7.40e-02
C08 N07 Port2 2.82e-09
L08 N07 Port2 1.06e-11
R08 N07 Port2 2.03e-01
.ENDS GRT0335C1E102FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT0335C1E102GA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E102GA02 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.77e-10
R03 N02 N03 9.26e-03
L04 N03 N04 5.22e-11
R04 N03 N04 4.33e-01
L05 N04 N05 2.70e-11
R05 N04 N05 2.70e-02
L06 N05 N06 6.87e-11
R06 N05 N06 1.01e-02
C07 N06 N07 1.77e-08
L07 N06 N07 3.33e-12
R07 N06 N07 7.40e-02
C08 N07 Port2 2.82e-09
L08 N07 Port2 1.06e-11
R08 N07 Port2 2.03e-01
.ENDS GRT0335C1E102GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT0335C1E102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E102JA02 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.77e-10
R03 N02 N03 9.26e-03
L04 N03 N04 5.22e-11
R04 N03 N04 4.33e-01
L05 N04 N05 2.70e-11
R05 N04 N05 2.70e-02
L06 N05 N06 6.87e-11
R06 N05 N06 1.01e-02
C07 N06 N07 1.77e-08
L07 N06 N07 3.33e-12
R07 N06 N07 7.40e-02
C08 N07 Port2 2.82e-09
L08 N07 Port2 1.06e-11
R08 N07 Port2 2.03e-01
.ENDS GRT0335C1E102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E120FA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E120FA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E120FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E120GA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E120GA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E120GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GRT0335C1E150FA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E150FA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E150FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GRT0335C1E150GA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E150GA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E150GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GRT0335C1E150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/25[V]
* Murata P/N :GRT0335C1E151FA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E151FA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1E151FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/25[V]
* Murata P/N :GRT0335C1E151GA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E151GA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1E151GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/25[V]
* Murata P/N :GRT0335C1E151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1E151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E180FA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E180FA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E180FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E180GA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E180GA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E180GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E181FA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E181FA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1E181FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E181GA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E181GA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1E181GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1E181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.64e-10
R03 N02 N03 7.56e-01
C04 N03 N04 4.63e-12
L04 N03 N04 1.01e-11
R04 N03 N04 5.09e+00
C05 N04 Port2 9.70e-13
L05 N04 Port2 4.20e-11
R05 N04 Port2 1.00e+08
.ENDS GRT0335C1E1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E220FA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E220FA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1E220FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E220GA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E220GA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1E220GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1E220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E221FA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E221FA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1E221FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E221GA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E221GA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1E221GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1E221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E270FA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E270FA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E270FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E270GA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E270GA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E270GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E271FA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E271FA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.24e-10
R03 N02 N03 9.66e-02
C04 N03 N04 1.79e-10
L04 N03 N04 2.46e-11
R04 N03 N04 4.51e-01
C05 N04 Port2 4.16e-12
L05 N04 Port2 3.45e-11
R05 N04 Port2 3.70e+00
.ENDS GRT0335C1E271FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E271GA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E271GA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.24e-10
R03 N02 N03 9.66e-02
C04 N03 N04 1.79e-10
L04 N03 N04 2.46e-11
R04 N03 N04 4.51e-01
C05 N04 Port2 4.16e-12
L05 N04 Port2 3.45e-11
R05 N04 Port2 3.70e+00
.ENDS GRT0335C1E271GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.24e-10
R03 N02 N03 9.66e-02
C04 N03 N04 1.79e-10
L04 N03 N04 2.46e-11
R04 N03 N04 4.51e-01
C05 N04 Port2 4.16e-12
L05 N04 Port2 3.45e-11
R05 N04 Port2 3.70e+00
.ENDS GRT0335C1E271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.79e-11
R03 N02 N03 2.70e-01
L04 N03 N04 1.79e-11
R04 N03 N04 6.64e-01
C05 N04 N05 2.42e-11
L05 N04 N05 9.93e-12
R05 N04 N05 1.55e+00
C06 N05 Port2 1.95e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/25[V]
* Murata P/N :GRT0335C1E330FA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E330FA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E330FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/25[V]
* Murata P/N :GRT0335C1E330GA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E330GA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E330GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/25[V]
* Murata P/N :GRT0335C1E330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-04[uF]/25[V]
* Murata P/N :GRT0335C1E331FA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E331FA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.26e-10
R03 N02 N03 8.02e-02
L04 N03 N04 3.97e-11
R04 N03 N04 5.26e-01
C05 N04 Port2 7.11e-10
L05 N04 Port2 8.76e-12
R05 N04 Port2 2.46e-01
.ENDS GRT0335C1E331FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-04[uF]/25[V]
* Murata P/N :GRT0335C1E331GA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E331GA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.26e-10
R03 N02 N03 8.02e-02
L04 N03 N04 3.97e-11
R04 N03 N04 5.26e-01
C05 N04 Port2 7.11e-10
L05 N04 Port2 8.76e-12
R05 N04 Port2 2.46e-01
.ENDS GRT0335C1E331GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-04[uF]/25[V]
* Murata P/N :GRT0335C1E331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.26e-10
R03 N02 N03 8.02e-02
L04 N03 N04 3.97e-11
R04 N03 N04 5.26e-01
C05 N04 Port2 7.11e-10
L05 N04 Port2 8.76e-12
R05 N04 Port2 2.46e-01
.ENDS GRT0335C1E331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/25[V]
* Murata P/N :GRT0335C1E390FA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E390FA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1E390FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/25[V]
* Murata P/N :GRT0335C1E390GA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E390GA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1E390GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/25[V]
* Murata P/N :GRT0335C1E390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1E390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-04[uF]/25[V]
* Murata P/N :GRT0335C1E391FA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E391FA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.15e-10
R03 N02 N03 7.99e-02
L04 N03 N04 1.97e-11
R04 N03 N04 3.15e-01
C05 N04 N05 3.63e-10
L05 N04 N05 2.20e-11
R05 N04 N05 3.54e-01
C06 N05 Port2 1.13e-11
L06 N05 Port2 1.82e-11
R06 N05 Port2 1.27e+00
.ENDS GRT0335C1E391FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-04[uF]/25[V]
* Murata P/N :GRT0335C1E391GA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E391GA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.15e-10
R03 N02 N03 7.99e-02
L04 N03 N04 1.97e-11
R04 N03 N04 3.15e-01
C05 N04 N05 3.63e-10
L05 N04 N05 2.20e-11
R05 N04 N05 3.54e-01
C06 N05 Port2 1.13e-11
L06 N05 Port2 1.82e-11
R06 N05 Port2 1.27e+00
.ENDS GRT0335C1E391GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-04[uF]/25[V]
* Murata P/N :GRT0335C1E391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.15e-10
R03 N02 N03 7.99e-02
L04 N03 N04 1.97e-11
R04 N03 N04 3.15e-01
C05 N04 N05 3.63e-10
L05 N04 N05 2.20e-11
R05 N04 N05 3.54e-01
C06 N05 Port2 1.13e-11
L06 N05 Port2 1.82e-11
R06 N05 Port2 1.27e+00
.ENDS GRT0335C1E391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.27e-10
R03 N02 N03 2.50e-01
L04 N03 N04 2.31e-11
R04 N03 N04 4.35e-01
C05 N04 N05 5.82e-11
L05 N04 N05 5.43e-12
R05 N04 N05 5.70e-01
C06 N05 Port2 7.80e-12
L06 N05 Port2 2.31e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E470FA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E470FA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E470FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E470GA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E470GA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E470GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/25[V]
* Murata P/N :GRT0335C1E470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E471FA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E471FA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.13e-10
R03 N02 N03 7.34e-02
L04 N03 N04 3.65e-11
R04 N03 N04 7.60e-01
C05 N04 N05 5.17e-09
L05 N04 N05 4.38e-12
R05 N04 N05 7.26e-02
C06 N05 N06 6.98e-10
L06 N05 N06 1.44e-11
R06 N05 N06 3.24e-01
C07 N06 Port2 9.56e-11
L07 N06 Port2 2.00e-12
R07 N06 Port2 4.09e-01
.ENDS GRT0335C1E471FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E471GA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E471GA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.13e-10
R03 N02 N03 7.34e-02
L04 N03 N04 3.65e-11
R04 N03 N04 7.60e-01
C05 N04 N05 5.17e-09
L05 N04 N05 4.38e-12
R05 N04 N05 7.26e-02
C06 N05 N06 6.98e-10
L06 N05 N06 1.44e-11
R06 N05 N06 3.24e-01
C07 N06 Port2 9.56e-11
L07 N06 Port2 2.00e-12
R07 N06 Port2 4.09e-01
.ENDS GRT0335C1E471GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT0335C1E471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.13e-10
R03 N02 N03 7.34e-02
L04 N03 N04 3.65e-11
R04 N03 N04 7.60e-01
C05 N04 N05 5.17e-09
L05 N04 N05 4.38e-12
R05 N04 N05 7.26e-02
C06 N05 N06 6.98e-10
L06 N05 N06 1.44e-11
R06 N05 N06 3.24e-01
C07 N06 Port2 9.56e-11
L07 N06 Port2 2.00e-12
R07 N06 Port2 4.09e-01
.ENDS GRT0335C1E471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 2.37e-01
C04 N03 N04 2.36e-11
L04 N03 N04 1.56e-11
R04 N03 N04 1.09e+00
C05 N04 Port2 2.86e-12
L05 N04 Port2 8.67e-11
R05 N04 Port2 1.00e+05
.ENDS GRT0335C1E4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/25[V]
* Murata P/N :GRT0335C1E560FA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E560FA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E560FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/25[V]
* Murata P/N :GRT0335C1E560GA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E560GA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E560GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/25[V]
* Murata P/N :GRT0335C1E560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GRT0335C1E561FA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E561FA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.05e-10
R03 N02 N03 6.74e-02
C04 N03 N04 6.93e-09
L04 N03 N04 3.97e-12
R04 N03 N04 8.48e-02
C05 N04 N05 8.60e-10
L05 N04 N05 1.49e-11
R05 N04 N05 2.93e-01
C06 N05 N06 1.23e-10
L06 N05 N06 2.31e-11
R06 N05 N06 3.42e-01
C07 N06 Port2 2.35e-11
L07 N06 Port2 1.04e-11
R07 N06 Port2 1.13e+00
.ENDS GRT0335C1E561FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GRT0335C1E561GA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E561GA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.05e-10
R03 N02 N03 6.74e-02
C04 N03 N04 6.93e-09
L04 N03 N04 3.97e-12
R04 N03 N04 8.48e-02
C05 N04 N05 8.60e-10
L05 N04 N05 1.49e-11
R05 N04 N05 2.93e-01
C06 N05 N06 1.23e-10
L06 N05 N06 2.31e-11
R06 N05 N06 3.42e-01
C07 N06 Port2 2.35e-11
L07 N06 Port2 1.04e-11
R07 N06 Port2 1.13e+00
.ENDS GRT0335C1E561GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GRT0335C1E561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.05e-10
R03 N02 N03 6.74e-02
C04 N03 N04 6.93e-09
L04 N03 N04 3.97e-12
R04 N03 N04 8.48e-02
C05 N04 N05 8.60e-10
L05 N04 N05 1.49e-11
R05 N04 N05 2.93e-01
C06 N05 N06 1.23e-10
L06 N05 N06 2.31e-11
R06 N05 N06 3.42e-01
C07 N06 Port2 2.35e-11
L07 N06 Port2 1.04e-11
R07 N06 Port2 1.13e+00
.ENDS GRT0335C1E561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.89e-11
R03 N02 N03 2.10e-01
C04 N03 N04 1.33e-12
L04 N03 N04 1.48e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 7.70e-12
L05 N04 Port2 2.44e-11
R05 N04 Port2 1.53e+00
.ENDS GRT0335C1E5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E680FA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E680FA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E680FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E680GA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E680GA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E680GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/25[V]
* Murata P/N :GRT0335C1E680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E681FA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E681FA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 6.12e-02
C04 N03 N04 1.10e-08
L04 N03 N04 3.22e-12
R04 N03 N04 7.26e-02
C05 N04 N05 1.70e-09
L05 N04 N05 1.03e-11
R05 N04 N05 2.41e-01
C06 N05 N06 8.97e-11
L06 N05 N06 3.43e-11
R06 N05 N06 3.61e-01
C07 N06 Port2 3.78e-11
L07 N06 Port2 6.75e-12
R07 N06 Port2 2.03e+00
.ENDS GRT0335C1E681FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E681GA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E681GA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 6.12e-02
C04 N03 N04 1.10e-08
L04 N03 N04 3.22e-12
R04 N03 N04 7.26e-02
C05 N04 N05 1.70e-09
L05 N04 N05 1.03e-11
R05 N04 N05 2.41e-01
C06 N05 N06 8.97e-11
L06 N05 N06 3.43e-11
R06 N05 N06 3.61e-01
C07 N06 Port2 3.78e-11
L07 N06 Port2 6.75e-12
R07 N06 Port2 2.03e+00
.ENDS GRT0335C1E681GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GRT0335C1E681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 6.12e-02
C04 N03 N04 1.10e-08
L04 N03 N04 3.22e-12
R04 N03 N04 7.26e-02
C05 N04 N05 1.70e-09
L05 N04 N05 1.03e-11
R05 N04 N05 2.41e-01
C06 N05 N06 8.97e-11
L06 N05 N06 3.43e-11
R06 N05 N06 3.61e-01
C07 N06 Port2 3.78e-11
L07 N06 Port2 6.75e-12
R07 N06 Port2 2.03e+00
.ENDS GRT0335C1E681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.11e-10
R03 N02 N03 2.00e-01
L04 N03 N04 1.63e-11
R04 N03 N04 3.89e-01
C05 N04 N05 4.37e-11
L05 N04 N05 7.79e-12
R05 N04 N05 9.62e-01
C06 N05 Port2 5.79e-12
L06 N05 Port2 3.65e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.04e-10
R03 N02 N03 1.95e-01
L04 N03 N04 8.38e-11
R04 N03 N04 1.95e+01
C05 N04 N05 2.29e-11
L05 N04 N05 1.43e-11
R05 N04 N05 3.77e+00
C06 N05 Port2 6.37e-12
L06 N05 Port2 4.73e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E820FA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E820FA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E820FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E820GA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E820GA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E820GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/25[V]
* Murata P/N :GRT0335C1E820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1E820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E821FA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E821FA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.76e-10
R03 N02 N03 4.89e-02
L04 N03 N04 4.43e-11
R04 N03 N04 4.10e-01
C05 N04 N05 1.09e-08
L05 N04 N05 4.10e-12
R05 N04 N05 6.53e-02
C06 N05 N06 1.91e-09
L06 N05 N06 1.15e-11
R06 N05 N06 2.25e-01
C07 N06 Port2 3.85e-11
L07 N06 Port2 7.43e-12
R07 N06 Port2 2.95e+00
.ENDS GRT0335C1E821FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E821GA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E821GA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.76e-10
R03 N02 N03 4.89e-02
L04 N03 N04 4.43e-11
R04 N03 N04 4.10e-01
C05 N04 N05 1.09e-08
L05 N04 N05 4.10e-12
R05 N04 N05 6.53e-02
C06 N05 N06 1.91e-09
L06 N05 N06 1.15e-11
R06 N05 N06 2.25e-01
C07 N06 Port2 3.85e-11
L07 N06 Port2 7.43e-12
R07 N06 Port2 2.95e+00
.ENDS GRT0335C1E821GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GRT0335C1E821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.76e-10
R03 N02 N03 4.89e-02
L04 N03 N04 4.43e-11
R04 N03 N04 4.10e-01
C05 N04 N05 1.09e-08
L05 N04 N05 4.10e-12
R05 N04 N05 6.53e-02
C06 N05 N06 1.91e-09
L06 N05 N06 1.15e-11
R06 N05 N06 2.25e-01
C07 N06 Port2 3.85e-11
L07 N06 Port2 7.43e-12
R07 N06 Port2 2.95e+00
.ENDS GRT0335C1E821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 1.85e-01
L04 N03 N04 2.00e-11
R04 N03 N04 4.11e-01
C05 N04 N05 1.14e-10
L05 N04 N05 3.04e-12
R05 N04 N05 3.77e-01
C06 N05 Port2 3.97e-13
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.00e-06[uF]/25[V]
* Murata P/N :GRT0335C1E9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1E9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.16e-10
R03 N02 N03 1.80e-01
L04 N03 N04 2.88e-11
R04 N03 N04 2.12e+00
C05 N04 N05 3.62e-12
L05 N04 N05 5.54e-11
R05 N04 N05 2.22e+01
C06 N05 Port2 3.53e-12
L06 N05 Port2 5.15e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1E9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GRT0335C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GRT0335C1H101FA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H101FA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H101FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GRT0335C1H101GA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H101GA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H101GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GRT0335C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H120FA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H120FA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H120FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H120GA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H120GA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H120GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H121FA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H121FA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.87e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.16e-09
L04 N03 N04 4.98e-12
R04 N03 N04 2.73e-01
C05 N04 N05 1.90e-10
L05 N04 N05 1.45e-11
R05 N04 N05 9.11e-01
C06 N05 Port2 1.12e-11
L06 N05 Port2 3.33e-11
R06 N05 Port2 2.72e+00
.ENDS GRT0335C1H121FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H121GA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H121GA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.87e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.16e-09
L04 N03 N04 4.98e-12
R04 N03 N04 2.73e-01
C05 N04 N05 1.90e-10
L05 N04 N05 1.45e-11
R05 N04 N05 9.11e-01
C06 N05 Port2 1.12e-11
L06 N05 Port2 3.33e-11
R06 N05 Port2 2.72e+00
.ENDS GRT0335C1H121GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.87e-10
R03 N02 N03 9.00e-02
C04 N03 N04 1.16e-09
L04 N03 N04 4.98e-12
R04 N03 N04 2.73e-01
C05 N04 N05 1.90e-10
L05 N04 N05 1.45e-11
R05 N04 N05 9.11e-01
C06 N05 Port2 1.12e-11
L06 N05 Port2 3.33e-11
R06 N05 Port2 2.72e+00
.ENDS GRT0335C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GRT0335C1H150FA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H150FA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H150FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GRT0335C1H150GA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H150GA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H150GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GRT0335C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GRT0335C1H151FA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H151FA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1H151FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GRT0335C1H151GA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H151GA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1H151GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GRT0335C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 9.12e-02
L04 N03 N04 2.50e-11
R04 N03 N04 7.73e-01
C05 N04 N05 1.16e-09
L05 N04 N05 6.03e-12
R05 N04 N05 1.98e-01
C06 N05 N06 3.43e-10
L06 N05 N06 8.69e-12
R06 N05 N06 4.90e-01
C07 N06 Port2 2.32e-11
L07 N06 Port2 1.35e-11
R07 N06 Port2 4.15e+00
.ENDS GRT0335C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H180FA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H180FA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H180FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H180GA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H180GA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H180GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GRT0335C1H181FA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H181FA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1H181FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GRT0335C1H181GA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H181GA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1H181GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GRT0335C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.60e-10
R03 N02 N03 7.99e-02
L04 N03 N04 3.26e-11
R04 N03 N04 1.29e+00
C05 N04 N05 1.48e-09
L05 N04 N05 5.96e-12
R05 N04 N05 2.14e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.24e-11
R06 N05 N06 4.97e-01
C07 N06 Port2 1.50e-11
L07 N06 Port2 1.90e-11
R07 N06 Port2 1.76e+01
.ENDS GRT0335C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.64e-10
R03 N02 N03 7.56e-01
C04 N03 N04 4.63e-12
L04 N03 N04 1.01e-11
R04 N03 N04 5.09e+00
C05 N04 Port2 9.70e-13
L05 N04 Port2 4.20e-11
R05 N04 Port2 1.00e+08
.ENDS GRT0335C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H220FA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H220FA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1H220FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H220GA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H220GA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1H220GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H221FA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H221FA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1H221FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H221GA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H221GA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1H221GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT0335C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.29e-02
L04 N03 N04 3.30e-11
R04 N03 N04 6.97e-01
C05 N04 N05 2.42e-09
L05 N04 N05 4.73e-12
R05 N04 N05 2.24e-01
C06 N05 N06 4.53e-10
L06 N05 N06 1.18e-11
R06 N05 N06 4.96e-01
C07 N06 Port2 1.44e-10
L07 N06 Port2 2.06e-12
R07 N06 Port2 3.58e-01
.ENDS GRT0335C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H270FA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H270FA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H270FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H270GA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H270GA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H270GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.79e-11
R03 N02 N03 2.70e-01
L04 N03 N04 1.79e-11
R04 N03 N04 6.64e-01
C05 N04 N05 2.42e-11
L05 N04 N05 9.93e-12
R05 N04 N05 1.55e+00
C06 N05 Port2 1.95e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GRT0335C1H330FA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H330FA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H330FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GRT0335C1H330GA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H330GA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H330GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GRT0335C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GRT0335C1H390FA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H390FA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1H390FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GRT0335C1H390GA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H390GA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1H390GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GRT0335C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.27e-10
R03 N02 N03 2.50e-01
L04 N03 N04 2.31e-11
R04 N03 N04 4.35e-01
C05 N04 N05 5.82e-11
L05 N04 N05 5.43e-12
R05 N04 N05 5.70e-01
C06 N05 Port2 7.80e-12
L06 N05 Port2 2.31e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H470FA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H470FA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H470FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H470GA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H470GA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H470GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GRT0335C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 2.37e-01
C04 N03 N04 2.36e-11
L04 N03 N04 1.56e-11
R04 N03 N04 1.09e+00
C05 N04 Port2 2.86e-12
L05 N04 Port2 8.67e-11
R05 N04 Port2 1.00e+05
.ENDS GRT0335C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GRT0335C1H560FA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H560FA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H560FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GRT0335C1H560GA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H560GA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H560GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GRT0335C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.89e-11
R03 N02 N03 2.10e-01
C04 N03 N04 1.33e-12
L04 N03 N04 1.48e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 7.70e-12
L05 N04 Port2 2.44e-11
R05 N04 Port2 1.53e+00
.ENDS GRT0335C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H680FA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H680FA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H680FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H680GA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H680GA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H680GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GRT0335C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.11e-10
R03 N02 N03 2.00e-01
L04 N03 N04 1.63e-11
R04 N03 N04 3.89e-01
C05 N04 N05 4.37e-11
L05 N04 N05 7.79e-12
R05 N04 N05 9.62e-01
C06 N05 Port2 5.79e-12
L06 N05 Port2 3.65e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.04e-10
R03 N02 N03 1.95e-01
L04 N03 N04 8.38e-11
R04 N03 N04 1.95e+01
C05 N04 N05 2.29e-11
L05 N04 N05 1.43e-11
R05 N04 N05 3.77e+00
C06 N05 Port2 6.37e-12
L06 N05 Port2 4.73e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H820FA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H820FA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H820FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H820GA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H820GA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H820GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GRT0335C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 1.85e-01
L04 N03 N04 2.00e-11
R04 N03 N04 4.11e-01
C05 N04 N05 1.14e-10
L05 N04 N05 3.04e-12
R05 N04 N05 3.77e-01
C06 N05 Port2 3.97e-13
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GRT0335C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.16e-10
R03 N02 N03 1.80e-01
L04 N03 N04 2.88e-11
R04 N03 N04 2.12e+00
C05 N04 N05 3.62e-12
L05 N04 N05 5.54e-11
R05 N04 N05 2.22e+01
C06 N05 Port2 3.53e-12
L06 N05 Port2 5.15e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GRT0335C2A100FA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A100FA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A100FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GRT0335C2A100GA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A100GA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A100GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GRT0335C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.46e-11
L05 N04 N05 1.35e-11
R05 N04 N05 7.83e-01
C06 N05 Port2 2.08e-12
L06 N05 Port2 5.07e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRT0335C2A101FA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A101FA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A101FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRT0335C2A101GA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A101GA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A101GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRT0335C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.82e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.42e-11
R04 N03 N04 8.01e-02
C05 N04 N05 8.18e-10
L05 N04 N05 5.66e-12
R05 N04 N05 2.81e-01
C06 N05 N06 1.93e-10
L06 N05 N06 1.09e-11
R06 N05 N06 8.44e-01
C07 N06 N07 1.29e-11
L07 N06 N07 3.09e-11
R07 N06 N07 2.89e+00
C08 N07 Port2 7.88e-12
L08 N07 Port2 3.35e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A120FA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A120FA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A120FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A120GA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A120GA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A120GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.88e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.14e-01
C05 N04 N05 3.25e-11
L05 N04 N05 9.75e-12
R05 N04 N05 1.15e+00
C06 N05 Port2 5.48e-12
L06 N05 Port2 3.75e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GRT0335C2A150FA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A150FA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A150FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GRT0335C2A150GA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A150GA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A150GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GRT0335C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.78e-01
L04 N03 N04 1.48e-11
R04 N03 N04 2.88e-01
C05 N04 N05 1.08e-11
L05 N04 N05 2.93e-11
R05 N04 N05 4.87e+00
C06 N05 Port2 4.90e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A180FA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A180FA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A180FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A180GA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A180GA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A180GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 1.59e-01
L04 N03 N04 1.17e-11
R04 N03 N04 2.21e-01
C05 N04 N05 1.61e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.56e+00
C06 N05 Port2 5.01e-12
L06 N05 Port2 4.81e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.64e-10
R03 N02 N03 7.56e-01
C04 N03 N04 4.63e-12
L04 N03 N04 1.01e-11
R04 N03 N04 5.09e+00
C05 N04 Port2 9.70e-13
L05 N04 Port2 4.20e-11
R05 N04 Port2 1.00e+08
.ENDS GRT0335C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A220FA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A220FA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C2A220FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A220GA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A220GA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C2A220GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-10
R03 N02 N03 1.48e-01
L04 N03 N04 1.54e-11
R04 N03 N04 2.91e-01
C05 N04 Port2 1.14e-11
L05 N04 Port2 3.02e-11
R05 N04 Port2 4.56e+00
.ENDS GRT0335C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A270FA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A270FA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A270FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A270GA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A270GA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A270GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.44e-10
R03 N02 N03 1.49e-01
L04 N03 N04 1.21e-11
R04 N03 N04 2.27e-01
C05 N04 N05 8.90e-12
L05 N04 N05 3.91e-11
R05 N04 N05 4.42e+00
C06 N05 Port2 3.63e-12
L06 N05 Port2 5.39e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.79e-11
R03 N02 N03 2.70e-01
L04 N03 N04 1.79e-11
R04 N03 N04 6.64e-01
C05 N04 N05 2.42e-11
L05 N04 N05 9.93e-12
R05 N04 N05 1.55e+00
C06 N05 Port2 1.95e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GRT0335C2A330FA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A330FA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A330FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GRT0335C2A330GA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A330GA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A330GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GRT0335C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.57e-11
R03 N02 N03 1.46e-01
L04 N03 N04 8.46e-12
R04 N03 N04 1.11e-01
C05 N04 N05 9.36e-12
L05 N04 N05 3.54e-11
R05 N04 N05 3.63e+00
C06 N05 Port2 6.75e-13
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GRT0335C2A390FA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A390FA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C2A390FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GRT0335C2A390GA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A390GA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C2A390GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GRT0335C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.64e-10
R03 N02 N03 1.30e-01
L04 N03 N04 1.62e-11
R04 N03 N04 2.03e-01
C05 N04 N05 7.01e-10
L05 N04 N05 2.28e-12
R05 N04 N05 2.49e-01
C06 N05 N06 4.12e-11
L06 N05 N06 1.60e-11
R06 N05 N06 1.47e+00
C07 N06 Port2 3.81e-12
L07 N06 Port2 5.03e-11
R07 N06 Port2 1.00e+05
.ENDS GRT0335C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.27e-10
R03 N02 N03 2.50e-01
L04 N03 N04 2.31e-11
R04 N03 N04 4.35e-01
C05 N04 N05 5.82e-11
L05 N04 N05 5.43e-12
R05 N04 N05 5.70e-01
C06 N05 Port2 7.80e-12
L06 N05 Port2 2.31e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A470FA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A470FA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A470FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A470GA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A470GA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A470GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GRT0335C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.66e-10
R03 N02 N03 1.26e-01
L04 N03 N04 1.31e-11
R04 N03 N04 1.65e-01
C05 N04 N05 5.81e-10
L05 N04 N05 3.32e-12
R05 N04 N05 2.62e-01
C06 N05 N06 9.57e-11
L06 N05 N06 9.24e-12
R06 N05 N06 1.10e+00
C07 N06 N07 1.69e-11
L07 N06 N07 1.94e-11
R07 N06 N07 2.53e+00
C08 N07 Port2 4.90e-12
L08 N07 Port2 3.18e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 2.37e-01
C04 N03 N04 2.36e-11
L04 N03 N04 1.56e-11
R04 N03 N04 1.09e+00
C05 N04 Port2 2.86e-12
L05 N04 Port2 8.67e-11
R05 N04 Port2 1.00e+05
.ENDS GRT0335C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GRT0335C2A560FA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A560FA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A560FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GRT0335C2A560GA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A560GA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A560GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GRT0335C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 1.21e-01
L04 N03 N04 1.12e-11
R04 N03 N04 1.41e-01
C05 N04 N05 4.77e-10
L05 N04 N05 4.85e-12
R05 N04 N05 3.49e-01
C06 N05 N06 7.82e-11
L06 N05 N06 1.35e-11
R06 N05 N06 1.31e+00
C07 N06 N07 1.89e-11
L07 N06 N07 1.74e-11
R07 N06 N07 2.27e+00
C08 N07 Port2 3.64e-12
L08 N07 Port2 5.64e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 6.89e-11
R03 N02 N03 2.10e-01
C04 N03 N04 1.33e-12
L04 N03 N04 1.48e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 7.70e-12
L05 N04 Port2 2.44e-11
R05 N04 Port2 1.53e+00
.ENDS GRT0335C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A680FA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A680FA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A680FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A680GA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A680GA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A680GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GRT0335C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.22e-01
L04 N03 N04 1.72e-11
R04 N03 N04 2.16e-01
C05 N04 N05 1.34e-09
L05 N04 N05 2.18e-12
R05 N04 N05 1.57e-01
C06 N05 N06 1.28e-10
L06 N05 N06 9.42e-12
R06 N05 N06 8.00e-01
C07 N06 N07 1.47e-11
L07 N06 N07 2.27e-11
R07 N06 N07 2.72e+00
C08 N07 Port2 7.36e-12
L08 N07 Port2 2.86e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.11e-10
R03 N02 N03 2.00e-01
L04 N03 N04 1.63e-11
R04 N03 N04 3.89e-01
C05 N04 N05 4.37e-11
L05 N04 N05 7.79e-12
R05 N04 N05 9.62e-01
C06 N05 Port2 5.79e-12
L06 N05 Port2 3.65e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.04e-10
R03 N02 N03 1.95e-01
L04 N03 N04 8.38e-11
R04 N03 N04 1.95e+01
C05 N04 N05 2.29e-11
L05 N04 N05 1.43e-11
R05 N04 N05 3.77e+00
C06 N05 Port2 6.37e-12
L06 N05 Port2 4.73e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A820FA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A820FA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A820FA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A820GA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A820GA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A820GA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GRT0335C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.85e-10
R03 N02 N03 1.14e-01
L04 N03 N04 1.08e-11
R04 N03 N04 6.80e-02
C05 N04 N05 1.47e-09
L05 N04 N05 2.50e-12
R05 N04 N05 1.01e-01
C06 N05 N06 1.98e-10
L06 N05 N06 7.01e-12
R06 N05 N06 6.68e-01
C07 N06 N07 8.44e-12
L07 N06 N07 3.94e-11
R07 N06 N07 4.72e+00
C08 N07 Port2 1.98e-11
L08 N07 Port2 1.57e-11
R08 N07 Port2 1.00e+05
.ENDS GRT0335C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.37e-10
R03 N02 N03 1.85e-01
L04 N03 N04 2.00e-11
R04 N03 N04 4.11e-01
C05 N04 N05 1.14e-10
L05 N04 N05 3.04e-12
R05 N04 N05 3.77e-01
C06 N05 Port2 3.97e-13
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GRT0335C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT0335C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.16e-10
R03 N02 N03 1.80e-01
L04 N03 N04 2.88e-11
R04 N03 N04 2.12e+00
C05 N04 N05 3.62e-12
L05 N04 N05 5.54e-11
R05 N04 N05 2.22e+01
C06 N05 Port2 3.53e-12
L06 N05 Port2 5.15e-11
R06 N05 Port2 1.00e+05
.ENDS GRT0335C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/4[V]
* Murata P/N :GRT033C80G104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80G104KE01 Port1 Port2
C01 Port1 N01 8.92e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.32e-10
R03 N02 N03 3.04e-02
C04 N03 N04 3.75e-07
R04 N03 N04 9.08e+00
C05 N04 N05 8.74e-07
R05 N04 N05 3.73e-01
C06 N05 N06 8.24e-07
R06 N05 N06 3.89e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.57e-01
L08 N07 N08 4.58e-11
R08 N07 N08 7.29e-02
C09 N08 N09 8.02e-08
L09 N08 N09 2.22e-11
R09 N08 N09 1.64e-02
C10 N09 Port2 8.29e-12
L10 N09 Port2 3.03e-11
R10 N09 Port2 3.32e+00
.ENDS GRT033C80G104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-01[uF]/4[V]
* Murata P/N :GRT033C80G224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80G224ME01 Port1 Port2
C01 Port1 N01 1.84e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.34e-10
R03 N02 N03 2.07e-02
C04 N03 N04 3.17e-06
R04 N03 N04 1.13e+00
C05 N04 N05 8.00e-06
R05 N04 N05 4.38e-02
C06 N05 N06 6.03e-06
R06 N05 N06 5.94e-03
L07 N06 N07 1.68e-11
R07 N06 N07 1.24e-01
L08 N07 N08 5.03e-11
R08 N07 N08 5.85e-02
C09 N08 N09 5.85e-08
L09 N08 N09 5.80e-11
R09 N08 N09 1.60e-02
C10 N09 Port2 5.36e-12
L10 N09 Port2 3.71e-11
R10 N09 Port2 4.50e+00
.ENDS GRT033C80G224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J103KE01 Port1 Port2
C01 Port1 N01 9.72e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.82e-10
R03 N02 N03 6.24e-02
C04 N03 N04 9.26e-07
R04 N03 N04 4.30e+03
C05 N04 N05 1.42e-06
R05 N04 N05 3.04e+02
C06 N05 N06 1.34e-06
R06 N05 N06 3.66e+01
C07 N06 N07 1.21e-06
R07 N06 N07 4.50e+00
C08 N07 N08 7.77e-07
R08 N07 N08 7.01e-01
C09 N08 N09 5.43e-07
R09 N08 N09 1.12e-01
L10 N09 N10 3.61e-11
R10 N09 N10 1.79e-01
C11 N10 N11 1.33e-08
L11 N10 N11 1.76e-11
R11 N10 N11 2.94e-02
C12 N11 Port2 7.52e-12
L12 N11 Port2 3.27e-11
R12 N11 Port2 4.60e+00
.ENDS GRT033C80J103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/6.3[V]
* Murata P/N :GRT033C80J104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J104KE01 Port1 Port2
C01 Port1 N01 8.92e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.32e-10
R03 N02 N03 3.04e-02
C04 N03 N04 3.75e-07
R04 N03 N04 9.08e+00
C05 N04 N05 8.74e-07
R05 N04 N05 3.73e-01
C06 N05 N06 8.24e-07
R06 N05 N06 3.89e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.57e-01
L08 N07 N08 4.58e-11
R08 N07 N08 7.29e-02
C09 N08 N09 8.02e-08
L09 N08 N09 2.22e-11
R09 N08 N09 1.64e-02
C10 N09 Port2 8.29e-12
L10 N09 Port2 3.03e-11
R10 N09 Port2 3.32e+00
.ENDS GRT033C80J104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.50e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J153KE01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J153KE01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.43e-10
R03 N02 N03 6.48e-02
C04 N03 N04 6.77e-07
R04 N03 N04 3.72e+00
C05 N04 N05 9.19e-07
R05 N04 N05 4.59e-01
C06 N05 N06 1.44e-06
R06 N05 N06 6.62e-02
C07 N06 N07 1.33e-06
R07 N06 N07 1.85e-02
L08 N07 N08 1.24e-11
R08 N07 N08 1.09e-01
L09 N08 N09 4.95e-11
R09 N08 N09 8.37e-02
C10 N09 Port2 1.58e-12
L10 N09 Port2 8.22e-11
R10 N09 Port2 2.03e+01
.ENDS GRT033C80J153KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.50e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J153ME01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J153ME01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.43e-10
R03 N02 N03 6.48e-02
C04 N03 N04 6.77e-07
R04 N03 N04 3.72e+00
C05 N04 N05 9.19e-07
R05 N04 N05 4.59e-01
C06 N05 N06 1.44e-06
R06 N05 N06 6.62e-02
C07 N06 N07 1.33e-06
R07 N06 N07 1.85e-02
L08 N07 N08 1.24e-11
R08 N07 N08 1.09e-01
L09 N08 N09 4.95e-11
R09 N08 N09 8.37e-02
C10 N09 Port2 1.58e-12
L10 N09 Port2 8.22e-11
R10 N09 Port2 2.03e+01
.ENDS GRT033C80J153ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-03[uF]/6.3[V]
* Murata P/N :GRT033C80J222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J222KE01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.54e-01
C04 N03 N04 2.47e-07
R04 N03 N04 1.20e+04
C05 N04 N05 3.04e-07
R05 N04 N05 1.25e+03
C06 N05 N06 3.28e-07
R06 N05 N06 1.22e+02
C07 N06 N07 2.53e-07
R07 N06 N07 1.99e+01
C08 N07 N08 1.68e-07
R08 N07 N08 3.33e+00
C09 N08 N09 1.41e-07
R09 N08 N09 3.90e-01
C10 N09 N10 1.19e-07
R10 N09 N10 8.96e-02
L11 N10 N11 2.37e-11
R11 N10 N11 3.35e-01
C12 N11 N12 2.39e-09
L12 N11 N12 1.36e-11
R12 N11 N12 8.28e-02
C13 N12 Port2 3.62e-12
L13 N12 Port2 5.74e-11
R13 N12 Port2 1.07e+01
.ENDS GRT033C80J222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J223KE01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.06e-10
R03 N02 N03 3.63e-02
C04 N03 N04 9.22e-07
R04 N03 N04 2.65e+00
C05 N04 N05 1.55e-06
R05 N04 N05 2.15e-01
C06 N05 N06 2.99e-06
R06 N05 N06 3.30e-02
C07 N06 N07 2.21e-06
R07 N06 N07 1.11e-02
L08 N07 N08 4.95e-11
R08 N07 N08 1.41e-01
C09 N08 N09 2.75e-08
L09 N08 N09 2.57e-11
R09 N08 N09 3.44e-02
C10 N09 Port2 1.64e-14
L10 N09 Port2 9.90e-11
R10 N09 Port2 3.20e+01
.ENDS GRT033C80J223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J223ME01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J223ME01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.06e-10
R03 N02 N03 3.63e-02
C04 N03 N04 9.22e-07
R04 N03 N04 2.65e+00
C05 N04 N05 1.55e-06
R05 N04 N05 2.15e-01
C06 N05 N06 2.99e-06
R06 N05 N06 3.30e-02
C07 N06 N07 2.21e-06
R07 N06 N07 1.11e-02
L08 N07 N08 4.95e-11
R08 N07 N08 1.41e-01
C09 N08 N09 2.75e-08
L09 N08 N09 2.57e-11
R09 N08 N09 3.44e-02
C10 N09 Port2 1.64e-14
L10 N09 Port2 9.90e-11
R10 N09 Port2 3.20e+01
.ENDS GRT033C80J223ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT033C80J224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J224KE01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.36e-10
R03 N02 N03 1.66e-02
C04 N03 N04 6.09e-06
R04 N03 N04 4.26e-01
C05 N04 N05 1.13e-05
R05 N04 N05 1.83e-02
C06 N05 N06 1.36e-05
R06 N05 N06 2.42e-03
L07 N06 N07 1.91e-11
R07 N06 N07 1.10e-01
L08 N07 N08 6.08e-11
R08 N07 N08 5.08e-02
C09 N08 N09 1.49e-07
L09 N08 N09 4.57e-11
R09 N08 N09 1.24e-02
C10 N09 Port2 8.11e-12
L10 N09 Port2 2.92e-11
R10 N09 Port2 2.91e+00
.ENDS GRT033C80J224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT033C80J224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J224ME01 Port1 Port2
C01 Port1 N01 1.95e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.55e-10
R03 N02 N03 1.68e-02
C04 N03 N04 5.97e-06
R04 N03 N04 4.04e-01
C05 N04 N05 1.01e-05
R05 N04 N05 1.77e-02
L06 N05 N06 5.61e-11
R06 N05 N06 8.84e-02
C07 N06 N07 1.45e-07
L07 N06 N07 4.41e-11
R07 N06 N07 1.68e-02
C08 N07 Port2 6.56e-12
L08 N07 Port2 2.76e-11
R08 N07 Port2 9.63e-01
.ENDS GRT033C80J224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/3.30e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J333KE01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J333KE01 Port1 Port2
C01 Port1 N01 3.05e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.77e-10
R03 N02 N03 3.21e-02
C04 N03 N04 1.45e-06
R04 N03 N04 1.63e+00
C05 N04 N05 2.23e-06
R05 N04 N05 1.99e-01
C06 N05 N06 2.43e-06
R06 N05 N06 3.05e-02
C07 N06 N07 6.47e-06
R07 N06 N07 2.40e-03
L08 N07 N08 1.02e-11
R08 N07 N08 1.44e-01
L09 N08 N09 4.88e-11
R09 N08 N09 1.06e-01
C10 N09 N10 3.51e-08
L10 N09 N10 2.84e-11
R10 N09 N10 2.65e-02
C11 N10 Port2 1.88e-11
L11 N10 Port2 1.05e-11
R11 N10 Port2 8.12e-01
.ENDS GRT033C80J333KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/3.30e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J333ME01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J333ME01 Port1 Port2
C01 Port1 N01 3.05e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.77e-10
R03 N02 N03 3.21e-02
C04 N03 N04 1.45e-06
R04 N03 N04 1.63e+00
C05 N04 N05 2.23e-06
R05 N04 N05 1.99e-01
C06 N05 N06 2.43e-06
R06 N05 N06 3.05e-02
C07 N06 N07 6.47e-06
R07 N06 N07 2.40e-03
L08 N07 N08 1.02e-11
R08 N07 N08 1.44e-01
L09 N08 N09 4.88e-11
R09 N08 N09 1.06e-01
C10 N09 N10 3.51e-08
L10 N09 N10 2.84e-11
R10 N09 N10 2.65e-02
C11 N10 Port2 1.88e-11
L11 N10 Port2 1.05e-11
R11 N10 Port2 8.12e-01
.ENDS GRT033C80J333ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/4.70e-03[uF]/6.3[V]
* Murata P/N :GRT033C80J472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J472KE01 Port1 Port2
C01 Port1 N01 4.63e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.50e-10
R03 N02 N03 1.11e-01
C04 N03 N04 5.16e-07
R04 N03 N04 6.65e+03
C05 N04 N05 6.81e-07
R05 N04 N05 6.80e+02
C06 N05 N06 6.31e-07
R06 N05 N06 8.56e+01
C07 N06 N07 5.83e-07
R07 N06 N07 1.08e+01
C08 N07 N08 3.74e-07
R08 N07 N08 1.69e+00
C09 N08 N09 2.66e-07
R09 N08 N09 2.22e-01
C10 N09 N10 2.38e-07
R10 N09 N10 3.34e-02
L11 N10 N11 2.33e-11
R11 N10 N11 2.23e-01
C12 N11 N12 2.22e-09
L12 N11 N12 1.88e-11
R12 N11 N12 7.45e-02
C13 N12 Port2 1.90e-12
L13 N12 Port2 8.82e-11
R13 N12 Port2 1.62e+01
.ENDS GRT033C80J472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/4.70e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J473KE01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 2.51e-02
C04 N03 N04 1.90e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.98e-06
R05 N04 N05 1.09e-01
C06 N05 N06 3.40e-06
R06 N05 N06 2.24e-02
L07 N06 N07 1.26e-11
R07 N06 N07 1.09e-01
L08 N07 N08 6.15e-11
R08 N07 N08 7.53e-02
C09 N08 N09 4.63e-07
L09 N08 N09 6.92e-12
R09 N08 N09 6.21e-03
C10 N09 N10 9.34e-08
L10 N09 N10 1.69e-11
R10 N09 N10 1.73e-02
C11 N10 Port2 1.71e-11
L11 N10 Port2 1.15e-11
R11 N10 Port2 5.99e-01
.ENDS GRT033C80J473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/4.70e-02[uF]/6.3[V]
* Murata P/N :GRT033C80J473ME01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J473ME01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 2.51e-02
C04 N03 N04 1.90e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.98e-06
R05 N04 N05 1.09e-01
C06 N05 N06 3.40e-06
R06 N05 N06 2.24e-02
L07 N06 N07 1.26e-11
R07 N06 N07 1.09e-01
L08 N07 N08 6.15e-11
R08 N07 N08 7.53e-02
C09 N08 N09 4.63e-07
L09 N08 N09 6.92e-12
R09 N08 N09 6.21e-03
C10 N09 N10 9.34e-08
L10 N09 N10 1.69e-11
R10 N09 N10 1.73e-02
C11 N10 Port2 1.71e-11
L11 N10 Port2 1.15e-11
R11 N10 Port2 5.99e-01
.ENDS GRT033C80J473ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GRT033C81A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81A104KE01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033C81A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GRT033C81C104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81C104KE01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033C81C104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GRT033C81C104ME01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81C104ME01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033C81C104ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT033C81E102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81E102KE01 Port1 Port2
C01 Port1 N01 9.70e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.62e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.51e-07
R04 N03 N04 4.79e+00
C05 N04 N05 4.62e-08
R05 N04 N05 1.63e+00
C06 N05 N06 3.76e-08
R06 N05 N06 1.92e-01
C07 N06 N07 4.45e-08
R07 N06 N07 5.96e-02
C08 N07 N08 7.67e-09
R08 N07 N08 5.19e-02
C09 N08 N09 2.63e-10
L09 N08 N09 2.75e-11
R09 N08 N09 2.42e-01
C10 N09 N10 5.00e-12
L10 N09 N10 5.80e-11
R10 N09 N10 8.56e+00
C11 N10 Port2 9.00e-12
L11 N10 Port2 3.00e-11
R11 N10 Port2 1.00e+05
.ENDS GRT033C81E102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRT033C81E104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81E104KE01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033C81E104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRT033C81E104ME01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81E104ME01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033C81E104ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT033C81E471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81E471KE01 Port1 Port2
C01 Port1 N01 4.72e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.80e-10
R03 N02 N03 2.80e-01
C04 N03 N04 2.83e-08
R04 N03 N04 2.44e+00
C05 N04 N05 1.52e-08
R05 N04 N05 4.77e-01
C06 N05 N06 2.65e-09
R06 N05 N06 1.50e-01
C07 N06 N07 2.04e-08
R07 N06 N07 1.30e-01
L08 N07 N08 5.89e-11
R08 N07 N08 7.93e-01
C09 N08 N09 1.00e-11
L09 N08 N09 3.00e-11
R09 N08 N09 5.57e+00
C10 N09 Port2 9.00e-12
L10 N09 Port2 3.00e-11
R10 N09 Port2 1.00e+05
.ENDS GRT033C81E471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e+00[uF]/4[V]
* Murata P/N :GRT033R60G105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60G105ME13 Port1 Port2
C01 Port1 N01 8.48e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.36e-10
R03 N02 N03 9.12e-03
C04 N03 N04 6.00e-06
R04 N03 N04 1.17e+03
C05 N04 N05 3.47e-05
R05 N04 N05 8.06e+00
C06 N05 N06 4.11e-05
R06 N05 N06 6.82e-01
C07 N06 N07 3.80e-05
R07 N06 N07 7.36e-02
C08 N07 N08 2.29e-05
R08 N07 N08 1.22e-02
L09 N08 N09 1.38e-11
R09 N08 N09 5.40e-01
L10 N09 N10 2.36e-11
R10 N09 N10 1.34e-01
L11 N10 N11 8.85e-11
R11 N10 N11 3.81e-02
C12 N11 Port2 4.52e-07
L12 N11 Port2 6.20e-11
R12 N11 Port2 8.29e-03
.ENDS GRT033R60G105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J103KE01 Port1 Port2
C01 Port1 N01 9.50e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 5.50e-02
C04 N03 N04 7.14e-07
R04 N03 N04 5.87e+00
C05 N04 N05 7.82e-07
R05 N04 N05 1.20e+00
C06 N05 N06 1.01e-06
R06 N05 N06 2.72e-01
C07 N06 N07 6.37e-07
R07 N06 N07 1.38e-01
C08 N07 N08 6.85e-07
R08 N07 N08 2.38e-02
L09 N08 N09 4.02e-11
R09 N08 N09 1.62e-01
L10 N09 N10 5.07e-12
R10 N09 N10 5.51e-02
C11 N10 N11 1.03e-08
L11 N10 N11 2.05e-11
R11 N10 N11 4.27e-02
C12 N11 N12 7.50e-12
L12 N11 N12 3.40e-11
R12 N11 N12 1.00e+05
C13 N12 Port2 8.00e-12
L13 N12 Port2 2.50e-11
R13 N12 Port2 3.13e+00
.ENDS GRT033R60J103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-01[uF]/6.3[V]
* Murata P/N :GRT033R60J104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J104KE01 Port1 Port2
C01 Port1 N01 8.92e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.32e-10
R03 N02 N03 3.04e-02
C04 N03 N04 3.75e-07
R04 N03 N04 9.08e+00
C05 N04 N05 8.74e-07
R05 N04 N05 3.73e-01
C06 N05 N06 8.24e-07
R06 N05 N06 3.89e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.57e-01
L08 N07 N08 4.58e-11
R08 N07 N08 7.29e-02
C09 N08 N09 8.02e-08
L09 N08 N09 2.22e-11
R09 N08 N09 1.64e-02
C10 N09 Port2 8.29e-12
L10 N09 Port2 3.03e-11
R10 N09 Port2 3.32e+00
.ENDS GRT033R60J104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT033R60J105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J105ME13 Port1 Port2
C01 Port1 N01 7.63e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-02
C04 N03 N04 1.08e-05
R04 N03 N04 1.45e+03
C05 N04 N05 4.46e-05
R05 N04 N05 2.67e+01
C06 N05 N06 4.05e-05
R06 N05 N06 3.78e+00
C07 N06 N07 4.05e-05
R07 N06 N07 3.72e-01
C08 N07 N08 3.11e-05
R08 N07 N08 3.97e-02
C09 N08 N09 4.01e-05
R09 N08 N09 6.37e-03
L10 N09 N10 9.48e-11
R10 N09 N10 4.95e-02
C11 N10 N11 5.73e-07
L11 N10 N11 4.79e-11
R11 N10 N11 7.63e-03
C12 N11 N12 3.38e-10
L12 N11 N12 1.86e-11
R12 N11 N12 1.13e-01
C13 N12 Port2 2.54e-11
L13 N12 Port2 1.03e-11
R13 N12 Port2 1.80e+00
.ENDS GRT033R60J105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.50e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J153KE01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J153KE01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.43e-10
R03 N02 N03 6.48e-02
C04 N03 N04 6.77e-07
R04 N03 N04 3.72e+00
C05 N04 N05 9.19e-07
R05 N04 N05 4.59e-01
C06 N05 N06 1.44e-06
R06 N05 N06 6.62e-02
C07 N06 N07 1.33e-06
R07 N06 N07 1.85e-02
L08 N07 N08 1.24e-11
R08 N07 N08 1.09e-01
L09 N08 N09 4.95e-11
R09 N08 N09 8.37e-02
C10 N09 Port2 1.58e-12
L10 N09 Port2 8.22e-11
R10 N09 Port2 2.03e+01
.ENDS GRT033R60J153KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J223KE01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.06e-10
R03 N02 N03 3.63e-02
C04 N03 N04 9.22e-07
R04 N03 N04 2.65e+00
C05 N04 N05 1.55e-06
R05 N04 N05 2.15e-01
C06 N05 N06 2.99e-06
R06 N05 N06 3.30e-02
C07 N06 N07 2.21e-06
R07 N06 N07 1.11e-02
L08 N07 N08 4.95e-11
R08 N07 N08 1.41e-01
C09 N08 N09 2.75e-08
L09 N08 N09 2.57e-11
R09 N08 N09 3.44e-02
C10 N09 Port2 1.64e-14
L10 N09 Port2 9.90e-11
R10 N09 Port2 3.20e+01
.ENDS GRT033R60J223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT033R60J224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J224KE01 Port1 Port2
C01 Port1 N01 1.84e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.34e-10
R03 N02 N03 2.07e-02
C04 N03 N04 3.17e-06
R04 N03 N04 1.13e+00
C05 N04 N05 8.00e-06
R05 N04 N05 4.38e-02
C06 N05 N06 6.03e-06
R06 N05 N06 5.94e-03
L07 N06 N07 1.68e-11
R07 N06 N07 1.24e-01
L08 N07 N08 5.03e-11
R08 N07 N08 5.85e-02
C09 N08 N09 5.85e-08
L09 N08 N09 5.80e-11
R09 N08 N09 1.60e-02
C10 N09 Port2 5.36e-12
L10 N09 Port2 3.71e-11
R10 N09 Port2 4.50e+00
.ENDS GRT033R60J224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/3.30e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J333KE01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J333KE01 Port1 Port2
C01 Port1 N01 3.05e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.77e-10
R03 N02 N03 3.21e-02
C04 N03 N04 1.45e-06
R04 N03 N04 1.63e+00
C05 N04 N05 2.23e-06
R05 N04 N05 1.99e-01
C06 N05 N06 2.43e-06
R06 N05 N06 3.05e-02
C07 N06 N07 6.47e-06
R07 N06 N07 2.40e-03
L08 N07 N08 1.02e-11
R08 N07 N08 1.44e-01
L09 N08 N09 4.88e-11
R09 N08 N09 1.06e-01
C10 N09 N10 3.51e-08
L10 N09 N10 2.84e-11
R10 N09 N10 2.65e-02
C11 N10 Port2 1.88e-11
L11 N10 Port2 1.05e-11
R11 N10 Port2 8.12e-01
.ENDS GRT033R60J333KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J473KE01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 2.51e-02
C04 N03 N04 1.90e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.98e-06
R05 N04 N05 1.09e-01
C06 N05 N06 3.40e-06
R06 N05 N06 2.24e-02
L07 N06 N07 1.26e-11
R07 N06 N07 1.09e-01
L08 N07 N08 6.15e-11
R08 N07 N08 7.53e-02
C09 N08 N09 4.63e-07
L09 N08 N09 6.92e-12
R09 N08 N09 6.21e-03
C10 N09 N10 9.34e-08
L10 N09 N10 1.69e-11
R10 N09 N10 1.73e-02
C11 N10 Port2 1.71e-11
L11 N10 Port2 1.15e-11
R11 N10 Port2 5.99e-01
.ENDS GRT033R60J473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :GRT033R60J474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J474KE01 Port1 Port2
C01 Port1 N01 3.79e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.65e-10
R03 N02 N03 1.50e-02
C04 N03 N04 4.23e-05
R04 N03 N04 3.77e-01
C05 N04 N05 3.16e-05
R05 N04 N05 3.77e-01
C06 N05 N06 2.02e-05
R06 N05 N06 7.89e-02
C07 N06 N07 2.43e-05
R07 N06 N07 9.37e-03
C08 N07 N08 1.12e-05
R08 N07 N08 1.42e-03
L09 N08 N09 3.42e-11
R09 N08 N09 1.80e-01
L10 N09 N10 7.06e-11
R10 N09 N10 3.37e-02
C11 N10 N11 5.17e-07
L11 N10 N11 3.25e-11
R11 N10 N11 6.65e-03
C12 N11 Port2 3.35e-11
L12 N11 Port2 7.87e-12
R12 N11 Port2 1.19e+00
.ENDS GRT033R60J474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-02[uF]/10[V]
* Murata P/N :GRT033R61A103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A103KE01 Port1 Port2
C01 Port1 N01 9.50e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 5.50e-02
C04 N03 N04 7.14e-07
R04 N03 N04 5.87e+00
C05 N04 N05 7.82e-07
R05 N04 N05 1.20e+00
C06 N05 N06 1.01e-06
R06 N05 N06 2.72e-01
C07 N06 N07 6.37e-07
R07 N06 N07 1.38e-01
C08 N07 N08 6.85e-07
R08 N07 N08 2.38e-02
L09 N08 N09 4.02e-11
R09 N08 N09 1.62e-01
L10 N09 N10 5.07e-12
R10 N09 N10 5.51e-02
C11 N10 N11 1.03e-08
L11 N10 N11 2.05e-11
R11 N10 N11 4.27e-02
C12 N11 N12 7.50e-12
L12 N11 N12 3.40e-11
R12 N11 N12 1.00e+05
C13 N12 Port2 8.00e-12
L13 N12 Port2 2.50e-11
R13 N12 Port2 3.13e+00
.ENDS GRT033R61A103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GRT033R61A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A104KE01 Port1 Port2
C01 Port1 N01 8.92e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.32e-10
R03 N02 N03 3.04e-02
C04 N03 N04 3.75e-07
R04 N03 N04 9.08e+00
C05 N04 N05 8.74e-07
R05 N04 N05 3.73e-01
C06 N05 N06 8.24e-07
R06 N05 N06 3.89e-02
L07 N06 N07 1.69e-11
R07 N06 N07 1.57e-01
L08 N07 N08 4.58e-11
R08 N07 N08 7.29e-02
C09 N08 N09 8.02e-08
L09 N08 N09 2.22e-11
R09 N08 N09 1.64e-02
C10 N09 Port2 8.29e-12
L10 N09 Port2 3.03e-11
R10 N09 Port2 3.32e+00
.ENDS GRT033R61A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-03[uF]/10[V]
* Murata P/N :GRT033R61A222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 300[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A222KE01 Port1 Port2
C01 Port1 N01 2.11e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.13e-07
R04 N03 N04 7.47e+00
C05 N04 N05 1.32e-07
R05 N04 N05 1.85e+00
C06 N05 N06 8.33e-08
R06 N05 N06 3.68e-01
C07 N06 N07 9.30e-08
R07 N06 N07 3.59e-02
C08 N07 N08 4.01e-10
L08 N07 N08 3.01e-11
R08 N07 N08 1.73e-01
C09 N08 N09 9.00e-12
L09 N08 N09 3.00e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 3.50e-12
L10 N09 Port2 6.50e-11
R10 N09 Port2 7.34e+00
.ENDS GRT033R61A222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-02[uF]/10[V]
* Murata P/N :GRT033R61A223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A223KE01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.06e-10
R03 N02 N03 3.63e-02
C04 N03 N04 9.22e-07
R04 N03 N04 2.65e+00
C05 N04 N05 1.55e-06
R05 N04 N05 2.15e-01
C06 N05 N06 2.99e-06
R06 N05 N06 3.30e-02
C07 N06 N07 2.21e-06
R07 N06 N07 1.11e-02
L08 N07 N08 4.95e-11
R08 N07 N08 1.41e-01
C09 N08 N09 2.75e-08
L09 N08 N09 2.57e-11
R09 N08 N09 3.44e-02
C10 N09 Port2 1.64e-14
L10 N09 Port2 9.90e-11
R10 N09 Port2 3.20e+01
.ENDS GRT033R61A223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GRT033R61A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A224KE01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.36e-10
R03 N02 N03 1.66e-02
C04 N03 N04 6.09e-06
R04 N03 N04 4.26e-01
C05 N04 N05 1.13e-05
R05 N04 N05 1.83e-02
C06 N05 N06 1.36e-05
R06 N05 N06 2.42e-03
L07 N06 N07 1.91e-11
R07 N06 N07 1.10e-01
L08 N07 N08 6.08e-11
R08 N07 N08 5.08e-02
C09 N08 N09 1.49e-07
L09 N08 N09 4.57e-11
R09 N08 N09 1.24e-02
C10 N09 Port2 8.11e-12
L10 N09 Port2 2.92e-11
R10 N09 Port2 2.91e+00
.ENDS GRT033R61A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GRT033R61A224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A224ME01 Port1 Port2
C01 Port1 N01 1.85e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.64e-10
R03 N02 N03 2.07e-02
C04 N03 N04 7.65e-06
R04 N03 N04 2.22e-01
C05 N04 N05 2.63e-05
R05 N04 N05 5.94e-02
C06 N05 N06 9.03e-06
R06 N05 N06 1.46e-02
L07 N06 N07 2.20e-11
R07 N06 N07 1.66e-01
L08 N07 N08 4.55e-11
R08 N07 N08 6.14e-02
C09 N08 N09 7.95e-08
L09 N08 N09 4.39e-11
R09 N08 N09 1.61e-02
C10 N09 Port2 1.21e-10
L10 N09 Port2 4.84e-12
R10 N09 Port2 2.73e-01
.ENDS GRT033R61A224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-03[uF]/10[V]
* Murata P/N :GRT033R61A472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A472KE01 Port1 Port2
C01 Port1 N01 4.46e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 9.10e-02
C04 N03 N04 2.07e-07
R04 N03 N04 1.67e+00
C05 N04 N05 1.40e-06
R05 N04 N05 8.02e-01
C06 N05 N06 2.21e-07
R06 N05 N06 1.80e-01
C07 N06 N07 3.42e-07
R07 N06 N07 3.88e-02
L08 N07 N08 1.06e-11
R08 N07 N08 2.00e-01
C09 N08 N09 4.80e-10
L09 N08 N09 4.19e-11
R09 N08 N09 1.41e-01
C10 N09 N10 7.50e-12
L10 N09 N10 3.40e-11
R10 N09 N10 1.00e+05
C11 N10 Port2 6.00e-12
L11 N10 Port2 4.00e-11
R11 N10 Port2 4.83e+00
.ENDS GRT033R61A472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-02[uF]/10[V]
* Murata P/N :GRT033R61A473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A473KE01 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.83e-10
R03 N02 N03 2.51e-02
C04 N03 N04 1.90e-06
R04 N03 N04 1.27e+00
C05 N04 N05 3.98e-06
R05 N04 N05 1.09e-01
C06 N05 N06 3.40e-06
R06 N05 N06 2.24e-02
L07 N06 N07 1.26e-11
R07 N06 N07 1.09e-01
L08 N07 N08 6.15e-11
R08 N07 N08 7.53e-02
C09 N08 N09 4.63e-07
L09 N08 N09 6.92e-12
R09 N08 N09 6.21e-03
C10 N09 N10 9.34e-08
L10 N09 N10 1.69e-11
R10 N09 N10 1.73e-02
C11 N10 Port2 1.71e-11
L11 N10 Port2 1.15e-11
R11 N10 Port2 5.99e-01
.ENDS GRT033R61A473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-02[uF]/16[V]
* Murata P/N :GRT033R61C103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61C103KE01 Port1 Port2
C01 Port1 N01 9.50e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 5.50e-02
C04 N03 N04 7.14e-07
R04 N03 N04 5.87e+00
C05 N04 N05 7.82e-07
R05 N04 N05 1.20e+00
C06 N05 N06 1.01e-06
R06 N05 N06 2.72e-01
C07 N06 N07 6.37e-07
R07 N06 N07 1.38e-01
C08 N07 N08 6.85e-07
R08 N07 N08 2.38e-02
L09 N08 N09 4.02e-11
R09 N08 N09 1.62e-01
L10 N09 N10 5.07e-12
R10 N09 N10 5.51e-02
C11 N10 N11 1.03e-08
L11 N10 N11 2.05e-11
R11 N10 N11 4.27e-02
C12 N11 N12 7.50e-12
L12 N11 N12 3.40e-11
R12 N11 N12 1.00e+05
C13 N12 Port2 8.00e-12
L13 N12 Port2 2.50e-11
R13 N12 Port2 3.13e+00
.ENDS GRT033R61C103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GRT033R61C104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61C104KE01 Port1 Port2
C01 Port1 N01 9.87e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.50e-10
R03 N02 N03 2.73e-02
C04 N03 N04 5.26e-06
R04 N03 N04 1.22e+00
C05 N04 N05 4.13e-05
R05 N04 N05 3.86e-01
C06 N05 N06 8.22e-06
R06 N05 N06 9.76e-02
C07 N06 N07 2.87e-05
R07 N06 N07 6.11e-02
C08 N07 N08 7.55e-05
R08 N07 N08 5.57e-02
C09 N08 N09 8.96e-06
R09 N08 N09 1.78e-02
L10 N09 N10 1.91e-11
R10 N09 N10 3.80e-01
L11 N10 N11 4.87e-11
R11 N10 N11 1.33e-01
C12 N11 N12 5.57e-08
L12 N11 N12 4.08e-11
R12 N11 N12 1.78e-02
C13 N12 N13 3.25e-11
L13 N12 N13 9.83e-12
R13 N12 N13 1.00e+05
C14 N13 Port2 2.88e-11
L14 N13 Port2 9.90e-12
R14 N13 Port2 1.25e+00
.ENDS GRT033R61C104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-02[uF]/16[V]
* Murata P/N :GRT033R61C223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61C223KE01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.89e-10
R03 N02 N03 3.82e-02
C04 N03 N04 8.47e-07
R04 N03 N04 3.30e+00
C05 N04 N05 3.04e-06
R05 N04 N05 1.68e-01
C06 N05 N06 1.94e-06
R06 N05 N06 1.31e-01
C07 N06 N07 1.56e-06
R07 N06 N07 3.29e-02
L08 N07 N08 1.82e-11
R08 N07 N08 1.65e-01
L09 N08 N09 4.42e-11
R09 N08 N09 9.03e-02
C10 N09 N10 3.64e-08
L10 N09 N10 1.84e-11
R10 N09 N10 2.46e-02
C11 N10 Port2 8.35e-11
L11 N10 Port2 6.89e-12
R11 N10 Port2 4.54e-01
.ENDS GRT033R61C223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GRT033R61C473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61C473KE01 Port1 Port2
C01 Port1 N01 4.42e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.83e-10
R03 N02 N03 2.52e-02
C04 N03 N04 1.55e-06
R04 N03 N04 2.38e+00
C05 N04 N05 3.13e-06
R05 N04 N05 1.52e-01
C06 N05 N06 3.49e-06
R06 N05 N06 2.08e-02
L07 N06 N07 1.88e-11
R07 N06 N07 1.89e-01
L08 N07 N08 4.56e-11
R08 N07 N08 7.44e-02
C09 N08 N09 5.13e-08
L09 N08 N09 2.75e-11
R09 N08 N09 2.37e-02
C10 N09 Port2 1.59e-10
L10 N09 Port2 4.25e-12
R10 N09 Port2 2.48e-01
.ENDS GRT033R61C473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GRT033R61E101KE01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 5[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E101KE01 Port1 Port2
C01 Port1 N01 9.60e-11
R01 Port1 N01 1.00e+09
L02 N01 N02 1.45e-10
R03 N02 N03 8.00e-01
C04 N03 N04 4.10e-09
R04 N03 N04 2.59e+00
C05 N04 N05 2.52e-09
R05 N04 N05 9.02e-01
C06 N05 N06 4.86e-10
R06 N05 N06 8.19e-01
L07 N06 N07 1.22e-10
R07 N06 N07 1.34e+01
C08 N07 N08 5.50e-11
L08 N07 N08 6.20e-12
R08 N07 N08 2.45e+00
C09 N08 Port2 3.00e-11
L09 N08 Port2 1.00e-11
R09 N08 Port2 1.00e+05
.ENDS GRT033R61E101KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT033R61E102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E102KE01 Port1 Port2
C01 Port1 N01 9.70e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.62e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.51e-07
R04 N03 N04 4.79e+00
C05 N04 N05 4.62e-08
R05 N04 N05 1.63e+00
C06 N05 N06 3.76e-08
R06 N05 N06 1.92e-01
C07 N06 N07 4.45e-08
R07 N06 N07 5.96e-02
C08 N07 N08 7.67e-09
R08 N07 N08 5.19e-02
C09 N08 N09 2.63e-10
L09 N08 N09 2.75e-11
R09 N08 N09 2.42e-01
C10 N09 N10 5.00e-12
L10 N09 N10 5.80e-11
R10 N09 N10 8.56e+00
C11 N10 Port2 9.00e-12
L11 N10 Port2 3.00e-11
R11 N10 Port2 1.00e+05
.ENDS GRT033R61E102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GRT033R61E103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E103KE01 Port1 Port2
C01 Port1 N01 9.50e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 5.50e-02
C04 N03 N04 7.14e-07
R04 N03 N04 5.87e+00
C05 N04 N05 7.82e-07
R05 N04 N05 1.20e+00
C06 N05 N06 1.01e-06
R06 N05 N06 2.72e-01
C07 N06 N07 6.37e-07
R07 N06 N07 1.38e-01
C08 N07 N08 6.85e-07
R08 N07 N08 2.38e-02
L09 N08 N09 4.02e-11
R09 N08 N09 1.62e-01
L10 N09 N10 5.07e-12
R10 N09 N10 5.51e-02
C11 N10 N11 1.03e-08
L11 N10 N11 2.05e-11
R11 N10 N11 4.27e-02
C12 N11 N12 7.50e-12
L12 N11 N12 3.40e-11
R12 N11 N12 1.00e+05
C13 N12 Port2 8.00e-12
L13 N12 Port2 2.50e-11
R13 N12 Port2 3.13e+00
.ENDS GRT033R61E103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRT033R61E104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E104KE01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033R61E104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GRT033R61E221KE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 2[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E221KE01 Port1 Port2
C01 Port1 N01 2.15e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.65e-10
R03 N02 N03 4.20e-01
C04 N03 N04 9.07e-09
R04 N03 N04 2.51e+00
C05 N04 N05 4.75e-09
R05 N04 N05 4.78e-01
C06 N05 N06 1.15e-09
R06 N05 N06 3.45e-01
L07 N06 N07 5.48e-11
R07 N06 N07 1.81e+00
C08 N07 N08 1.00e-11
L08 N07 N08 3.00e-11
R08 N07 N08 5.57e+00
C09 N08 Port2 9.00e-12
L09 N08 Port2 3.00e-11
R09 N08 Port2 1.00e+05
.ENDS GRT033R61E221KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT033R61E471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E471KE01 Port1 Port2
C01 Port1 N01 4.72e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.80e-10
R03 N02 N03 2.80e-01
C04 N03 N04 2.83e-08
R04 N03 N04 2.44e+00
C05 N04 N05 1.52e-08
R05 N04 N05 4.77e-01
C06 N05 N06 2.65e-09
R06 N05 N06 1.50e-01
C07 N06 N07 2.04e-08
R07 N06 N07 1.30e-01
L08 N07 N08 5.89e-11
R08 N07 N08 7.93e-01
C09 N08 N09 1.00e-11
L09 N08 N09 3.00e-11
R09 N08 N09 5.57e+00
C10 N09 Port2 9.00e-12
L10 N09 Port2 3.00e-11
R10 N09 Port2 1.00e+05
.ENDS GRT033R61E471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GRT033R61E472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61E472KE01 Port1 Port2
C01 Port1 N01 4.43e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 2.24e-10
R03 N02 N03 1.21e-01
C04 N03 N04 1.15e-07
R04 N03 N04 3.48e+01
C05 N04 N05 3.17e-07
R05 N04 N05 2.30e+00
C06 N05 N06 2.46e-07
R06 N05 N06 6.80e-01
C07 N06 N07 2.21e-07
R07 N06 N07 1.27e-01
L08 N07 N08 2.10e-11
R08 N07 N08 2.37e-01
C09 N08 N09 1.28e-09
L09 N08 N09 3.15e-11
R09 N08 N09 9.40e-02
C10 N09 Port2 1.80e-11
L10 N09 Port2 2.00e-11
R10 N09 Port2 4.89e+00
.ENDS GRT033R61E472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-01[uF]/35[V]
* Murata P/N :GRT033R6YA104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R6YA104KE01 Port1 Port2
C01 Port1 N01 8.35e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.58e-10
R03 N02 N03 2.90e-02
C04 N03 N04 9.65e-07
R04 N03 N04 1.17e+01
C05 N04 N05 9.60e-07
R05 N04 N05 1.93e+00
C06 N05 N06 1.78e-06
R06 N05 N06 1.43e-01
C07 N06 N07 1.11e-06
R07 N06 N07 2.21e-02
L08 N07 N08 1.73e-11
R08 N07 N08 3.77e-01
L09 N08 N09 4.44e-11
R09 N08 N09 1.54e-01
C10 N09 N10 1.99e-08
L10 N09 N10 4.78e-11
R10 N09 N10 2.86e-02
C11 N10 Port2 8.02e-10
L11 N10 Port2 8.39e-13
R11 N10 Port2 1.03e-01
.ENDS GRT033R6YA104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/1.00e-02[uF]/6.3[V]
* Murata P/N :GRT033R70J103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R70J103KE01 Port1 Port2
C01 Port1 N01 9.72e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.82e-10
R03 N02 N03 6.24e-02
C04 N03 N04 9.26e-07
R04 N03 N04 4.30e+03
C05 N04 N05 1.42e-06
R05 N04 N05 3.04e+02
C06 N05 N06 1.34e-06
R06 N05 N06 3.66e+01
C07 N06 N07 1.21e-06
R07 N06 N07 4.50e+00
C08 N07 N08 7.77e-07
R08 N07 N08 7.01e-01
C09 N08 N09 5.43e-07
R09 N08 N09 1.12e-01
L10 N09 N10 3.61e-11
R10 N09 N10 1.79e-01
C11 N10 N11 1.33e-08
L11 N10 N11 1.76e-11
R11 N10 N11 2.94e-02
C12 N11 Port2 7.52e-12
L12 N11 Port2 3.27e-11
R12 N11 Port2 4.60e+00
.ENDS GRT033R70J103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/2.20e-03[uF]/6.3[V]
* Murata P/N :GRT033R70J222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R70J222KE01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.54e-01
C04 N03 N04 2.47e-07
R04 N03 N04 1.20e+04
C05 N04 N05 3.04e-07
R05 N04 N05 1.25e+03
C06 N05 N06 3.28e-07
R06 N05 N06 1.22e+02
C07 N06 N07 2.53e-07
R07 N06 N07 1.99e+01
C08 N07 N08 1.68e-07
R08 N07 N08 3.33e+00
C09 N08 N09 1.41e-07
R09 N08 N09 3.90e-01
C10 N09 N10 1.19e-07
R10 N09 N10 8.96e-02
L11 N10 N11 2.37e-11
R11 N10 N11 3.35e-01
C12 N11 N12 2.39e-09
L12 N11 N12 1.36e-11
R12 N11 N12 8.28e-02
C13 N12 Port2 3.62e-12
L13 N12 Port2 5.74e-11
R13 N12 Port2 1.07e+01
.ENDS GRT033R70J222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/4.70e-03[uF]/6.3[V]
* Murata P/N :GRT033R70J472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R70J472KE01 Port1 Port2
C01 Port1 N01 4.63e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.50e-10
R03 N02 N03 1.11e-01
C04 N03 N04 5.16e-07
R04 N03 N04 6.65e+03
C05 N04 N05 6.81e-07
R05 N04 N05 6.80e+02
C06 N05 N06 6.31e-07
R06 N05 N06 8.56e+01
C07 N06 N07 5.83e-07
R07 N06 N07 1.08e+01
C08 N07 N08 3.74e-07
R08 N07 N08 1.69e+00
C09 N08 N09 2.66e-07
R09 N08 N09 2.22e-01
C10 N09 N10 2.38e-07
R10 N09 N10 3.34e-02
L11 N10 N11 2.33e-11
R11 N10 N11 2.23e-01
C12 N11 N12 2.22e-09
L12 N11 N12 1.88e-11
R12 N11 N12 7.45e-02
C13 N12 Port2 1.90e-12
L13 N12 Port2 8.82e-11
R13 N12 Port2 1.62e+01
.ENDS GRT033R70J472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/1.00e-02[uF]/10[V]
* Murata P/N :GRT033R71A103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R71A103KE01 Port1 Port2
C01 Port1 N01 9.50e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 5.50e-02
C04 N03 N04 7.14e-07
R04 N03 N04 5.87e+00
C05 N04 N05 7.82e-07
R05 N04 N05 1.20e+00
C06 N05 N06 1.01e-06
R06 N05 N06 2.72e-01
C07 N06 N07 6.37e-07
R07 N06 N07 1.38e-01
C08 N07 N08 6.85e-07
R08 N07 N08 2.38e-02
L09 N08 N09 4.02e-11
R09 N08 N09 1.62e-01
L10 N09 N10 5.07e-12
R10 N09 N10 5.51e-02
C11 N10 N11 1.03e-08
L11 N10 N11 2.05e-11
R11 N10 N11 4.27e-02
C12 N11 N12 7.50e-12
L12 N11 N12 3.40e-11
R12 N11 N12 1.00e+05
C13 N12 Port2 8.00e-12
L13 N12 Port2 2.50e-11
R13 N12 Port2 3.13e+00
.ENDS GRT033R71A103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT033R71E102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R71E102KE01 Port1 Port2
C01 Port1 N01 9.70e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.62e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.51e-07
R04 N03 N04 4.79e+00
C05 N04 N05 4.62e-08
R05 N04 N05 1.63e+00
C06 N05 N06 3.76e-08
R06 N05 N06 1.92e-01
C07 N06 N07 4.45e-08
R07 N06 N07 5.96e-02
C08 N07 N08 7.67e-09
R08 N07 N08 5.19e-02
C09 N08 N09 2.63e-10
L09 N08 N09 2.75e-11
R09 N08 N09 2.42e-01
C10 N09 N10 5.00e-12
L10 N09 N10 5.80e-11
R10 N09 N10 8.56e+00
C11 N10 Port2 9.00e-12
L11 N10 Port2 3.00e-11
R11 N10 Port2 1.00e+05
.ENDS GRT033R71E102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT033R71E471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R71E471KE01 Port1 Port2
C01 Port1 N01 4.72e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.80e-10
R03 N02 N03 2.80e-01
C04 N03 N04 2.83e-08
R04 N03 N04 2.44e+00
C05 N04 N05 1.52e-08
R05 N04 N05 4.77e-01
C06 N05 N06 2.65e-09
R06 N05 N06 1.50e-01
C07 N06 N07 2.04e-08
R07 N06 N07 1.30e-01
L08 N07 N08 5.89e-11
R08 N07 N08 7.93e-01
C09 N08 N09 1.00e-11
L09 N08 N09 3.00e-11
R09 N08 N09 5.57e+00
C10 N09 Port2 9.00e-12
L10 N09 Port2 3.00e-11
R10 N09 Port2 1.00e+05
.ENDS GRT033R71E471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GRT1555C1E100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1E100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/25[V]
* Murata P/N :GRT1555C1E101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT1555C1E102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GRT1555C1E102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GRT1555C1E120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1E120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/25[V]
* Murata P/N :GRT1555C1E121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1E121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GRT1555C1E150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1E150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/25[V]
* Murata P/N :GRT1555C1E151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GRT1555C1E151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GRT1555C1E180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GRT1555C1E180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/25[V]
* Murata P/N :GRT1555C1E181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1E181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GRT1555C1E220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GRT1555C1E220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/25[V]
* Murata P/N :GRT1555C1E221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GRT1555C1E221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GRT1555C1E270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/25[V]
* Murata P/N :GRT1555C1E271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1E271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/25[V]
* Murata P/N :GRT1555C1E330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/25[V]
* Murata P/N :GRT1555C1E331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GRT1555C1E331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/25[V]
* Murata P/N :GRT1555C1E390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/25[V]
* Murata P/N :GRT1555C1E391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/25[V]
* Murata P/N :GRT1555C1E470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT1555C1E471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/25[V]
* Murata P/N :GRT1555C1E560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GRT1555C1E561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/25[V]
* Murata P/N :GRT1555C1E680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1E680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GRT1555C1E681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GRT1555C1E681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/25[V]
* Murata P/N :GRT1555C1E820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GRT1555C1E820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GRT1555C1E821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1E821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1E821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GRT1555C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GRT1555C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRT1555C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GRT1555C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GRT1555C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GRT1555C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GRT1555C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GRT1555C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GRT1555C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GRT1555C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GRT1555C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GRT1555C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GRT1555C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GRT1555C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GRT1555C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT1555C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GRT1555C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GRT1555C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GRT1555C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GRT1555C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GRT1555C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GRT1555C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GRT1555C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GRT1555C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GRT1555C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GRT1555C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GRT1555C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRT1555C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GRT1555C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GRT1555C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GRT1555C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GRT1555C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GRT1555C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GRT1555C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GRT1555C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GRT1555C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GRT1555C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GRT1555C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GRT1555C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1555C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GRT1555C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GRT1555C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GRT1555C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GRT1555C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRT1555C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GRT1555C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GRT1555C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1555C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GRT1555C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GRT1555C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GRT1555C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GRT1555C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GRT1555C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GRT1555C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GRT1555C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GRT1555C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GRT1555C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GRT1555C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GRT1555C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GRT1555C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GRT1555C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GRT1555C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GRT1555C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1555C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GRT1555C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GRT1555C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GRT1555C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GRT1555C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GRT1555C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GRT1555C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1555C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GRT1555C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7S(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT155C71A105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C71A105KE13 Port1 Port2
C01 Port1 N01 8.59e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.41e-10
R03 N02 N03 8.69e-03
C04 N03 N04 5.52e-06
R04 N03 N04 1.27e+03
C05 N04 N05 2.84e-05
R05 N04 N05 9.72e+00
C06 N05 N06 2.82e-05
R06 N05 N06 9.68e-01
C07 N06 N07 2.15e-05
R07 N06 N07 1.27e-01
C08 N07 N08 1.86e-05
R08 N07 N08 1.53e-02
L09 N08 N09 3.48e-11
R09 N08 N09 1.61e-01
L10 N09 N10 1.32e-10
R10 N09 N10 3.54e-02
C11 N10 N11 1.85e-06
L11 N10 N11 4.48e-11
R11 N10 N11 5.55e-03
C12 N11 N12 1.70e-06
L12 N11 N12 2.36e-11
R12 N11 N12 6.23e-03
C13 N12 Port2 6.58e-12
L13 N12 Port2 4.18e-11
R13 N12 Port2 7.73e+00
.ENDS GRT155C71A105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7S(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT155C71A225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C71A225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C71A225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+01[uF]/2.5[V]
* Murata P/N :GRT155C80E106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80E106ME13 Port1 Port2
C01 Port1 N01 6.79e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.26e-10
R03 N02 N03 4.75e-03
C04 N03 N04 1.84e-04
R04 N03 N04 2.88e+01
C05 N04 N05 3.60e-04
R05 N04 N05 8.57e-01
C06 N05 N06 4.39e-04
R06 N05 N06 6.98e-02
C07 N06 N07 3.48e-04
R07 N06 N07 8.88e-03
C08 N07 N08 1.75e-04
R08 N07 N08 1.75e-03
L09 N08 N09 4.34e-11
R09 N08 N09 2.21e-01
L10 N09 N10 8.98e-11
R10 N09 N10 6.29e-02
L11 N10 N11 1.93e-10
R11 N10 N11 1.60e-02
C12 N11 N12 6.95e-06
L12 N11 N12 9.82e-11
R12 N11 N12 3.17e-03
C13 N12 Port2 1.41e-11
L13 N12 Port2 1.87e-11
R13 N12 Port2 2.24e+00
.ENDS GRT155C80E106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT155C80J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J105KE01 Port1 Port2
C01 Port1 N01 8.36e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 1.04e-02
C04 N03 N04 2.59e-05
R04 N03 N04 2.15e+02
C05 N04 N05 3.92e-05
R05 N04 N05 1.09e+01
C06 N05 N06 4.33e-05
R06 N05 N06 9.62e-01
C07 N06 N07 3.90e-05
R07 N06 N07 1.06e-01
C08 N07 N08 2.26e-05
R08 N07 N08 1.85e-02
L09 N08 N09 3.29e-11
R09 N08 N09 2.81e-01
L10 N09 N10 2.43e-11
R10 N09 N10 6.14e-02
L11 N10 N11 1.22e-10
R11 N10 N11 3.10e-02
C12 N11 N12 8.98e-07
L12 N11 N12 5.27e-11
R12 N11 N12 8.91e-03
C13 N12 Port2 2.52e-12
L13 N12 Port2 7.01e-11
R13 N12 Port2 1.17e+01
.ENDS GRT155C80J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J224KE01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155C80J224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J224ME01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155C80J224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT155C80J225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J225KE01 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 1.02e-02
C04 N03 N04 8.06e-05
R04 N03 N04 6.14e+01
C05 N04 N05 1.25e-04
R05 N04 N05 6.22e+00
C06 N05 N06 1.82e-04
R06 N05 N06 8.78e-01
C07 N06 N07 2.01e-04
R07 N06 N07 1.72e-01
C08 N07 N08 1.57e-04
R08 N07 N08 3.28e-02
C09 N08 N09 9.62e-05
R09 N08 N09 6.65e-03
L10 N09 N10 3.22e-11
R10 N09 N10 2.75e-01
L11 N10 N11 3.31e-11
R11 N10 N11 4.86e-02
L12 N11 N12 1.28e-10
R12 N11 N12 2.32e-02
C13 N12 N13 2.24e-06
L13 N12 N13 5.54e-11
R13 N12 N13 4.59e-03
C14 N13 Port2 2.08e-11
L14 N13 Port2 1.58e-11
R14 N13 Port2 4.09e+00
.ENDS GRT155C80J225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT155C80J225ME01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J225ME01 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 1.02e-02
C04 N03 N04 8.06e-05
R04 N03 N04 6.14e+01
C05 N04 N05 1.25e-04
R05 N04 N05 6.22e+00
C06 N05 N06 1.82e-04
R06 N05 N06 8.78e-01
C07 N06 N07 2.01e-04
R07 N06 N07 1.72e-01
C08 N07 N08 1.57e-04
R08 N07 N08 3.28e-02
C09 N08 N09 9.62e-05
R09 N08 N09 6.65e-03
L10 N09 N10 3.22e-11
R10 N09 N10 2.75e-01
L11 N10 N11 3.31e-11
R11 N10 N11 4.86e-02
L12 N11 N12 1.28e-10
R12 N11 N12 2.32e-02
C13 N12 N13 2.24e-06
L13 N12 N13 5.54e-11
R13 N12 N13 4.59e-03
C14 N13 Port2 2.08e-11
L14 N13 Port2 1.58e-11
R14 N13 Port2 4.09e+00
.ENDS GRT155C80J225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/3.30e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J334KE01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J334KE01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155C80J334KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/3.30e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J334ME01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J334ME01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155C80J334ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J474KE01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155C80J474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :GRT155C80J474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J474ME01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155C80J474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT155C80J475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80J475ME13 Port1 Port2
C01 Port1 N01 3.82e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.54e-10
R03 N02 N03 6.18e-03
C04 N03 N04 3.78e-04
R04 N03 N04 1.10e+01
C05 N04 N05 4.50e-04
R05 N04 N05 1.40e+00
C06 N05 N06 4.46e-04
R06 N05 N06 2.31e-01
C07 N06 N07 5.30e-04
R07 N06 N07 3.42e-02
C08 N07 N08 3.45e-04
R08 N07 N08 5.80e-03
L09 N08 N09 4.22e-11
R09 N08 N09 1.96e-01
L10 N09 N10 5.14e-11
R10 N09 N10 3.31e-02
L11 N10 N11 1.42e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.14e-06
L12 N11 N12 1.24e-10
R12 N11 N12 5.30e-03
C13 N12 Port2 2.09e-11
L13 N12 Port2 1.19e-11
R13 N12 Port2 1.76e+00
.ENDS GRT155C80J475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT155C81A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81A105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GRT155C81A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT155C81A225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81A225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C81A225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT155C81A225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81A225ME13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C81A225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT155C81C105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C105KE13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155C81C105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT155C81C105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155C81C105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT155C81C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C81C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT155C81C225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C225ME13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C81C225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRT155C81C474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155C81C474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRT155C81C474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81C474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155C81C474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT155C81E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81E105KE13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155C81E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT155C81E105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81E105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155C81E105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRT155C81E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81E224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155C81E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRT155C81E224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C81E224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155C81E224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GRT155C8YA224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C8YA224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155C8YA224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GRT155C8YA224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C8YA224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155C8YA224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e+00[uF]/4[V]
* Murata P/N :GRT155R60G475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60G475ME13 Port1 Port2
C01 Port1 N01 3.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.65e-10
R03 N02 N03 5.60e-03
C04 N03 N04 2.12e-04
R04 N03 N04 2.60e+01
C05 N04 N05 3.05e-04
R05 N04 N05 3.47e+00
C06 N05 N06 2.77e-04
R06 N05 N06 5.91e-01
C07 N06 N07 3.50e-04
R07 N06 N07 7.02e-02
C08 N07 N08 3.17e-04
R08 N07 N08 1.06e-02
C09 N08 N09 3.46e-04
R09 N08 N09 1.79e-03
L10 N09 N10 4.28e-11
R10 N09 N10 4.30e-02
L11 N10 N11 1.90e-10
R11 N10 N11 1.88e-02
C12 N11 N12 6.98e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.05e-03
C13 N12 N13 1.72e-10
L13 N12 N13 2.36e-11
R13 N12 N13 1.42e-01
C14 N13 Port2 1.14e-11
L14 N13 Port2 2.22e-11
R14 N13 Port2 3.31e+00
.ENDS GRT155R60G475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT155R60J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J105KE01 Port1 Port2
C01 Port1 N01 8.36e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 1.04e-02
C04 N03 N04 2.59e-05
R04 N03 N04 2.15e+02
C05 N04 N05 3.92e-05
R05 N04 N05 1.09e+01
C06 N05 N06 4.33e-05
R06 N05 N06 9.62e-01
C07 N06 N07 3.90e-05
R07 N06 N07 1.06e-01
C08 N07 N08 2.26e-05
R08 N07 N08 1.85e-02
L09 N08 N09 3.29e-11
R09 N08 N09 2.81e-01
L10 N09 N10 2.43e-11
R10 N09 N10 6.14e-02
L11 N10 N11 1.22e-10
R11 N10 N11 3.10e-02
C12 N11 N12 8.98e-07
L12 N11 N12 5.27e-11
R12 N11 N12 8.91e-03
C13 N12 Port2 2.52e-12
L13 N12 Port2 7.01e-11
R13 N12 Port2 1.17e+01
.ENDS GRT155R60J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J224KE01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155R60J224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J224ME01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155R60J224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT155R60J225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J225KE01 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.16e-10
R03 N02 N03 1.22e-02
C04 N03 N04 3.80e-05
R04 N03 N04 1.46e+02
C05 N04 N05 6.07e-05
R05 N04 N05 9.07e+00
C06 N05 N06 9.06e-05
R06 N05 N06 6.16e-01
C07 N06 N07 9.72e-05
R07 N06 N07 5.66e-02
C08 N07 N08 4.65e-05
R08 N07 N08 1.18e-02
L09 N08 N09 5.44e-11
R09 N08 N09 3.11e-01
L10 N09 N10 9.06e-11
R10 N09 N10 4.09e-02
C11 N10 N11 3.11e-07
L11 N10 N11 1.40e-10
R11 N10 N11 7.62e-03
C12 N11 Port2 2.61e-12
L12 N11 Port2 7.06e-11
R12 N11 Port2 2.46e+02
.ENDS GRT155R60J225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT155R60J225ME01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J225ME01 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 1.02e-02
C04 N03 N04 8.06e-05
R04 N03 N04 6.14e+01
C05 N04 N05 1.25e-04
R05 N04 N05 6.22e+00
C06 N05 N06 1.82e-04
R06 N05 N06 8.78e-01
C07 N06 N07 2.01e-04
R07 N06 N07 1.72e-01
C08 N07 N08 1.57e-04
R08 N07 N08 3.28e-02
C09 N08 N09 9.62e-05
R09 N08 N09 6.65e-03
L10 N09 N10 3.22e-11
R10 N09 N10 2.75e-01
L11 N10 N11 3.31e-11
R11 N10 N11 4.86e-02
L12 N11 N12 1.28e-10
R12 N11 N12 2.32e-02
C13 N12 N13 2.24e-06
L13 N12 N13 5.54e-11
R13 N12 N13 4.59e-03
C14 N13 Port2 2.08e-11
L14 N13 Port2 1.58e-11
R14 N13 Port2 4.09e+00
.ENDS GRT155R60J225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/3.30e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J334KE01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J334KE01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155R60J334KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/3.30e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J334ME01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J334ME01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155R60J334ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J474KE01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155R60J474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J474ME01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155R60J474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT155R60J475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J475ME13 Port1 Port2
C01 Port1 N01 3.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.65e-10
R03 N02 N03 5.60e-03
C04 N03 N04 2.12e-04
R04 N03 N04 2.60e+01
C05 N04 N05 3.05e-04
R05 N04 N05 3.47e+00
C06 N05 N06 2.77e-04
R06 N05 N06 5.91e-01
C07 N06 N07 3.50e-04
R07 N06 N07 7.02e-02
C08 N07 N08 3.17e-04
R08 N07 N08 1.06e-02
C09 N08 N09 3.46e-04
R09 N08 N09 1.79e-03
L10 N09 N10 4.28e-11
R10 N09 N10 4.30e-02
L11 N10 N11 1.90e-10
R11 N10 N11 1.88e-02
C12 N11 N12 6.98e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.05e-03
C13 N12 N13 1.72e-10
L13 N12 N13 2.36e-11
R13 N12 N13 1.42e-01
C14 N13 Port2 1.14e-11
L14 N13 Port2 2.22e-11
R14 N13 Port2 3.31e+00
.ENDS GRT155R60J475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/6.80e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J684KE01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J684KE01 Port1 Port2
C01 Port1 N01 6.23e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.01e-10
R03 N02 N03 9.73e-03
C04 N03 N04 3.78e-05
R04 N03 N04 1.29e-01
C05 N04 N05 5.86e-05
R05 N04 N05 6.77e-03
L06 N05 N06 3.30e-11
R06 N05 N06 1.79e-01
L07 N06 N07 1.14e-10
R07 N06 N07 4.07e-02
C08 N07 N08 6.77e-07
L08 N07 N08 5.70e-11
R08 N07 N08 9.02e-03
C09 N08 Port2 1.62e-11
L09 N08 Port2 2.03e-11
R09 N08 Port2 9.97e-01
.ENDS GRT155R60J684KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/6.80e-01[uF]/6.3[V]
* Murata P/N :GRT155R60J684ME01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J684ME01 Port1 Port2
C01 Port1 N01 6.23e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.01e-10
R03 N02 N03 9.73e-03
C04 N03 N04 3.78e-05
R04 N03 N04 1.29e-01
C05 N04 N05 5.86e-05
R05 N04 N05 6.77e-03
L06 N05 N06 3.30e-11
R06 N05 N06 1.79e-01
L07 N06 N07 1.14e-10
R07 N06 N07 4.07e-02
C08 N07 N08 6.77e-07
L08 N07 N08 5.70e-11
R08 N07 N08 9.02e-03
C09 N08 Port2 1.62e-11
L09 N08 Port2 2.03e-11
R09 N08 Port2 9.97e-01
.ENDS GRT155R60J684ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT155R61A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A105KE01 Port1 Port2
C01 Port1 N01 7.82e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.56e-11
R03 N02 N03 1.42e-02
C04 N03 N04 4.37e-06
R04 N03 N04 1.71e+03
C05 N04 N05 3.28e-05
R05 N04 N05 1.46e+01
C06 N05 N06 3.38e-05
R06 N05 N06 1.33e+00
C07 N06 N07 3.14e-05
R07 N06 N07 1.48e-01
C08 N07 N08 2.09e-05
R08 N07 N08 2.27e-02
L09 N08 N09 3.38e-11
R09 N08 N09 1.41e-01
L10 N09 N10 1.10e-10
R10 N09 N10 4.24e-02
C11 N10 N11 5.33e-07
L11 N10 N11 8.71e-11
R11 N10 N11 1.33e-02
C12 N11 Port2 7.86e-13
L12 N11 Port2 1.63e-10
R12 N11 Port2 4.30e+01
.ENDS GRT155R61A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GRT155R61A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A224KE01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155R61A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GRT155R61A224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A224ME01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.21e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.16e-05
R04 N03 N04 2.60e-01
C05 N04 N05 1.63e-05
R05 N04 N05 1.73e-02
L06 N05 N06 2.77e-11
R06 N05 N06 1.32e-01
L07 N06 N07 1.09e-10
R07 N06 N07 5.56e-02
C08 N07 N08 1.44e-06
L08 N07 N08 1.49e-11
R08 N07 N08 4.61e-03
C09 N08 N09 5.49e-07
L09 N08 N09 1.96e-11
R09 N08 N09 8.07e-03
C10 N09 Port2 2.10e-11
L10 N09 Port2 1.57e-11
R10 N09 Port2 2.83e+00
.ENDS GRT155R61A224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT155R61A225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A225KE01 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.16e-10
R03 N02 N03 1.22e-02
C04 N03 N04 3.80e-05
R04 N03 N04 1.46e+02
C05 N04 N05 6.07e-05
R05 N04 N05 9.07e+00
C06 N05 N06 9.06e-05
R06 N05 N06 6.16e-01
C07 N06 N07 9.72e-05
R07 N06 N07 5.66e-02
C08 N07 N08 4.65e-05
R08 N07 N08 1.18e-02
L09 N08 N09 5.44e-11
R09 N08 N09 3.11e-01
L10 N09 N10 9.06e-11
R10 N09 N10 4.09e-02
C11 N10 N11 3.11e-07
L11 N10 N11 1.40e-10
R11 N10 N11 7.62e-03
C12 N11 Port2 2.61e-12
L12 N11 Port2 7.06e-11
R12 N11 Port2 2.46e+02
.ENDS GRT155R61A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT155R61A225ME01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A225ME01 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 1.02e-02
C04 N03 N04 8.06e-05
R04 N03 N04 6.14e+01
C05 N04 N05 1.25e-04
R05 N04 N05 6.22e+00
C06 N05 N06 1.82e-04
R06 N05 N06 8.78e-01
C07 N06 N07 2.01e-04
R07 N06 N07 1.72e-01
C08 N07 N08 1.57e-04
R08 N07 N08 3.28e-02
C09 N08 N09 9.62e-05
R09 N08 N09 6.65e-03
L10 N09 N10 3.22e-11
R10 N09 N10 2.75e-01
L11 N10 N11 3.31e-11
R11 N10 N11 4.86e-02
L12 N11 N12 1.28e-10
R12 N11 N12 2.32e-02
C13 N12 N13 2.24e-06
L13 N12 N13 5.54e-11
R13 N12 N13 4.59e-03
C14 N13 Port2 2.08e-11
L14 N13 Port2 1.58e-11
R14 N13 Port2 4.09e+00
.ENDS GRT155R61A225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/3.30e-01[uF]/10[V]
* Murata P/N :GRT155R61A334KE01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A334KE01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155R61A334KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/3.30e-01[uF]/10[V]
* Murata P/N :GRT155R61A334ME01
* Property : C = 3.30e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A334ME01 Port1 Port2
C01 Port1 N01 3.10e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.16e-10
R03 N02 N03 1.37e-02
C04 N03 N04 2.33e-05
R04 N03 N04 1.08e-01
C05 N04 N05 2.57e-05
R05 N04 N05 1.37e-02
L06 N05 N06 9.08e-12
R06 N05 N06 1.89e-01
L07 N06 N07 2.74e-11
R07 N06 N07 9.50e-02
L08 N07 N08 1.06e-10
R08 N07 N08 4.19e-02
C09 N08 N09 2.98e-06
L09 N08 N09 1.17e-11
R09 N08 N09 4.44e-03
C10 N09 N10 7.94e-07
L10 N09 N10 2.21e-11
R10 N09 N10 9.18e-03
C11 N10 Port2 1.57e-11
L11 N10 Port2 2.04e-11
R11 N10 Port2 4.13e+00
.ENDS GRT155R61A334ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/10[V]
* Murata P/N :GRT155R61A474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A474KE01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155R61A474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/10[V]
* Murata P/N :GRT155R61A474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A474ME01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.12e-02
C04 N03 N04 3.32e-05
R04 N03 N04 9.70e-02
C05 N04 N05 3.68e-05
R05 N04 N05 1.21e-02
L06 N05 N06 1.00e-11
R06 N05 N06 1.69e-01
L07 N06 N07 2.75e-11
R07 N06 N07 9.99e-02
L08 N07 N08 1.27e-10
R08 N07 N08 4.20e-02
C09 N08 N09 2.91e-06
L09 N08 N09 1.53e-11
R09 N08 N09 3.68e-03
C10 N09 N10 1.02e-06
L10 N09 N10 2.60e-11
R10 N09 N10 7.05e-03
C11 N10 Port2 2.41e-11
L11 N10 Port2 1.28e-11
R11 N10 Port2 2.00e+00
.ENDS GRT155R61A474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRT155R61A475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A475ME13 Port1 Port2
C01 Port1 N01 3.82e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.54e-10
R03 N02 N03 6.18e-03
C04 N03 N04 3.78e-04
R04 N03 N04 1.10e+01
C05 N04 N05 4.50e-04
R05 N04 N05 1.40e+00
C06 N05 N06 4.46e-04
R06 N05 N06 2.31e-01
C07 N06 N07 5.30e-04
R07 N06 N07 3.42e-02
C08 N07 N08 3.45e-04
R08 N07 N08 5.80e-03
L09 N08 N09 4.22e-11
R09 N08 N09 1.96e-01
L10 N09 N10 5.14e-11
R10 N09 N10 3.31e-02
L11 N10 N11 1.42e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.14e-06
L12 N11 N12 1.24e-10
R12 N11 N12 5.30e-03
C13 N12 Port2 2.09e-11
L13 N12 Port2 1.19e-11
R13 N12 Port2 1.76e+00
.ENDS GRT155R61A475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/6.80e-01[uF]/10[V]
* Murata P/N :GRT155R61A684KE01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A684KE01 Port1 Port2
C01 Port1 N01 6.23e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.01e-10
R03 N02 N03 9.73e-03
C04 N03 N04 3.78e-05
R04 N03 N04 1.29e-01
C05 N04 N05 5.86e-05
R05 N04 N05 6.77e-03
L06 N05 N06 3.30e-11
R06 N05 N06 1.79e-01
L07 N06 N07 1.14e-10
R07 N06 N07 4.07e-02
C08 N07 N08 6.77e-07
L08 N07 N08 5.70e-11
R08 N07 N08 9.02e-03
C09 N08 Port2 1.62e-11
L09 N08 Port2 2.03e-11
R09 N08 Port2 9.97e-01
.ENDS GRT155R61A684KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/6.80e-01[uF]/10[V]
* Murata P/N :GRT155R61A684ME01
* Property : C = 6.80e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61A684ME01 Port1 Port2
C01 Port1 N01 6.23e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.01e-10
R03 N02 N03 9.73e-03
C04 N03 N04 3.78e-05
R04 N03 N04 1.29e-01
C05 N04 N05 5.86e-05
R05 N04 N05 6.77e-03
L06 N05 N06 3.30e-11
R06 N05 N06 1.79e-01
L07 N06 N07 1.14e-10
R07 N06 N07 4.07e-02
C08 N07 N08 6.77e-07
L08 N07 N08 5.70e-11
R08 N07 N08 9.02e-03
C09 N08 Port2 1.62e-11
L09 N08 Port2 2.03e-11
R09 N08 Port2 9.97e-01
.ENDS GRT155R61A684ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT155R61C105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61C105KE01 Port1 Port2
C01 Port1 N01 6.61e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 9.93e-11
R03 N02 N03 1.12e-02
C04 N03 N04 2.55e-06
R04 N03 N04 2.74e+03
C05 N04 N05 1.19e-05
R05 N04 N05 2.54e+01
C06 N05 N06 1.25e-05
R06 N05 N06 2.42e+00
C07 N06 N07 9.90e-06
R07 N06 N07 2.95e-01
C08 N07 N08 7.19e-06
R08 N07 N08 3.13e-02
L09 N08 N09 3.54e-11
R09 N08 N09 1.48e-01
L10 N09 N10 1.21e-10
R10 N09 N10 3.60e-02
C11 N10 N11 1.95e-06
L11 N10 N11 2.54e-11
R11 N10 N11 5.15e-03
C12 N11 N12 1.30e-06
L12 N11 N12 2.16e-11
R12 N11 N12 5.51e-03
C13 N12 Port2 1.40e-12
L13 N12 Port2 9.72e-11
R13 N12 Port2 1.85e+01
.ENDS GRT155R61C105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRT155R61C224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61C224KE01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.05e-10
R03 N02 N03 1.84e-02
C04 N03 N04 1.07e-06
R04 N03 N04 2.75e+00
C05 N04 N05 3.54e-06
R05 N04 N05 7.95e-02
C06 N05 N06 2.09e-06
R06 N05 N06 2.48e-02
L07 N06 N07 1.75e-11
R07 N06 N07 1.02e-01
L08 N07 N08 9.10e-11
R08 N07 N08 7.76e-02
C09 N08 N09 6.65e-07
L09 N08 N09 1.70e-11
R09 N08 N09 7.72e-03
C10 N09 N10 2.19e-07
L10 N09 N10 2.85e-11
R10 N09 N10 1.47e-02
C11 N10 Port2 1.53e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 3.37e+01
.ENDS GRT155R61C224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT155R61C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61C225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155R61C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRT155R61C474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61C474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R61C474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRT155R61C474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61C474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R61C474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT155R61E105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GRT155R61E105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRT155R61E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155R61E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRT155R61E224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155R61E224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT155R61E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155R61E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRT155R61E474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R61E474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRT155R61E474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R61E474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R61E474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRT155R6YA105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA105KE13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155R6YA105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRT155R6YA105ME13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA105ME13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GRT155R6YA105ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GRT155R6YA224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155R6YA224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e-01[uF]/35[V]
* Murata P/N :GRT155R6YA224ME01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA224ME01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155R6YA224ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GRT155R6YA474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R6YA474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e-01[uF]/35[V]
* Murata P/N :GRT155R6YA474ME01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R6YA474ME01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R6YA474ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e+00[uF]/4[V]
* Murata P/N :GRT155R70G105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R70G105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GRT155R70G105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT155R70J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R70J105KE01 Port1 Port2
C01 Port1 N01 5.34e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.67e-10
R03 N02 N03 1.07e-02
C04 N03 N04 1.55e-05
R04 N03 N04 1.19e+02
C05 N04 N05 1.45e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.35e+00
C07 N06 N07 1.20e-05
R07 N06 N07 1.71e-01
C08 N07 N08 7.58e-06
R08 N07 N08 2.53e-02
L09 N08 N09 2.56e-11
R09 N08 N09 4.36e-01
L10 N09 N10 2.22e-11
R10 N09 N10 5.47e-02
L11 N10 N11 1.26e-10
R11 N10 N11 3.70e-02
C12 N11 N12 2.95e-06
L12 N11 N12 1.63e-11
R12 N11 N12 4.03e-03
C13 N12 N13 1.86e-06
L13 N12 N13 1.54e-11
R13 N12 N13 6.00e-03
C14 N13 Port2 2.96e-11
L14 N13 Port2 7.20e-12
R14 N13 Port2 1.09e+00
.ENDS GRT155R70J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/6.3[V]
* Murata P/N :GRT155R70J223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R70J223KE01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.35e-10
R03 N02 N03 4.51e-02
C04 N03 N04 2.79e-06
R04 N03 N04 2.89e+00
C05 N04 N05 8.15e-06
R05 N04 N05 1.95e+00
C06 N05 N06 2.00e-06
R06 N05 N06 7.93e-01
C07 N06 N07 1.80e-06
R07 N06 N07 1.92e-01
C08 N07 N08 2.31e-06
R08 N07 N08 4.67e-02
C09 N08 N09 1.02e-06
R09 N08 N09 1.90e-02
L10 N09 N10 5.66e-11
R10 N09 N10 1.51e-01
L11 N10 N11 3.81e-12
R11 N10 N11 1.30e-01
C12 N11 N12 1.75e-08
L12 N11 N12 4.06e-11
R12 N11 N12 4.05e-02
C13 N12 Port2 1.71e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 2.50e+01
.ENDS GRT155R70J223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :GRT155R71A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71A224KE01 Port1 Port2
C01 Port1 N01 1.37e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.44e-10
R03 N02 N03 1.65e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.80e+00
C05 N04 N05 3.01e-06
R05 N04 N05 8.31e-02
C06 N05 N06 2.16e-06
R06 N05 N06 2.22e-02
L07 N06 N07 2.55e-11
R07 N06 N07 2.19e-01
L08 N07 N08 1.34e-10
R08 N07 N08 6.69e-02
C09 N08 N09 1.58e-06
L09 N08 N09 7.07e-12
R09 N08 N09 6.37e-03
C10 N09 N10 5.41e-07
L10 N09 N10 1.11e-11
R10 N09 N10 1.09e-02
C11 N10 Port2 2.55e-12
L11 N10 Port2 8.73e-11
R11 N10 Port2 1.95e+01
.ENDS GRT155R71A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-01[uF]/10[V]
* Murata P/N :GRT155R71A474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71A474KE01 Port1 Port2
C01 Port1 N01 2.59e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.21e-11
R03 N02 N03 1.40e-02
C04 N03 N04 3.19e-06
R04 N03 N04 7.65e-01
C05 N04 N05 6.81e-06
R05 N04 N05 4.77e-02
C06 N05 N06 4.48e-06
R06 N05 N06 1.51e-02
L07 N06 N07 2.56e-11
R07 N06 N07 1.41e-01
L08 N07 N08 1.11e-10
R08 N07 N08 5.61e-02
C09 N08 N09 1.59e-06
L09 N08 N09 1.64e-11
R09 N08 N09 6.04e-03
C10 N09 N10 5.16e-07
L10 N09 N10 2.30e-11
R10 N09 N10 1.05e-02
C11 N10 Port2 1.08e-12
L11 N10 Port2 1.67e-10
R11 N10 Port2 7.85e+01
.ENDS GRT155R71A474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/16[V]
* Murata P/N :GRT155R71C103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71C103KE01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 7.41e-02
C04 N03 N04 1.44e-06
R04 N03 N04 2.16e+00
C05 N04 N05 7.19e-07
R05 N04 N05 7.49e-01
C06 N05 N06 5.43e-07
R06 N05 N06 1.70e-01
C07 N06 N07 2.88e-07
R07 N06 N07 3.69e-02
L08 N07 N08 5.57e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.22e-08
L09 N08 N09 2.08e-11
R09 N08 N09 4.36e-02
C10 N09 Port2 2.00e-12
L10 N09 Port2 1.49e-10
R10 N09 Port2 2.06e+01
.ENDS GRT155R71C103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GRT155R71C104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71C104KE01 Port1 Port2
C01 Port1 N01 9.50e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.90e-10
R03 N02 N03 1.58e-02
C04 N03 N04 1.49e-05
R04 N03 N04 1.07e+00
C05 N04 N05 9.35e-06
R05 N04 N05 5.25e-01
C06 N05 N06 7.51e-06
R06 N05 N06 1.73e-01
C07 N06 N07 1.08e-05
R07 N06 N07 2.39e-02
C08 N07 N08 9.01e-06
R08 N07 N08 1.08e-02
L09 N08 N09 1.51e-11
R09 N08 N09 2.10e-01
L10 N09 N10 3.56e-11
R10 N09 N10 6.09e-02
L11 N10 N11 7.23e-11
R11 N10 N11 3.97e-02
C12 N11 N12 4.94e-07
L12 N11 N12 1.70e-11
R12 N11 N12 8.29e-03
C13 N12 N13 2.03e-07
L13 N12 N13 2.31e-11
R13 N12 N13 1.69e-02
C14 N13 Port2 8.84e-12
L14 N13 Port2 3.54e-11
R14 N13 Port2 6.00e+00
.ENDS GRT155R71C104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/16[V]
* Murata P/N :GRT155R71C223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71C223KE01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.35e-10
R03 N02 N03 4.51e-02
C04 N03 N04 2.79e-06
R04 N03 N04 2.89e+00
C05 N04 N05 8.15e-06
R05 N04 N05 1.95e+00
C06 N05 N06 2.00e-06
R06 N05 N06 7.93e-01
C07 N06 N07 1.80e-06
R07 N06 N07 1.92e-01
C08 N07 N08 2.31e-06
R08 N07 N08 4.67e-02
C09 N08 N09 1.02e-06
R09 N08 N09 1.90e-02
L10 N09 N10 5.66e-11
R10 N09 N10 1.51e-01
L11 N10 N11 3.81e-12
R11 N10 N11 1.30e-01
C12 N11 N12 1.75e-08
L12 N11 N12 4.06e-11
R12 N11 N12 4.05e-02
C13 N12 Port2 1.71e-12
L13 N12 Port2 1.61e-10
R13 N12 Port2 2.50e+01
.ENDS GRT155R71C223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRT155R71C224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71C224KE01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.05e-10
R03 N02 N03 1.84e-02
C04 N03 N04 1.07e-06
R04 N03 N04 2.75e+00
C05 N04 N05 3.54e-06
R05 N04 N05 7.95e-02
C06 N05 N06 2.09e-06
R06 N05 N06 2.48e-02
L07 N06 N07 1.75e-11
R07 N06 N07 1.02e-01
L08 N07 N08 9.10e-11
R08 N07 N08 7.76e-02
C09 N08 N09 6.65e-07
L09 N08 N09 1.70e-11
R09 N08 N09 7.72e-03
C10 N09 N10 2.19e-07
L10 N09 N10 2.85e-11
R10 N09 N10 1.47e-02
C11 N10 Port2 1.53e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 3.37e+01
.ENDS GRT155R71C224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GRT155R71C473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71C473KE01 Port1 Port2
C01 Port1 N01 4.57e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 2.33e-02
C04 N03 N04 3.83e-06
R04 N03 N04 1.65e+00
C05 N04 N05 3.30e-06
R05 N04 N05 2.99e-01
C06 N05 N06 4.01e-06
R06 N05 N06 4.18e-02
C07 N06 N07 4.58e-06
R07 N06 N07 1.14e-02
L08 N07 N08 1.67e-11
R08 N07 N08 2.90e-01
L09 N08 N09 7.54e-11
R09 N08 N09 1.10e-01
C10 N09 N10 1.46e-06
L10 N09 N10 2.84e-12
R10 N09 N10 5.76e-03
C11 N10 N11 5.18e-08
L11 N10 N11 3.82e-11
R11 N10 N11 3.32e-02
C12 N11 N12 2.94e-11
L12 N11 N12 1.29e-11
R12 N11 N12 2.12e+00
C13 N12 Port2 4.57e-12
L13 N12 Port2 6.25e-11
R13 N12 Port2 2.85e+01
.ENDS GRT155R71C473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GRT155R71E103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71E103KE01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.60e-10
R03 N02 N03 7.41e-02
C04 N03 N04 1.44e-06
R04 N03 N04 2.16e+00
C05 N04 N05 7.19e-07
R05 N04 N05 7.49e-01
C06 N05 N06 5.43e-07
R06 N05 N06 1.70e-01
C07 N06 N07 2.88e-07
R07 N06 N07 3.69e-02
L08 N07 N08 5.57e-11
R08 N07 N08 1.83e-01
C09 N08 N09 1.22e-08
L09 N08 N09 2.08e-11
R09 N08 N09 4.36e-02
C10 N09 Port2 2.00e-12
L10 N09 Port2 1.49e-10
R10 N09 Port2 2.06e+01
.ENDS GRT155R71E103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRT155R71E104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71E104KE01 Port1 Port2
C01 Port1 N01 9.09e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.20e-10
R03 N02 N03 1.44e-02
C04 N03 N04 4.94e-06
R04 N03 N04 4.13e-01
C05 N04 N05 7.71e-06
R05 N04 N05 3.89e-02
C06 N05 N06 9.53e-06
R06 N05 N06 7.15e-03
L07 N06 N07 1.30e-11
R07 N06 N07 8.90e-02
L08 N07 N08 9.65e-11
R08 N07 N08 6.74e-02
C09 N08 N09 6.50e-07
L09 N08 N09 1.23e-11
R09 N08 N09 1.12e-02
C10 N09 N10 1.85e-07
L10 N09 N10 2.10e-11
R10 N09 N10 2.12e-02
C11 N10 Port2 2.31e-12
L11 N10 Port2 8.12e-11
R11 N10 Port2 1.94e+01
.ENDS GRT155R71E104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GRT155R71E223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71E223KE01 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.62e-10
R03 N02 N03 4.45e-02
C04 N03 N04 2.74e-06
R04 N03 N04 3.05e+00
C05 N04 N05 2.03e-06
R05 N04 N05 9.08e-01
C06 N05 N06 1.33e-06
R06 N05 N06 2.19e-01
C07 N06 N07 1.08e-06
R07 N06 N07 3.30e-02
L08 N07 N08 1.36e-11
R08 N07 N08 3.42e-01
L09 N08 N09 6.96e-11
R09 N08 N09 1.43e-01
C10 N09 N10 2.66e-07
L10 N09 N10 6.74e-12
R10 N09 N10 8.99e-03
C11 N10 N11 3.75e-08
L11 N10 N11 2.03e-11
R11 N10 N11 2.82e-02
C12 N11 Port2 2.62e-12
L12 N11 Port2 1.19e-10
R12 N11 Port2 2.15e+01
.ENDS GRT155R71E223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GRT155R71E473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71E473KE01 Port1 Port2
C01 Port1 N01 4.53e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.72e-10
R03 N02 N03 2.19e-02
C04 N03 N04 3.67e-06
R04 N03 N04 1.17e+00
C05 N04 N05 4.27e-06
R05 N04 N05 2.01e-01
C06 N05 N06 3.59e-06
R06 N05 N06 4.68e-02
C07 N06 N07 4.59e-06
R07 N06 N07 7.38e-03
L08 N07 N08 1.82e-11
R08 N07 N08 3.12e-01
L09 N08 N09 7.35e-11
R09 N08 N09 1.09e-01
C10 N09 N10 1.70e-06
L10 N09 N10 2.50e-12
R10 N09 N10 5.59e-03
C11 N10 N11 4.78e-08
L11 N10 N11 4.35e-11
R11 N10 N11 3.58e-02
C12 N11 N12 3.13e-11
L12 N11 N12 1.10e-11
R12 N11 N12 2.07e+00
C13 N12 Port2 5.70e-12
L13 N12 Port2 5.03e-11
R13 N12 Port2 2.12e+01
.ENDS GRT155R71E473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRT155R71H102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 400[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H102KE01 Port1 Port2
C01 Port1 N01 9.61e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.47e-10
R03 N02 N03 1.62e-01
C04 N03 N04 8.47e-08
R04 N03 N04 3.12e+00
C05 N04 N05 4.39e-08
R05 N04 N05 1.01e+00
C06 N05 N06 2.16e-08
R06 N05 N06 2.97e-01
C07 N06 N07 3.56e-09
R07 N06 N07 2.08e-01
L08 N07 N08 2.67e-11
R08 N07 N08 6.72e-01
C09 N08 N09 2.68e-10
L09 N08 N09 5.25e-11
R09 N08 N09 2.78e-01
C10 N09 Port2 1.90e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 2.21e+01
.ENDS GRT155R71H102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRT155R71H103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H103KE01 Port1 Port2
C01 Port1 N01 9.66e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.81e-10
R03 N02 N03 4.87e-02
C04 N03 N04 8.69e-07
R04 N03 N04 1.77e+00
C05 N04 N05 7.39e-07
R05 N04 N05 3.60e-01
C06 N05 N06 9.13e-07
R06 N05 N06 6.29e-02
C07 N06 N07 5.45e-07
R07 N06 N07 2.36e-02
L08 N07 N08 5.77e-11
R08 N07 N08 2.28e-01
C09 N08 N09 1.55e-07
L09 N08 N09 4.43e-12
R09 N08 N09 1.53e-02
C10 N09 N10 9.52e-09
L10 N09 N10 3.19e-11
R10 N09 N10 7.37e-02
C11 N10 Port2 4.31e-12
L11 N10 Port2 6.52e-11
R11 N10 Port2 1.11e+01
.ENDS GRT155R71H103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRT155R71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H104KE01 Port1 Port2
C01 Port1 N01 9.09e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.20e-10
R03 N02 N03 1.44e-02
C04 N03 N04 4.94e-06
R04 N03 N04 4.13e-01
C05 N04 N05 7.71e-06
R05 N04 N05 3.89e-02
C06 N05 N06 9.53e-06
R06 N05 N06 7.15e-03
L07 N06 N07 1.30e-11
R07 N06 N07 8.90e-02
L08 N07 N08 9.65e-11
R08 N07 N08 6.74e-02
C09 N08 N09 6.50e-07
L09 N08 N09 1.23e-11
R09 N08 N09 1.12e-02
C10 N09 N10 1.85e-07
L10 N09 N10 2.10e-11
R10 N09 N10 2.12e-02
C11 N10 Port2 2.31e-12
L11 N10 Port2 8.12e-11
R11 N10 Port2 1.94e+01
.ENDS GRT155R71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT155R71H221KE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 2[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H221KE01 Port1 Port2
C01 Port1 N01 2.09e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.30e-10
R03 N02 N03 5.33e-01
C04 N03 N04 3.76e-08
R04 N03 N04 5.48e+00
C05 N04 N05 1.36e-08
R05 N04 N05 2.95e+00
C06 N05 N06 4.30e-09
R06 N05 N06 1.39e+00
C07 N06 N07 9.50e-10
R07 N06 N07 8.19e-01
C08 N07 N08 2.60e-12
L08 N07 N08 1.10e-10
R08 N07 N08 1.97e+01
C09 N08 Port2 1.09e-12
L09 N08 Port2 1.29e-10
R09 N08 Port2 4.87e+00
.ENDS GRT155R71H221KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRT155R71H222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 200[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H222KE01 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.51e-10
R03 N02 N03 1.56e-01
C04 N03 N04 3.25e-07
R04 N03 N04 3.26e+00
C05 N04 N05 1.32e-07
R05 N04 N05 1.12e+00
C06 N05 N06 1.07e-07
R06 N05 N06 2.29e-01
C07 N06 N07 2.58e-08
R07 N06 N07 1.15e-01
L08 N07 N08 5.89e-11
R08 N07 N08 5.55e-01
C09 N08 N09 3.78e-09
L09 N08 N09 1.38e-11
R09 N08 N09 8.55e-02
C10 N09 Port2 1.98e-12
L10 N09 Port2 1.48e-10
R10 N09 Port2 2.05e+01
.ENDS GRT155R71H222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRT155R71H223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H223KE01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.70e-10
R03 N02 N03 2.90e-02
C04 N03 N04 5.68e-06
R04 N03 N04 1.99e+00
C05 N04 N05 3.48e-06
R05 N04 N05 1.00e+00
C06 N05 N06 1.91e-06
R06 N05 N06 3.72e-01
C07 N06 N07 1.64e-06
R07 N06 N07 7.92e-02
C08 N07 N08 1.59e-06
R08 N07 N08 1.25e-02
L09 N08 N09 2.16e-11
R09 N08 N09 4.51e-01
L10 N09 N10 8.90e-11
R10 N09 N10 1.32e-01
C11 N10 N11 2.89e-07
L11 N10 N11 6.79e-12
R11 N10 N11 1.71e-02
C12 N11 N12 5.64e-08
L12 N11 N12 1.62e-11
R12 N11 N12 3.46e-02
C13 N12 N13 8.55e-12
L13 N12 N13 3.31e-11
R13 N12 N13 1.62e+01
C14 N13 Port2 1.92e-11
L14 N13 Port2 1.46e-11
R14 N13 Port2 3.63e+00
.ENDS GRT155R71H223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRT155R71H471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H471KE01 Port1 Port2
C01 Port1 N01 4.82e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 1.25e-10
R03 N02 N03 1.11e-01
C04 N03 N04 1.92e-08
R04 N03 N04 3.06e+00
C05 N04 N05 6.66e-09
R05 N04 N05 5.66e-01
C06 N05 N06 9.42e-10
R06 N05 N06 4.85e-01
C07 N06 N07 2.99e-09
L07 N06 N07 2.12e-11
R07 N06 N07 6.80e-02
C08 N07 N08 4.79e-12
L08 N07 N08 1.03e-10
R08 N07 N08 1.18e+00
C09 N08 Port2 1.60e-12
L09 N08 Port2 1.87e-10
R09 N08 Port2 2.06e+01
.ENDS GRT155R71H471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRT155R71H472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H472KE01 Port1 Port2
C01 Port1 N01 4.49e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.80e-10
R03 N02 N03 1.00e-01
C04 N03 N04 5.37e-07
R04 N03 N04 2.50e+00
C05 N04 N05 2.57e-07
R05 N04 N05 7.01e-01
C06 N05 N06 2.45e-07
R06 N05 N06 9.93e-02
C07 N06 N07 6.76e-08
R07 N06 N07 5.89e-02
L08 N07 N08 1.98e-11
R08 N07 N08 4.98e-01
L09 N08 N09 5.30e-11
R09 N08 N09 1.78e-01
C10 N09 N10 8.36e-09
L10 N09 N10 1.44e-11
R10 N09 N10 4.76e-02
C11 N10 Port2 3.24e-12
L11 N10 Port2 9.11e-11
R11 N10 Port2 1.40e+01
.ENDS GRT155R71H472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRT155R71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H473KE01 Port1 Port2
C01 Port1 N01 4.53e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.87e-10
R03 N02 N03 2.24e-02
C04 N03 N04 2.20e-06
R04 N03 N04 1.40e+00
C05 N04 N05 3.55e-06
R05 N04 N05 1.28e-01
C06 N05 N06 2.70e-06
R06 N05 N06 2.38e-02
L07 N06 N07 1.36e-11
R07 N06 N07 1.32e-01
L08 N07 N08 8.79e-11
R08 N07 N08 1.10e-01
C09 N08 N09 3.32e-07
L09 N08 N09 1.20e-11
R09 N08 N09 1.51e-02
C10 N09 N10 7.35e-08
L10 N09 N10 2.36e-11
R10 N09 N10 2.95e-02
C11 N10 Port2 1.51e-11
L11 N10 Port2 2.18e-11
R11 N10 Port2 5.15e+00
.ENDS GRT155R71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GRT1885C1E102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1885C1E102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GRT1885C1E103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GRT1885C1E103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/25[V]
* Murata P/N :GRT1885C1E122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 2.13e+10
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C1E122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/25[V]
* Murata P/N :GRT1885C1E152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C1E152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-03[uF]/25[V]
* Murata P/N :GRT1885C1E472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 2.13e+10
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GRT1885C1E472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/25[V]
* Murata P/N :GRT1885C1E561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GRT1885C1E561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-03[uF]/25[V]
* Murata P/N :GRT1885C1E562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 2.13e+10
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GRT1885C1E562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/25[V]
* Murata P/N :GRT1885C1E681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1E681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GRT1885C1E682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 2.13e+10
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GRT1885C1E682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GRT1885C1E821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GRT1885C1E821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-03[uF]/25[V]
* Murata P/N :GRT1885C1E822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1E822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 2.13e+10
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GRT1885C1E822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GRT1885C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.38e-10
R03 N02 N03 3.27e-01
L04 N03 N04 4.34e-11
R04 N03 N04 1.44e+00
C05 N04 N05 7.64e-12
L05 N04 N05 8.81e-11
R05 N04 N05 1.95e+01
C06 N05 N06 8.62e-12
L06 N05 N06 5.79e-11
R06 N05 N06 1.03e+01
C07 N06 Port2 7.05e-13
L07 N06 Port2 3.07e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1885C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GRT1885C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.25e-11
R03 N02 N03 1.20e-01
L04 N03 N04 8.79e-12
R04 N03 N04 3.34e-02
C05 N04 N05 9.42e-10
L05 N04 N05 8.78e-12
R05 N04 N05 3.16e-01
C06 N05 N06 9.53e-11
L06 N05 N06 2.93e-11
R06 N05 N06 1.59e+00
C07 N06 N07 8.94e-13
L07 N06 N07 2.65e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 9.25e-13
L08 N07 Port2 2.28e-10
R08 N07 Port2 6.03e+01
.ENDS GRT1885C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRT1885C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1885C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRT1885C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GRT1885C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GRT1885C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-11
R03 N02 N03 3.60e-01
C04 N03 N04 7.42e-13
L04 N03 N04 4.62e-10
R04 N03 N04 3.51e+02
C05 N04 Port2 1.58e-11
L05 N04 Port2 7.41e-11
R05 N04 Port2 1.06e+01
.ENDS GRT1885C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GRT1885C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GRT1885C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GRT1885C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GRT1885C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.50e-11
R03 N02 N03 1.70e-01
L04 N03 N04 3.49e-11
R04 N03 N04 2.68e-01
C05 N04 N05 9.95e-11
L05 N04 N05 1.79e-11
R05 N04 N05 1.87e+00
C06 N05 N06 5.77e-12
L06 N05 N06 6.79e-11
R06 N05 N06 1.21e+01
C07 N06 Port2 4.93e-13
L07 N06 Port2 4.00e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1885C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GRT1885C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GRT1885C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GRT1885C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.00e-12
R03 N02 N03 2.50e-01
L04 N03 N04 2.90e-11
R04 N03 N04 1.37e-01
C05 N04 N05 5.00e-13
L05 N04 N05 4.32e-10
C06 N05 N06 1.20e-11
L06 N05 N06 3.30e-11
R06 N05 N06 3.97e+00
C07 N06 N07 3.47e-11
L07 N06 N07 2.33e-11
R07 N06 N07 3.06e+00
C08 N07 Port2 8.29e-11
L08 N07 Port2 2.17e-11
R08 N07 Port2 2.00e+00
.ENDS GRT1885C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GRT1885C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GRT1885C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GRT1885C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H182JA02 Port1 Port2
C01 Port1 N01 1.81e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 2.05e-02
L04 N03 N04 5.19e-11
R04 N03 N04 2.29e-02
C05 N04 N05 1.64e-08
L05 N04 N05 1.29e-11
R05 N04 N05 1.80e-01
C06 N05 N06 3.02e-09
L06 N05 N06 2.50e-11
R06 N05 N06 3.70e-01
C07 N06 N07 8.34e-10
L07 N06 N07 2.40e-11
R07 N06 N07 2.24e-01
C08 N07 N08 8.66e-12
L08 N07 N08 4.55e-11
R08 N07 N08 8.81e-01
C09 N08 Port2 9.61e-13
L09 N08 Port2 2.31e-10
R09 N08 Port2 1.00e+05
.ENDS GRT1885C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.93e-10
R03 N02 N03 2.71e-01
L04 N03 N04 1.85e-10
R04 N03 N04 5.65e-01
C05 N04 Port2 9.41e-13
L05 N04 Port2 1.37e-10
R05 N04 Port2 1.00e+05
.ENDS GRT1885C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GRT1885C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.52e-10
R03 N02 N03 2.07e-01
L04 N03 N04 2.23e-11
R04 N03 N04 4.07e-01
C05 N04 N05 4.01e-10
L05 N04 N05 6.40e-12
R05 N04 N05 7.26e-01
C06 N05 N06 2.70e-11
L06 N05 N06 2.53e-11
R06 N05 N06 2.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 3.00e-11
R07 N06 N07 4.71e+00
C08 N07 Port2 1.29e-12
L08 N07 Port2 1.92e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GRT1885C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRT1885C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H222JA02 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.20e-10
R03 N02 N03 1.62e-02
L04 N03 N04 4.87e-11
R04 N03 N04 5.51e-01
L05 N04 N05 7.26e-11
R05 N04 N05 2.02e-02
C06 N05 N06 1.76e-08
L06 N05 N06 1.51e-11
R06 N05 N06 1.94e-01
C07 N06 N07 3.11e-09
L07 N06 N07 3.33e-11
R07 N06 N07 4.17e-01
C08 N07 N08 1.80e-09
L08 N07 N08 1.85e-11
R08 N07 N08 2.06e-01
C09 N08 N09 7.70e-12
L09 N08 N09 3.27e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 3.82e-12
L10 N09 Port2 4.88e-11
R10 N09 Port2 4.39e+01
.ENDS GRT1885C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GRT1885C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-12
R03 N02 N03 2.00e-01
L04 N03 N04 1.04e-11
R04 N03 N04 1.11e-01
C05 N04 N05 3.00e-13
L05 N04 N05 4.30e-10
C06 N05 N06 9.22e-12
L06 N05 N06 3.80e-11
R06 N05 N06 3.34e+00
C07 N06 N07 3.30e-11
L07 N06 N07 3.07e-11
R07 N06 N07 3.19e+00
C08 N07 Port2 1.77e-10
L08 N07 Port2 1.76e-11
R08 N07 Port2 1.72e+00
.ENDS GRT1885C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GRT1885C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GRT1885C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GRT1885C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H272JA02 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.10e-10
R03 N02 N03 8.85e-03
L04 N03 N04 6.97e-11
R04 N03 N04 3.95e-01
L05 N04 N05 5.39e-11
R05 N04 N05 1.70e-02
L06 N05 N06 1.10e-10
R06 N05 N06 5.60e-03
C07 N06 N07 2.25e-08
L07 N06 N07 1.50e-11
R07 N06 N07 2.27e-01
C08 N07 N08 4.93e-09
L08 N07 N08 3.05e-11
R08 N07 N08 3.76e-01
C09 N08 N09 5.43e-09
L09 N08 N09 9.13e-12
R09 N08 N09 1.31e-01
C10 N09 Port2 3.95e-12
L10 N09 Port2 8.52e-11
R10 N09 Port2 3.84e+01
.ENDS GRT1885C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 1.56e-01
L04 N03 N04 1.68e-10
R04 N03 N04 3.08e-01
C05 N04 Port2 5.01e-12
L05 N04 Port2 6.41e-11
R05 N04 Port2 2.80e+01
.ENDS GRT1885C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GRT1885C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.89e-01
L04 N03 N04 2.09e-11
R04 N03 N04 2.94e-01
C05 N04 N05 1.82e-10
L05 N04 N05 2.02e-11
R05 N04 N05 2.22e+00
C06 N05 N06 8.98e-11
L06 N05 N06 1.23e-11
R06 N05 N06 1.59e+00
C07 N06 N07 9.59e-12
L07 N06 N07 4.43e-11
R07 N06 N07 6.69e+00
C08 N07 Port2 9.51e-13
L08 N07 Port2 2.55e-10
R08 N07 Port2 1.41e+09
.ENDS GRT1885C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GRT1885C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1885C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GRT1885C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H332JA02 Port1 Port2
C01 Port1 N01 3.17e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.80e-10
R03 N02 N03 1.30e-02
L04 N03 N04 6.85e-11
R04 N03 N04 3.59e-01
L05 N04 N05 5.87e-11
R05 N04 N05 9.32e-03
C06 N05 N06 1.87e-08
L06 N05 N06 2.12e-11
R06 N05 N06 2.45e-01
C07 N06 N07 4.92e-09
L07 N06 N07 3.73e-11
R07 N06 N07 4.02e-01
C08 N07 N08 4.77e-09
L08 N07 N08 1.37e-11
R08 N07 N08 1.46e-01
C09 N08 N09 3.76e-11
L09 N08 N09 9.32e-12
R09 N08 N09 1.98e+00
C10 N09 Port2 4.05e-12
L10 N09 Port2 6.98e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GRT1885C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.80e-01
C04 N03 N04 8.14e-13
L04 N03 N04 3.55e-10
C05 N04 N05 4.33e-12
L05 N04 N05 9.14e-11
R05 N04 N05 1.72e+01
C06 N05 N06 3.46e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.56e+00
C07 N06 Port2 2.62e-10
L07 N06 Port2 1.80e-11
R07 N06 Port2 1.45e+00
.ENDS GRT1885C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GRT1885C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GRT1885C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GRT1885C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H392JA02 Port1 Port2
C01 Port1 N01 3.84e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 7.60e-03
L04 N03 N04 1.02e-10
R04 N03 N04 3.69e-01
L05 N04 N05 5.34e-11
R05 N04 N05 1.33e-02
L06 N05 N06 1.38e-10
R06 N05 N06 5.29e-03
C07 N06 N07 2.13e-08
L07 N06 N07 2.39e-11
R07 N06 N07 3.03e-01
C08 N07 N08 8.43e-09
L08 N07 N08 2.82e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 1.70e-11
L09 N08 Port2 2.15e-11
R09 N08 Port2 5.93e+00
.ENDS GRT1885C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.43e-10
R03 N02 N03 1.45e-01
L04 N03 N04 1.39e-10
R04 N03 N04 3.29e-01
C05 N04 Port2 4.81e-12
L05 N04 Port2 7.00e-11
R05 N04 Port2 3.16e+01
.ENDS GRT1885C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GRT1885C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.77e-11
R03 N02 N03 1.51e-01
L04 N03 N04 2.91e-11
R04 N03 N04 2.48e+00
C05 N04 N05 3.18e-10
L05 N04 N05 1.89e-11
R05 N04 N05 1.58e+00
C06 N05 N06 5.06e-11
L06 N05 N06 3.41e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.18e-11
L07 N06 N07 3.87e-11
R07 N06 N07 4.81e+00
C08 N07 Port2 6.00e-13
L08 N07 Port2 3.14e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRT1885C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRT1885C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GRT1885C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.92e-10
R03 N02 N03 1.43e-01
L04 N03 N04 1.14e-10
R04 N03 N04 2.57e-01
C05 N04 N05 8.50e-12
L05 N04 N05 4.98e-11
R05 N04 N05 2.28e+01
C06 N05 Port2 7.58e-12
L06 N05 Port2 4.44e-11
R06 N05 Port2 1.31e+02
.ENDS GRT1885C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GRT1885C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.90e-01
L04 N03 N04 6.82e-11
R04 N03 N04 5.32e+00
C05 N04 N05 6.97e-13
L05 N04 N05 5.30e-10
R05 N04 N05 4.49e+02
C06 N05 N06 9.78e-11
L06 N05 N06 1.22e-11
R06 N05 N06 1.25e+00
C07 N06 Port2 6.52e-10
L07 N06 Port2 9.24e-12
R07 N06 Port2 5.79e-01
.ENDS GRT1885C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GRT1885C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GRT1885C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GRT1885C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GRT1885C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 1.25e-01
L04 N03 N04 5.72e-11
R04 N03 N04 1.82e-01
C05 N04 N05 1.38e-11
L05 N04 N05 4.43e-11
R05 N04 N05 2.47e+01
C06 N05 Port2 1.94e-12
L06 N05 Port2 1.65e-10
R06 N05 Port2 9.72e+01
.ENDS GRT1885C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GRT1885C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.38e-11
R03 N02 N03 1.41e-01
L04 N03 N04 2.21e-11
R04 N03 N04 2.51e-01
C05 N04 N05 4.99e-10
L05 N04 N05 1.53e-11
R05 N04 N05 9.03e-01
C06 N05 N06 1.53e-10
L06 N05 N06 1.33e-11
R06 N05 N06 8.63e-01
C07 N06 N07 1.32e-10
L07 N06 N07 7.74e-12
R07 N06 N07 1.09e+00
C08 N07 N08 1.29e-11
L08 N07 N08 3.12e-11
R08 N07 N08 3.10e+00
C09 N08 Port2 4.13e-13
L09 N08 Port2 4.26e-10
R09 N08 Port2 1.51e+05
.ENDS GRT1885C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GRT1885C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GRT1885C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GRT1885C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.40e-10
R03 N02 N03 1.10e-01
L04 N03 N04 8.15e-11
R04 N03 N04 2.31e-01
C05 N04 N05 2.29e-09
L05 N04 N05 4.21e-13
R05 N04 N05 1.88e-01
C06 N05 N06 2.26e-11
L06 N05 N06 2.50e-11
R06 N05 N06 7.74e+00
C07 N06 Port2 2.92e-12
L07 N06 Port2 1.10e-10
R07 N06 Port2 6.77e+01
.ENDS GRT1885C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.75e-10
R03 N02 N03 1.07e-01
L04 N03 N04 9.00e-11
R04 N03 N04 2.08e-01
C05 N04 Port2 3.10e-12
L05 N04 Port2 1.10e-10
R05 N04 Port2 5.56e+01
.ENDS GRT1885C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GRT1885C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 1.40e-01
L04 N03 N04 8.63e-11
R04 N03 N04 3.05e+00
C05 N04 N05 7.57e-13
L05 N04 N05 3.72e-10
C06 N05 N06 4.91e-12
L06 N05 N06 7.68e-11
R06 N05 N06 1.24e+01
C07 N06 N07 5.16e-10
L07 N06 N07 5.01e-12
R07 N06 N07 4.41e-01
C08 N07 Port2 6.77e-10
L08 N07 Port2 1.39e-11
R08 N07 Port2 8.02e-01
.ENDS GRT1885C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GRT1885C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GRT1885C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GRT1885C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GRT1885C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.08e-01
L04 N03 N04 6.03e-11
R04 N03 N04 1.82e-01
C05 N04 N05 3.98e-11
L05 N04 N05 2.32e-11
R05 N04 N05 1.21e+01
C06 N05 N06 6.70e-12
L06 N05 N06 6.18e-11
R06 N05 N06 2.22e+01
C07 N06 Port2 2.58e-12
L07 N06 Port2 1.04e-10
R07 N06 Port2 1.17e+02
.ENDS GRT1885C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GRT1885C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.56e-10
R03 N02 N03 1.02e-01
L04 N03 N04 7.41e-11
R04 N03 N04 1.88e-01
C05 N04 N05 4.74e-11
L05 N04 N05 2.21e-11
R05 N04 N05 9.56e+00
C06 N05 N06 8.52e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.89e+01
C07 N06 Port2 8.92e-12
L07 N06 Port2 3.60e-11
R07 N06 Port2 2.37e+01
.ENDS GRT1885C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GRT1885C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.38e-10
R03 N02 N03 3.27e-01
L04 N03 N04 4.34e-11
R04 N03 N04 1.44e+00
C05 N04 N05 7.64e-12
L05 N04 N05 8.81e-11
R05 N04 N05 1.95e+01
C06 N05 N06 8.62e-12
L06 N05 N06 5.79e-11
R06 N05 N06 1.03e+01
C07 N06 Port2 7.05e-13
L07 N06 Port2 3.07e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1885C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRT1885C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.25e-11
R03 N02 N03 1.20e-01
L04 N03 N04 8.79e-12
R04 N03 N04 3.34e-02
C05 N04 N05 9.42e-10
L05 N04 N05 8.78e-12
R05 N04 N05 3.16e-01
C06 N05 N06 9.53e-11
L06 N05 N06 2.93e-11
R06 N05 N06 1.59e+00
C07 N06 N07 8.94e-13
L07 N06 N07 2.65e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 9.25e-13
L08 N07 Port2 2.28e-10
R08 N07 Port2 6.03e+01
.ENDS GRT1885C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRT1885C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GRT1885C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GRT1885C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-11
R03 N02 N03 3.60e-01
C04 N03 N04 7.42e-13
L04 N03 N04 4.62e-10
R04 N03 N04 3.51e+02
C05 N04 Port2 1.58e-11
L05 N04 Port2 7.41e-11
R05 N04 Port2 1.06e+01
.ENDS GRT1885C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GRT1885C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GRT1885C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GRT1885C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 1.02e-02
L04 N03 N04 5.61e-11
R04 N03 N04 5.09e-01
L05 N04 N05 6.27e-11
R05 N04 N05 2.60e-02
L06 N05 N06 1.55e-10
R06 N05 N06 1.01e-02
C07 N06 N07 1.30e-08
L07 N06 N07 9.93e-12
R07 N06 N07 1.52e-01
C08 N07 N08 1.95e-09
L08 N07 N08 2.77e-11
R08 N07 N08 4.83e-01
C09 N08 N09 3.31e-12
L09 N08 N09 1.00e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 6.28e-12
L10 N09 Port2 4.44e-11
R10 N09 Port2 9.95e+00
.ENDS GRT1885C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GRT1885C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.25e-12
R03 N02 N03 2.46e-01
L04 N03 N04 1.48e-10
R04 N03 N04 4.37e+01
L05 N04 N05 5.03e-12
R05 N04 N05 6.52e-02
C06 N05 N06 1.82e-10
L06 N05 N06 9.87e-12
R06 N05 N06 9.76e-01
C07 N06 N07 3.90e-12
L07 N06 N07 1.00e-10
R07 N06 N07 1.78e+01
C08 N07 Port2 9.65e-13
L08 N07 Port2 2.69e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GRT1885C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GRT1885C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GRT1885C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GRT1885C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.00e-12
R03 N02 N03 2.50e-01
L04 N03 N04 2.90e-11
R04 N03 N04 1.37e-01
C05 N04 N05 5.00e-13
L05 N04 N05 4.32e-10
C06 N05 N06 1.20e-11
L06 N05 N06 3.30e-11
R06 N05 N06 3.97e+00
C07 N06 N07 3.47e-11
L07 N06 N07 2.33e-11
R07 N06 N07 3.06e+00
C08 N07 Port2 8.29e-11
L08 N07 Port2 2.17e-11
R08 N07 Port2 2.00e+00
.ENDS GRT1885C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GRT1885C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GRT1885C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.93e-10
R03 N02 N03 2.71e-01
L04 N03 N04 1.85e-10
R04 N03 N04 5.65e-01
C05 N04 Port2 9.41e-13
L05 N04 Port2 1.37e-10
R05 N04 Port2 1.00e+05
.ENDS GRT1885C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GRT1885C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.52e-10
R03 N02 N03 2.07e-01
L04 N03 N04 2.23e-11
R04 N03 N04 4.07e-01
C05 N04 N05 4.01e-10
L05 N04 N05 6.40e-12
R05 N04 N05 7.26e-01
C06 N05 N06 2.70e-11
L06 N05 N06 2.53e-11
R06 N05 N06 2.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 3.00e-11
R07 N06 N07 4.71e+00
C08 N07 Port2 1.29e-12
L08 N07 Port2 1.92e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRT1885C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GRT1885C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 5.00e-12
R03 N02 N03 2.00e-01
L04 N03 N04 1.04e-11
R04 N03 N04 1.11e-01
C05 N04 N05 3.00e-13
L05 N04 N05 4.30e-10
C06 N05 N06 9.22e-12
L06 N05 N06 3.80e-11
R06 N05 N06 3.34e+00
C07 N06 N07 3.30e-11
L07 N06 N07 3.07e-11
R07 N06 N07 3.19e+00
C08 N07 Port2 1.77e-10
L08 N07 Port2 1.76e-11
R08 N07 Port2 1.72e+00
.ENDS GRT1885C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GRT1885C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GRT1885C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.25e-10
R03 N02 N03 1.56e-01
L04 N03 N04 1.68e-10
R04 N03 N04 3.08e-01
C05 N04 Port2 5.01e-12
L05 N04 Port2 6.41e-11
R05 N04 Port2 2.80e+01
.ENDS GRT1885C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GRT1885C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.97e-10
R03 N02 N03 1.89e-01
L04 N03 N04 2.09e-11
R04 N03 N04 2.94e-01
C05 N04 N05 1.82e-10
L05 N04 N05 2.02e-11
R05 N04 N05 2.22e+00
C06 N05 N06 8.98e-11
L06 N05 N06 1.23e-11
R06 N05 N06 1.59e+00
C07 N06 N07 9.59e-12
L07 N06 N07 4.43e-11
R07 N06 N07 6.69e+00
C08 N07 Port2 9.51e-13
L08 N07 Port2 2.55e-10
R08 N07 Port2 1.41e+09
.ENDS GRT1885C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GRT1885C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GRT1885C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GRT1885C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.80e-01
C04 N03 N04 8.14e-13
L04 N03 N04 3.55e-10
C05 N04 N05 4.33e-12
L05 N04 N05 9.14e-11
R05 N04 N05 1.72e+01
C06 N05 N06 3.46e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.56e+00
C07 N06 Port2 2.62e-10
L07 N06 Port2 1.80e-11
R07 N06 Port2 1.45e+00
.ENDS GRT1885C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GRT1885C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GRT1885C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.43e-10
R03 N02 N03 1.45e-01
L04 N03 N04 1.39e-10
R04 N03 N04 3.29e-01
C05 N04 Port2 4.81e-12
L05 N04 Port2 7.00e-11
R05 N04 Port2 3.16e+01
.ENDS GRT1885C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GRT1885C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.77e-11
R03 N02 N03 1.51e-01
L04 N03 N04 2.91e-11
R04 N03 N04 2.48e+00
C05 N04 N05 3.18e-10
L05 N04 N05 1.89e-11
R05 N04 N05 1.58e+00
C06 N05 N06 5.06e-11
L06 N05 N06 3.41e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.18e-11
L07 N06 N07 3.87e-11
R07 N06 N07 4.81e+00
C08 N07 Port2 6.00e-13
L08 N07 Port2 3.14e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GRT1885C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.92e-10
R03 N02 N03 1.43e-01
L04 N03 N04 1.14e-10
R04 N03 N04 2.57e-01
C05 N04 N05 8.50e-12
L05 N04 N05 4.98e-11
R05 N04 N05 2.28e+01
C06 N05 Port2 7.58e-12
L06 N05 Port2 4.44e-11
R06 N05 Port2 1.31e+02
.ENDS GRT1885C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GRT1885C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 1.90e-01
L04 N03 N04 6.82e-11
R04 N03 N04 5.32e+00
C05 N04 N05 6.97e-13
L05 N04 N05 5.30e-10
R05 N04 N05 4.49e+02
C06 N05 N06 9.78e-11
L06 N05 N06 1.22e-11
R06 N05 N06 1.25e+00
C07 N06 Port2 6.52e-10
L07 N06 Port2 9.24e-12
R07 N06 Port2 5.79e-01
.ENDS GRT1885C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GRT1885C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GRT1885C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 1.25e-01
L04 N03 N04 5.72e-11
R04 N03 N04 1.82e-01
C05 N04 N05 1.38e-11
L05 N04 N05 4.43e-11
R05 N04 N05 2.47e+01
C06 N05 Port2 1.94e-12
L06 N05 Port2 1.65e-10
R06 N05 Port2 9.72e+01
.ENDS GRT1885C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GRT1885C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.38e-11
R03 N02 N03 1.41e-01
L04 N03 N04 2.21e-11
R04 N03 N04 2.51e-01
C05 N04 N05 4.99e-10
L05 N04 N05 1.53e-11
R05 N04 N05 9.03e-01
C06 N05 N06 1.53e-10
L06 N05 N06 1.33e-11
R06 N05 N06 8.63e-01
C07 N06 N07 1.32e-10
L07 N06 N07 7.74e-12
R07 N06 N07 1.09e+00
C08 N07 N08 1.29e-11
L08 N07 N08 3.12e-11
R08 N07 N08 3.10e+00
C09 N08 Port2 4.13e-13
L09 N08 Port2 4.26e-10
R09 N08 Port2 1.51e+05
.ENDS GRT1885C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GRT1885C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GRT1885C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.40e-10
R03 N02 N03 1.10e-01
L04 N03 N04 8.15e-11
R04 N03 N04 2.31e-01
C05 N04 N05 2.29e-09
L05 N04 N05 4.21e-13
R05 N04 N05 1.88e-01
C06 N05 N06 2.26e-11
L06 N05 N06 2.50e-11
R06 N05 N06 7.74e+00
C07 N06 Port2 2.92e-12
L07 N06 Port2 1.10e-10
R07 N06 Port2 6.77e+01
.ENDS GRT1885C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.75e-10
R03 N02 N03 1.07e-01
L04 N03 N04 9.00e-11
R04 N03 N04 2.08e-01
C05 N04 Port2 3.10e-12
L05 N04 Port2 1.10e-10
R05 N04 Port2 5.56e+01
.ENDS GRT1885C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GRT1885C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 1.40e-01
L04 N03 N04 8.63e-11
R04 N03 N04 3.05e+00
C05 N04 N05 7.57e-13
L05 N04 N05 3.72e-10
C06 N05 N06 4.91e-12
L06 N05 N06 7.68e-11
R06 N05 N06 1.24e+01
C07 N06 N07 5.16e-10
L07 N06 N07 5.01e-12
R07 N06 N07 4.41e-01
C08 N07 Port2 6.77e-10
L08 N07 Port2 1.39e-11
R08 N07 Port2 8.02e-01
.ENDS GRT1885C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GRT1885C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GRT1885C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.08e-01
L04 N03 N04 6.03e-11
R04 N03 N04 1.82e-01
C05 N04 N05 3.98e-11
L05 N04 N05 2.32e-11
R05 N04 N05 1.21e+01
C06 N05 N06 6.70e-12
L06 N05 N06 6.18e-11
R06 N05 N06 2.22e+01
C07 N06 Port2 2.58e-12
L07 N06 Port2 1.04e-10
R07 N06 Port2 1.17e+02
.ENDS GRT1885C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GRT1885C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT1885C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.56e-10
R03 N02 N03 1.02e-01
L04 N03 N04 7.41e-11
R04 N03 N04 1.88e-01
C05 N04 N05 4.74e-11
L05 N04 N05 2.21e-11
R05 N04 N05 9.56e+00
C06 N05 N06 8.52e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.89e+01
C07 N06 Port2 8.92e-12
L07 N06 Port2 3.60e-11
R07 N06 Port2 2.37e+01
.ENDS GRT1885C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/4[V]
* Murata P/N :GRT188C80G105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80G105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GRT188C80G105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRT188C80G106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80G106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GRT188C80G106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRT188C80G226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80G226ME13 Port1 Port2
C01 Port1 N01 1.53e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.69e-10
R03 N02 N03 2.67e-03
C04 N03 N04 6.03e-04
R04 N03 N04 8.79e+00
C05 N04 N05 7.02e-04
R05 N04 N05 8.26e-01
C06 N05 N06 9.27e-04
R06 N05 N06 6.12e-02
C07 N06 N07 7.68e-04
R07 N06 N07 4.54e-03
L08 N07 N08 2.74e-11
R08 N07 N08 7.68e-02
L09 N08 N09 7.35e-11
R09 N08 N09 1.93e-02
L10 N09 N10 3.16e-10
R10 N09 N10 9.70e-03
C11 N10 N11 5.23e-05
L11 N10 N11 6.49e-11
R11 N10 N11 1.71e-03
C12 N11 N12 3.83e-05
L12 N11 N12 4.87e-11
R12 N11 N12 1.98e-03
C13 N12 Port2 5.70e-12
L13 N12 Port2 5.69e-11
R13 N12 Port2 5.55e+00
.ENDS GRT188C80G226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/4[V]
* Murata P/N :GRT188C80G475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80G475KE01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GRT188C80G475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/4[V]
* Murata P/N :GRT188C80G475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80G475ME01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GRT188C80G475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT188C80J226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80J226ME13 Port1 Port2
C01 Port1 N01 1.46e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.77e-10
R03 N02 N03 2.39e-03
C04 N03 N04 6.79e-04
R04 N03 N04 7.64e+00
C05 N04 N05 9.19e-04
R05 N04 N05 6.87e-01
C06 N05 N06 1.10e-03
R06 N05 N06 7.45e-02
C07 N06 N07 1.25e-03
R07 N06 N07 5.67e-03
C08 N07 N08 1.20e-03
R08 N07 N08 7.52e-04
L09 N08 N09 2.70e-11
R09 N08 N09 7.57e-02
L10 N09 N10 5.88e-11
R10 N09 N10 2.03e-02
L11 N10 N11 3.42e-10
R11 N10 N11 1.22e-02
C12 N11 N12 3.86e-05
L12 N11 N12 7.07e-11
R12 N11 N12 2.29e-03
C13 N12 N13 3.15e-05
L13 N12 N13 4.57e-11
R13 N12 N13 2.33e-03
C14 N13 Port2 7.44e-12
L14 N13 Port2 4.87e-11
R14 N13 Port2 6.32e+00
.ENDS GRT188C80J226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT188C80J475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80J475KE01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GRT188C80J475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT188C80J475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80J475ME01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GRT188C80J475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT188C81A105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81A105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188C81A105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT188C81A106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81A106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GRT188C81A106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT188C81C105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81C105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188C81C105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT188C81C106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81C106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GRT188C81C106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT188C81C225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81C225KE13 Port1 Port2
C01 Port1 N01 1.55e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.49e-10
R03 N02 N03 6.05e-03
C04 N03 N04 5.84e-05
R04 N03 N04 7.38e+01
C05 N04 N05 5.16e-05
R05 N04 N05 9.53e+00
C06 N05 N06 4.52e-05
R06 N05 N06 1.08e+00
C07 N06 N07 3.81e-05
R07 N06 N07 1.25e-01
C08 N07 N08 2.99e-05
R08 N07 N08 1.58e-02
L09 N08 N09 2.88e-11
R09 N08 N09 6.98e-02
L10 N09 N10 2.01e-10
R10 N09 N10 2.99e-02
C11 N10 N11 4.09e-06
L11 N10 N11 5.37e-11
R11 N10 N11 6.06e-03
C12 N11 N12 6.10e-06
L12 N11 N12 2.03e-11
R12 N11 N12 6.17e-03
C13 N12 Port2 2.14e-12
L13 N12 Port2 1.38e-10
R13 N12 Port2 3.10e+01
.ENDS GRT188C81C225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT188C81C475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81C475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188C81C475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT188C81C475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81C475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188C81C475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT188C81E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81E105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188C81E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT188C81E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81E225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GRT188C81E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT188C81E225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81E225ME13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GRT188C81E225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT188C81E475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81E475KE13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GRT188C81E475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT188C81E475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C81E475ME13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GRT188C81E475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRT188C8YA105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C8YA105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188C8YA105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRT188C8YA225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C8YA225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GRT188C8YA225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRT188R60G106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60G106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GRT188R60G106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT188R60J105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J105KE01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GRT188R60J105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT188R60J105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GRT188R60J105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRT188R60J106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J106ME13 Port1 Port2
C01 Port1 N01 6.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.06e-10
R03 N02 N03 2.59e-03
C04 N03 N04 2.55e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.72e-04
R05 N04 N05 1.25e+00
C06 N05 N06 5.07e-04
R06 N05 N06 9.10e-02
C07 N06 N07 4.89e-04
R07 N06 N07 9.20e-03
C08 N07 N08 3.99e-04
R08 N07 N08 1.19e-03
L09 N08 N09 2.16e-11
R09 N08 N09 8.41e-02
L10 N09 N10 4.23e-11
R10 N09 N10 2.08e-02
L11 N10 N11 3.30e-10
R11 N10 N11 1.51e-02
C12 N11 N12 3.81e-05
L12 N11 N12 3.12e-11
R12 N11 N12 2.14e-03
C13 N12 N13 3.50e-05
L13 N12 N13 2.07e-11
R13 N12 N13 2.04e-03
C14 N13 Port2 1.47e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 3.09e+01
.ENDS GRT188R60J106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT188R60J225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J225KE13 Port1 Port2
C01 Port1 N01 1.92e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.50e-10
R03 N02 N03 4.58e-03
C04 N03 N04 6.49e-05
R04 N03 N04 8.36e+01
C05 N04 N05 1.07e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.31e-04
R06 N05 N06 3.08e-01
C07 N06 N07 1.12e-04
R07 N06 N07 3.56e-02
C08 N07 N08 7.98e-05
R08 N07 N08 5.07e-03
L09 N08 N09 1.20e-11
R09 N08 N09 9.96e-02
L10 N09 N10 2.71e-11
R10 N09 N10 3.45e-02
L11 N10 N11 2.15e-10
R11 N10 N11 2.36e-02
C12 N11 N12 8.50e-06
L12 N11 N12 3.25e-11
R12 N11 N12 5.00e-03
C13 N12 N13 5.87e-06
L13 N12 N13 2.43e-11
R13 N12 N13 5.08e-03
C14 N13 Port2 2.11e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 4.70e+01
.ENDS GRT188R60J225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT188R60J226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J226ME13 Port1 Port2
C01 Port1 N01 1.42e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.40e-10
R03 N02 N03 2.64e-03
C04 N03 N04 6.40e-04
R04 N03 N04 7.58e+00
C05 N04 N05 9.85e-04
R05 N04 N05 7.93e-01
C06 N05 N06 1.02e-03
R06 N05 N06 1.20e-01
C07 N06 N07 2.19e-03
R07 N06 N07 1.05e-02
C08 N07 N08 1.86e-03
R08 N07 N08 3.87e-03
C09 N08 N09 1.05e-03
R09 N08 N09 1.14e-03
L10 N09 N10 3.35e-11
R10 N09 N10 1.10e-01
L11 N10 N11 6.24e-11
R11 N10 N11 2.31e-02
L12 N11 N12 3.19e-10
R12 N11 N12 1.18e-02
C13 N12 N13 8.65e-05
L13 N12 N13 4.22e-11
R13 N12 N13 1.40e-03
C14 N13 N14 2.49e-05
L14 N13 N14 7.70e-11
R14 N13 N14 2.66e-03
C15 N14 Port2 3.19e-12
L15 N14 Port2 8.26e-11
R15 N14 Port2 2.93e+01
.ENDS GRT188R60J226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT188R60J475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J475KE01 Port1 Port2
C01 Port1 N01 3.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.01e-11
R03 N02 N03 3.36e-03
C04 N03 N04 1.27e-04
R04 N03 N04 4.28e+01
C05 N04 N05 1.78e-04
R05 N04 N05 2.17e+00
C06 N05 N06 2.56e-04
R06 N05 N06 1.51e-01
C07 N06 N07 2.03e-04
R07 N06 N07 1.88e-02
C08 N07 N08 2.58e-04
R08 N07 N08 1.87e-03
L09 N08 N09 7.94e-12
R09 N08 N09 1.18e-01
L10 N09 N10 2.77e-11
R10 N09 N10 5.08e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.17e-02
C12 N11 N12 9.67e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.87e-03
C13 N12 N13 8.95e-06
L13 N12 N13 3.38e-11
R13 N12 N13 3.36e-03
C14 N13 Port2 1.21e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 1.17e+02
.ENDS GRT188R60J475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT188R61A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A105KE01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GRT188R61A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRT188R61A105ME01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A105ME01 Port1 Port2
C01 Port1 N01 9.32e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.82e-11
R03 N02 N03 5.15e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.32e-04
R05 N04 N05 1.29e+00
C06 N05 N06 9.52e-05
R06 N05 N06 2.07e-01
C07 N06 N07 1.22e-04
R07 N06 N07 2.08e-02
C08 N07 N08 6.58e-05
R08 N07 N08 6.97e-03
L09 N08 N09 2.62e-11
R09 N08 N09 9.79e-02
L10 N09 N10 2.58e-10
R10 N09 N10 4.11e-02
C11 N10 N11 5.68e-06
L11 N10 N11 2.83e-11
R11 N10 N11 7.54e-03
C12 N11 N12 3.21e-06
L12 N11 N12 2.52e-11
R12 N11 N12 8.13e-03
C13 N12 N13 2.26e-12
L13 N12 N13 1.10e-10
R13 N12 N13 1.00e+05
C14 N13 Port2 1.96e-12
L14 N13 Port2 1.25e-10
R14 N13 Port2 3.16e+01
.ENDS GRT188R61A105ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT188R61A106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A106KE13 Port1 Port2
C01 Port1 N01 6.07e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.56e-10
R03 N02 N03 2.93e-03
C04 N03 N04 1.39e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.62e-04
R05 N04 N05 3.57e+00
C06 N05 N06 4.04e-04
R06 N05 N06 3.12e-01
C07 N06 N07 6.11e-04
R07 N06 N07 2.00e-02
C08 N07 N08 5.89e-04
R08 N07 N08 3.51e-03
L09 N08 N09 1.76e-11
R09 N08 N09 6.03e-02
L10 N09 N10 3.44e-11
R10 N09 N10 2.44e-02
L11 N10 N11 2.56e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.33e-05
L12 N11 N12 7.52e-11
R12 N11 N12 4.28e-03
C13 N12 N13 1.85e-05
L13 N12 N13 2.97e-11
R13 N12 N13 2.97e-03
C14 N13 N14 2.08e-11
L14 N13 N14 1.52e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 6.21e-12
L15 N14 Port2 5.04e-11
R15 N14 Port2 6.75e+00
.ENDS GRT188R61A106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT188R61A106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A106ME13 Port1 Port2
C01 Port1 N01 6.07e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.56e-10
R03 N02 N03 2.93e-03
C04 N03 N04 1.39e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.62e-04
R05 N04 N05 3.57e+00
C06 N05 N06 4.04e-04
R06 N05 N06 3.12e-01
C07 N06 N07 6.11e-04
R07 N06 N07 2.00e-02
C08 N07 N08 5.89e-04
R08 N07 N08 3.51e-03
L09 N08 N09 1.76e-11
R09 N08 N09 6.03e-02
L10 N09 N10 3.44e-11
R10 N09 N10 2.44e-02
L11 N10 N11 2.56e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.33e-05
L12 N11 N12 7.52e-11
R12 N11 N12 4.28e-03
C13 N12 N13 1.85e-05
L13 N12 N13 2.97e-11
R13 N12 N13 2.97e-03
C14 N13 N14 2.08e-11
L14 N13 N14 1.52e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 6.21e-12
L15 N14 Port2 5.04e-11
R15 N14 Port2 6.75e+00
.ENDS GRT188R61A106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRT188R61A225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A225KE13 Port1 Port2
C01 Port1 N01 1.92e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.50e-10
R03 N02 N03 4.58e-03
C04 N03 N04 6.49e-05
R04 N03 N04 8.36e+01
C05 N04 N05 1.07e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.31e-04
R06 N05 N06 3.08e-01
C07 N06 N07 1.12e-04
R07 N06 N07 3.56e-02
C08 N07 N08 7.98e-05
R08 N07 N08 5.07e-03
L09 N08 N09 1.20e-11
R09 N08 N09 9.96e-02
L10 N09 N10 2.71e-11
R10 N09 N10 3.45e-02
L11 N10 N11 2.15e-10
R11 N10 N11 2.36e-02
C12 N11 N12 8.50e-06
L12 N11 N12 3.25e-11
R12 N11 N12 5.00e-03
C13 N12 N13 5.87e-06
L13 N12 N13 2.43e-11
R13 N12 N13 5.08e-03
C14 N13 Port2 2.11e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 4.70e+01
.ENDS GRT188R61A225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT188R61A226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61A226ME13 Port1 Port2
C01 Port1 N01 1.46e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.77e-10
R03 N02 N03 2.39e-03
C04 N03 N04 6.79e-04
R04 N03 N04 7.64e+00
C05 N04 N05 9.19e-04
R05 N04 N05 6.87e-01
C06 N05 N06 1.10e-03
R06 N05 N06 7.45e-02
C07 N06 N07 1.25e-03
R07 N06 N07 5.67e-03
C08 N07 N08 1.20e-03
R08 N07 N08 7.52e-04
L09 N08 N09 2.70e-11
R09 N08 N09 7.57e-02
L10 N09 N10 5.88e-11
R10 N09 N10 2.03e-02
L11 N10 N11 3.42e-10
R11 N10 N11 1.22e-02
C12 N11 N12 3.86e-05
L12 N11 N12 7.07e-11
R12 N11 N12 2.29e-03
C13 N12 N13 3.15e-05
L13 N12 N13 4.57e-11
R13 N12 N13 2.33e-03
C14 N13 Port2 7.44e-12
L14 N13 Port2 4.87e-11
R14 N13 Port2 6.32e+00
.ENDS GRT188R61A226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT188R61C105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61C105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188R61C105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT188R61C106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61C106KE13 Port1 Port2
C01 Port1 N01 6.59e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.28e-10
R03 N02 N03 3.44e-03
C04 N03 N04 3.33e-04
R04 N03 N04 9.64e+00
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.70e-04
R06 N05 N06 3.50e-01
C07 N06 N07 2.51e-04
R07 N06 N07 3.86e-02
C08 N07 N08 1.94e-04
R08 N07 N08 5.68e-03
L09 N08 N09 5.94e-12
R09 N08 N09 1.45e-01
L10 N09 N10 1.64e-11
R10 N09 N10 1.03e-01
L11 N10 N11 4.86e-11
R11 N10 N11 3.71e-02
L12 N11 N12 3.08e-10
R12 N11 N12 1.66e-02
C13 N12 N13 4.02e-05
L13 N12 N13 3.37e-11
R13 N12 N13 2.25e-03
C14 N13 N14 1.81e-05
L14 N13 N14 4.59e-11
R14 N13 N14 3.31e-03
C15 N14 Port2 2.31e-11
L15 N14 Port2 1.61e-11
R15 N14 Port2 4.30e+00
.ENDS GRT188R61C106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT188R61C106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61C106ME13 Port1 Port2
C01 Port1 N01 6.59e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.28e-10
R03 N02 N03 3.44e-03
C04 N03 N04 3.33e-04
R04 N03 N04 9.64e+00
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.70e-04
R06 N05 N06 3.50e-01
C07 N06 N07 2.51e-04
R07 N06 N07 3.86e-02
C08 N07 N08 1.94e-04
R08 N07 N08 5.68e-03
L09 N08 N09 5.94e-12
R09 N08 N09 1.45e-01
L10 N09 N10 1.64e-11
R10 N09 N10 1.03e-01
L11 N10 N11 4.86e-11
R11 N10 N11 3.71e-02
L12 N11 N12 3.08e-10
R12 N11 N12 1.66e-02
C13 N12 N13 4.02e-05
L13 N12 N13 3.37e-11
R13 N12 N13 2.25e-03
C14 N13 N14 1.81e-05
L14 N13 N14 4.59e-11
R14 N13 N14 3.31e-03
C15 N14 Port2 2.31e-11
L15 N14 Port2 1.61e-11
R15 N14 Port2 4.30e+00
.ENDS GRT188R61C106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT188R61C475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61C475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188R61C475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT188R61C475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61C475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188R61C475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT188R61E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61E105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188R61E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT188R61E106ME13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61E106ME13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.32e-10
R03 N02 N03 3.19e-03
C04 N03 N04 2.79e-04
R04 N03 N04 1.15e+01
C05 N04 N05 3.22e-04
R05 N04 N05 1.40e+00
C06 N05 N06 2.93e-04
R06 N05 N06 1.87e-01
C07 N06 N07 2.47e-04
R07 N06 N07 2.61e-02
C08 N07 N08 1.89e-04
R08 N07 N08 4.23e-03
L09 N08 N09 1.86e-11
R09 N08 N09 7.48e-02
L10 N09 N10 4.77e-11
R10 N09 N10 2.90e-02
L11 N10 N11 3.02e-10
R11 N10 N11 1.55e-02
C12 N11 N12 5.53e-05
L12 N11 N12 2.41e-11
R12 N11 N12 2.55e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.92e-11
R13 N12 N13 3.72e-03
C14 N13 N14 5.06e-12
L14 N13 N14 4.79e-11
R14 N13 N14 1.00e+05
C15 N14 Port2 7.26e-12
L15 N14 Port2 3.28e-11
R15 N14 Port2 2.56e+00
.ENDS GRT188R61E106ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT188R61E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61E225KE13 Port1 Port2
C01 Port1 N01 1.55e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.49e-10
R03 N02 N03 6.05e-03
C04 N03 N04 5.84e-05
R04 N03 N04 7.38e+01
C05 N04 N05 5.16e-05
R05 N04 N05 9.53e+00
C06 N05 N06 4.52e-05
R06 N05 N06 1.08e+00
C07 N06 N07 3.81e-05
R07 N06 N07 1.25e-01
C08 N07 N08 2.99e-05
R08 N07 N08 1.58e-02
L09 N08 N09 2.88e-11
R09 N08 N09 6.98e-02
L10 N09 N10 2.01e-10
R10 N09 N10 2.99e-02
C11 N10 N11 4.09e-06
L11 N10 N11 5.37e-11
R11 N10 N11 6.06e-03
C12 N11 N12 6.10e-06
L12 N11 N12 2.03e-11
R12 N11 N12 6.17e-03
C13 N12 Port2 2.14e-12
L13 N12 Port2 1.38e-10
R13 N12 Port2 3.10e+01
.ENDS GRT188R61E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT188R61E475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61E475KE13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188R61E475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT188R61E475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61E475ME13 Port1 Port2
C01 Port1 N01 3.43e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.87e-10
R03 N02 N03 4.01e-03
C04 N03 N04 1.92e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.95e+00
C06 N05 N06 3.04e-04
R06 N05 N06 5.03e-01
C07 N06 N07 1.88e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.42e-04
R08 N07 N08 3.01e-02
C09 N08 N09 1.02e-04
R09 N08 N09 5.77e-03
L10 N09 N10 2.04e-11
R10 N09 N10 1.46e-01
L11 N10 N11 3.79e-11
R11 N10 N11 3.82e-02
L12 N11 N12 2.48e-10
R12 N11 N12 2.32e-02
C13 N12 N13 3.03e-05
L13 N12 N13 2.22e-11
R13 N12 N13 2.79e-03
C14 N13 N14 4.72e-06
L14 N13 N14 7.19e-11
R14 N13 N14 5.94e-03
C15 N14 Port2 5.83e-12
L15 N14 Port2 5.98e-11
R15 N14 Port2 1.34e+01
.ENDS GRT188R61E475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRT188R61H105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61H105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188R61H105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT188R61H225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61H225KE13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GRT188R61H225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT188R61H225ME13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R61H225ME13 Port1 Port2
C01 Port1 N01 1.66e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.31e-03
C04 N03 N04 1.19e-04
R04 N03 N04 2.89e+01
C05 N04 N05 1.53e-04
R05 N04 N05 4.04e+00
C06 N05 N06 1.02e-04
R06 N05 N06 1.10e+00
C07 N06 N07 1.01e-04
R07 N06 N07 1.84e-01
C08 N07 N08 6.73e-05
R08 N07 N08 4.19e-02
C09 N08 N09 5.11e-05
R09 N08 N09 7.58e-03
L10 N09 N10 2.33e-11
R10 N09 N10 5.26e-02
L11 N10 N11 1.75e-10
R11 N10 N11 2.75e-02
C12 N11 N12 9.09e-06
L12 N11 N12 2.73e-11
R12 N11 N12 5.53e-03
C13 N12 N13 2.01e-06
L13 N12 N13 5.61e-11
R13 N12 N13 9.46e-03
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.74e-10
R14 N13 Port2 4.15e+01
.ENDS GRT188R61H225ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRT188R6YA105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R6YA105KE13 Port1 Port2
C01 Port1 N01 8.77e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 7.65e-03
C04 N03 N04 4.77e-06
R04 N03 N04 1.47e+03
C05 N04 N05 2.12e-05
R05 N04 N05 1.27e+01
C06 N05 N06 1.83e-05
R06 N05 N06 1.46e+00
C07 N06 N07 1.41e-05
R07 N06 N07 1.66e-01
C08 N07 N08 9.83e-06
R08 N07 N08 2.16e-02
L09 N08 N09 2.29e-11
R09 N08 N09 8.12e-02
L10 N09 N10 1.58e-10
R10 N09 N10 4.01e-02
C11 N10 N11 3.02e-06
L11 N10 N11 3.15e-11
R11 N10 N11 9.71e-03
C12 N11 N12 9.02e-07
L12 N11 N12 5.54e-11
R12 N11 N12 1.14e-02
C13 N12 Port2 1.55e-12
L13 N12 Port2 1.73e-10
R13 N12 Port2 6.44e+01
.ENDS GRT188R6YA105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRT188R6YA225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R6YA225KE13 Port1 Port2
C01 Port1 N01 1.41e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.78e-10
R03 N02 N03 5.47e-03
C04 N03 N04 7.99e-05
R04 N03 N04 5.52e+01
C05 N04 N05 6.06e-05
R05 N04 N05 6.17e+00
C06 N05 N06 5.00e-05
R06 N05 N06 7.40e-01
C07 N06 N07 4.71e-05
R07 N06 N07 8.61e-02
C08 N07 N08 3.25e-05
R08 N07 N08 1.60e-02
C09 N08 N09 4.41e-05
R09 N08 N09 2.00e-03
L10 N09 N10 3.58e-11
R10 N09 N10 8.02e-02
L11 N10 N11 2.29e-10
R11 N10 N11 3.02e-02
C12 N11 N12 7.53e-06
L12 N11 N12 2.62e-11
R12 N11 N12 5.42e-03
C13 N12 N13 3.80e-06
L13 N12 N13 2.71e-11
R13 N12 N13 6.82e-03
C14 N13 Port2 3.04e-12
L14 N13 Port2 1.23e-10
R14 N13 Port2 3.79e+01
.ENDS GRT188R6YA225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRT188R6YA475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R6YA475KE13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GRT188R6YA475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRT188R6YA475ME13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R6YA475ME13 Port1 Port2
C01 Port1 N01 3.49e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.18e-10
R03 N02 N03 4.05e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.34e+01
C05 N04 N05 2.20e-04
R05 N04 N05 2.64e+00
C06 N05 N06 1.75e-04
R06 N05 N06 5.74e-01
C07 N06 N07 1.56e-04
R07 N06 N07 8.61e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.16e-02
C09 N08 N09 1.56e-04
R09 N08 N09 4.09e-03
L10 N09 N10 1.38e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.98e-11
R11 N10 N11 3.11e-02
L12 N11 N12 2.29e-10
R12 N11 N12 2.22e-02
C13 N12 N13 1.19e-05
L13 N12 N13 5.05e-11
R13 N12 N13 5.27e-03
C14 N13 N14 5.14e-06
L14 N13 N14 5.64e-11
R14 N13 N14 6.68e-03
C15 N14 Port2 7.24e-12
L15 N14 Port2 4.78e-11
R15 N14 Port2 1.40e+01
.ENDS GRT188R6YA475ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT188R70J225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R70J225KE13 Port1 Port2
C01 Port1 N01 1.71e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.27e-11
R03 N02 N03 5.94e-03
C04 N03 N04 1.31e-05
R04 N03 N04 5.45e+02
C05 N04 N05 4.06e-05
R05 N04 N05 9.88e+00
C06 N05 N06 3.98e-05
R06 N05 N06 9.97e-01
C07 N06 N07 3.39e-05
R07 N06 N07 1.18e-01
C08 N07 N08 2.49e-05
R08 N07 N08 1.59e-02
L09 N08 N09 3.31e-11
R09 N08 N09 6.97e-02
L10 N09 N10 2.13e-10
R10 N09 N10 3.21e-02
C11 N10 N11 4.31e-06
L11 N10 N11 5.61e-11
R11 N10 N11 7.22e-03
C12 N11 N12 4.44e-06
L12 N11 N12 2.54e-11
R12 N11 N12 7.74e-03
C13 N12 Port2 1.28e-12
L13 N12 Port2 1.86e-10
R13 N12 Port2 5.44e+01
.ENDS GRT188R70J225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRT188R71C105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71C105KE13 Port1 Port2
C01 Port1 N01 7.22e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.05e-10
R03 N02 N03 6.64e-03
C04 N03 N04 5.45e-06
R04 N03 N04 1.28e+03
C05 N04 N05 1.84e-05
R05 N04 N05 1.75e+01
C06 N05 N06 1.87e-05
R06 N05 N06 1.73e+00
C07 N06 N07 1.44e-05
R07 N06 N07 2.23e-01
C08 N07 N08 1.23e-05
R08 N07 N08 2.61e-02
C09 N08 N09 1.07e-05
R09 N08 N09 2.34e-03
L10 N09 N10 1.19e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.17e-11
R11 N10 N11 4.75e-02
L12 N11 N12 1.75e-10
R12 N11 N12 4.14e-02
C13 N12 N13 2.48e-06
L13 N12 N13 3.63e-11
R13 N12 N13 1.05e-02
C14 N13 N14 1.23e-06
L14 N13 N14 3.64e-11
R14 N13 N14 1.44e-02
C15 N14 Port2 4.05e-12
L15 N14 Port2 9.16e-11
R15 N14 Port2 1.92e+01
.ENDS GRT188R71C105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT188R71E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71E105KE13 Port1 Port2
C01 Port1 N01 7.22e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.05e-10
R03 N02 N03 6.64e-03
C04 N03 N04 5.45e-06
R04 N03 N04 1.28e+03
C05 N04 N05 1.84e-05
R05 N04 N05 1.75e+01
C06 N05 N06 1.87e-05
R06 N05 N06 1.73e+00
C07 N06 N07 1.44e-05
R07 N06 N07 2.23e-01
C08 N07 N08 1.23e-05
R08 N07 N08 2.61e-02
C09 N08 N09 1.07e-05
R09 N08 N09 2.34e-03
L10 N09 N10 1.19e-11
R10 N09 N10 1.14e-01
L11 N10 N11 2.17e-11
R11 N10 N11 4.75e-02
L12 N11 N12 1.75e-10
R12 N11 N12 4.14e-02
C13 N12 N13 2.48e-06
L13 N12 N13 3.63e-11
R13 N12 N13 1.05e-02
C14 N13 N14 1.23e-06
L14 N13 N14 3.64e-11
R14 N13 N14 1.44e-02
C15 N14 Port2 4.05e-12
L15 N14 Port2 9.16e-11
R15 N14 Port2 1.92e+01
.ENDS GRT188R71E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRT188R71E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71E224KE01 Port1 Port2
C01 Port1 N01 2.08e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-02
C04 N03 N04 1.93e-05
R04 N03 N04 6.57e-01
C05 N04 N05 7.66e-05
R05 N04 N05 2.08e-01
C06 N05 N06 1.76e-05
R06 N05 N06 1.02e-01
C07 N06 N07 1.79e-05
R07 N06 N07 1.27e-02
C08 N07 N08 2.14e-05
R08 N07 N08 1.86e-03
L09 N08 N09 1.66e-11
R09 N08 N09 8.15e-02
L10 N09 N10 1.34e-10
R10 N09 N10 6.05e-02
C11 N10 N11 1.23e-06
L11 N10 N11 2.15e-11
R11 N10 N11 1.18e-02
C12 N11 N12 3.93e-07
L12 N11 N12 3.34e-11
R12 N11 N12 2.08e-02
C13 N12 N13 1.33e-11
L13 N12 N13 4.52e-11
R13 N12 N13 5.50e+00
C14 N13 Port2 1.97e-12
L14 N13 Port2 1.19e-10
R14 N13 Port2 2.69e+01
.ENDS GRT188R71E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRT188R71H104KE13
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71H104KE13 Port1 Port2
C01 Port1 N01 9.61e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.25e-10
R03 N02 N03 1.33e-02
C04 N03 N04 1.19e-05
R04 N03 N04 7.93e-01
C05 N04 N05 9.37e-06
R05 N04 N05 2.43e-01
C06 N05 N06 1.01e-04
R06 N05 N06 1.58e-01
C07 N06 N07 8.18e-06
R07 N06 N07 3.89e-02
C08 N07 N08 1.57e-05
R08 N07 N08 3.40e-03
L09 N08 N09 1.45e-10
R09 N08 N09 7.97e-02
L10 N09 N10 1.09e-11
R10 N09 N10 3.26e-02
C11 N10 N11 5.86e-07
L11 N10 N11 2.14e-11
R11 N10 N11 2.43e-02
C12 N11 N12 1.91e-07
L12 N11 N12 3.14e-11
R12 N11 N12 3.43e-02
C13 N12 N13 9.10e-12
L13 N12 N13 6.59e-11
R13 N12 N13 7.21e+00
C14 N13 Port2 2.99e-12
L14 N13 Port2 8.57e-11
R14 N13 Port2 2.66e+01
.ENDS GRT188R71H104KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRT188R71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71H473KE01 Port1 Port2
C01 Port1 N01 4.53e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.90e-10
R03 N02 N03 1.91e-02
C04 N03 N04 4.71e-06
R04 N03 N04 1.45e+00
C05 N04 N05 4.31e-06
R05 N04 N05 4.10e-01
C06 N05 N06 4.67e-05
R06 N05 N06 3.41e-01
C07 N06 N07 4.04e-06
R07 N06 N07 6.56e-02
C08 N07 N08 4.39e-06
R08 N07 N08 9.05e-03
L09 N08 N09 9.88e-11
R09 N08 N09 1.24e-01
L10 N09 N10 6.40e-12
R10 N09 N10 4.33e-02
C11 N10 N11 2.47e-07
L11 N10 N11 2.15e-11
R11 N10 N11 3.17e-02
C12 N11 N12 6.03e-08
L12 N11 N12 3.99e-11
R12 N11 N12 5.58e-02
C13 N12 N13 8.32e-12
L13 N12 N13 7.21e-11
R13 N12 N13 7.51e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 3.38e-11
R14 N13 Port2 1.53e+01
.ENDS GRT188R71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GRT2165C2A182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C2A182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 5.56e+11
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GRT2165C2A182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRT2165C2A222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C2A222JA02 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 4.55e+11
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GRT2165C2A222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GRT2165C2A272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C2A272JA02 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 3.70e+11
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GRT2165C2A272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GRT2165C2A332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C2A332JA02 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 3.03e+11
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRT2165C2A332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRT21B5C1H183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21B5C1H183JA02 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 5.56e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GRT21B5C1H183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRT21B5C1H223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21B5C1H223JA02 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 4.55e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GRT21B5C1H223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT21BC71E106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC71E106KE13 Port1 Port2
C01 Port1 N01 7.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.87e-10
R03 N02 N03 3.12e-03
C04 N03 N04 3.59e-04
R04 N03 N04 1.05e+01
C05 N04 N05 4.68e-04
R05 N04 N05 1.13e+00
C06 N05 N06 5.19e-04
R06 N05 N06 1.85e-01
C07 N06 N07 8.44e-04
R07 N06 N07 4.11e-02
C08 N07 N08 3.69e-04
R08 N07 N08 2.53e-02
C09 N08 N09 2.36e-04
R09 N08 N09 5.48e-03
L10 N09 N10 1.76e-11
R10 N09 N10 1.00e-01
L11 N10 N11 2.36e-11
R11 N10 N11 2.01e-02
L12 N11 N12 2.71e-10
R12 N11 N12 1.69e-02
C13 N12 N13 1.62e-05
L13 N12 N13 8.08e-11
R13 N12 N13 5.89e-03
C14 N13 N14 9.59e-06
L14 N13 N14 5.88e-11
R14 N13 N14 5.18e-03
C15 N14 N15 8.28e-12
L15 N14 N15 7.57e-11
R15 N14 N15 2.03e+01
C16 N15 Port2 7.44e-12
L16 N15 Port2 4.89e-11
R16 N15 Port2 1.29e+01
.ENDS GRT21BC71E106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRT21BC80G476ME13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC80G476ME13 Port1 Port2
C01 Port1 N01 3.55e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 9.05e-11
R03 N02 N03 1.62e-03
C04 N03 N04 1.31e-03
R04 N03 N04 4.05e+00
C05 N04 N05 1.75e-03
R05 N04 N05 3.57e-01
C06 N05 N06 2.34e-03
R06 N05 N06 2.90e-02
C07 N06 N07 2.97e-03
R07 N06 N07 2.18e-03
L08 N07 N08 1.39e-11
R08 N07 N08 6.34e-02
L09 N08 N09 6.62e-11
R09 N08 N09 2.53e-02
L10 N09 N10 3.97e-10
R10 N09 N10 9.41e-03
C11 N10 N11 3.11e-05
L11 N10 N11 2.18e-10
R11 N10 N11 2.51e-03
C12 N11 N12 2.00e-11
L12 N11 N12 5.83e-11
R12 N11 N12 6.42e+00
C13 N12 Port2 2.17e-12
L13 N12 Port2 1.22e-10
R13 N12 Port2 2.59e+01
.ENDS GRT21BC80G476ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT21BC81A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81A106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRT21BC81A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT21BC81A226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81A226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GRT21BC81A226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT21BC81C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81C106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRT21BC81C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT21BC81C225KA02
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81C225KA02 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRT21BC81C225KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT21BC81C475KA02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81C475KA02 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRT21BC81C475KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT21BC81E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81E105KE13 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 8.58e-11
R03 N02 N03 4.89e-03
C04 N03 N04 2.36e-05
R04 N03 N04 3.04e+02
C05 N04 N05 1.12e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.00e-01
C07 N06 N07 9.26e-05
R07 N06 N07 3.66e-02
C08 N07 N08 6.76e-05
R08 N07 N08 5.29e-03
L09 N08 N09 1.84e-11
R09 N08 N09 5.34e-02
L10 N09 N10 1.99e-10
R10 N09 N10 3.69e-02
C11 N10 N11 2.43e-06
L11 N10 N11 7.08e-11
R11 N10 N11 1.57e-02
C12 N11 N12 1.83e-06
L12 N11 N12 4.21e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.51e-11
L13 N12 N13 7.39e-11
R13 N12 N13 8.53e+00
C14 N13 Port2 1.91e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 3.37e+01
.ENDS GRT21BC81E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT21BC81E225KA02
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81E225KA02 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRT21BC81E225KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT21BC81E475KA02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81E475KA02 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRT21BC81E475KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRT21BC8YA225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC8YA225KE13 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRT21BC8YA225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRT21BC8YA475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC8YA475KE13 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.11e-11
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 9.27e-12
L14 N13 N14 8.46e-11
R14 N13 N14 1.12e+01
C15 N14 Port2 1.60e-12
L15 N14 Port2 1.35e-10
R15 N14 Port2 4.36e+01
.ENDS GRT21BC8YA475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRT21BR60J106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR60J106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRT21BR60J106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT21BR60J226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR60J226ME13 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 6.91e-11
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.15e-11
L14 N13 N14 7.32e-11
R14 N13 N14 8.61e+00
C15 N14 Port2 2.58e-12
L15 N14 Port2 1.02e-10
R15 N14 Port2 5.04e+01
.ENDS GRT21BR60J226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT21BR60J475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR60J475KE13 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 7.88e-11
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 9.22e-12
L14 N13 N14 6.66e-11
R14 N13 N14 7.73e+00
C15 N14 Port2 2.20e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 1.13e+02
.ENDS GRT21BR60J475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT21BR61A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61A106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRT21BR61A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT21BR61A226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61A226ME13 Port1 Port2
C01 Port1 N01 1.39e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.33e-10
R03 N02 N03 2.82e-03
C04 N03 N04 2.65e-04
R04 N03 N04 2.09e+01
C05 N04 N05 3.55e-04
R05 N04 N05 1.46e+00
C06 N05 N06 3.16e-04
R06 N05 N06 1.66e-01
C07 N06 N07 3.15e-04
R07 N06 N07 1.69e-02
C08 N07 N08 3.14e-04
R08 N07 N08 3.37e-03
L09 N08 N09 1.24e-11
R09 N08 N09 7.31e-02
L10 N09 N10 4.63e-11
R10 N09 N10 2.87e-02
L11 N10 N11 3.31e-10
R11 N10 N11 1.45e-02
C12 N11 N12 3.75e-05
L12 N11 N12 6.73e-11
R12 N11 N12 2.86e-03
C13 N12 N13 2.57e-05
L13 N12 N13 4.91e-11
R13 N12 N13 2.48e-03
C14 N13 N14 1.19e-11
L14 N13 N14 6.42e-11
R14 N13 N14 8.47e+00
C15 N14 Port2 5.63e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 3.66e+01
.ENDS GRT21BR61A226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRT21BR61A475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61A475KE13 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 7.88e-11
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 9.22e-12
L14 N13 N14 6.66e-11
R14 N13 N14 7.73e+00
C15 N14 Port2 2.20e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 1.13e+02
.ENDS GRT21BR61A475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT21BR61C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61C106KE01 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRT21BR61C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT21BR61C225KA02
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61C225KA02 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRT21BR61C225KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRT21BR61C226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61C226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GRT21BR61C226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT21BR61C475KA02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61C475KA02 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRT21BR61C475KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT21BR61E106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61E106KE13 Port1 Port2
C01 Port1 N01 6.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.11e-10
R03 N02 N03 3.02e-03
C04 N03 N04 2.84e-04
R04 N03 N04 3.48e+01
C05 N04 N05 2.29e-04
R05 N04 N05 8.23e+00
C06 N05 N06 2.02e-04
R06 N05 N06 9.38e-01
C07 N06 N07 2.04e-04
R07 N06 N07 9.49e-02
C08 N07 N08 1.63e-04
R08 N07 N08 1.34e-02
C09 N08 N09 3.02e-04
R09 N08 N09 1.32e-03
L10 N09 N10 1.85e-11
R10 N09 N10 9.97e-02
L11 N10 N11 2.87e-11
R11 N10 N11 2.30e-02
L12 N11 N12 2.72e-10
R12 N11 N12 1.97e-02
C13 N12 N13 2.72e-05
L13 N12 N13 4.42e-11
R13 N12 N13 4.05e-03
C14 N13 N14 5.96e-06
L14 N13 N14 9.84e-11
R14 N13 N14 5.27e-03
C15 N14 Port2 8.80e-12
L15 N14 Port2 7.08e-11
R15 N14 Port2 1.12e+01
.ENDS GRT21BR61E106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT21BR61E225KA02
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61E225KA02 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRT21BR61E225KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRT21BR61E226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61E226ME13 Port1 Port2
C01 Port1 N01 1.60e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.89e-11
R03 N02 N03 2.00e-03
C04 N03 N04 5.95e-04
R04 N03 N04 7.32e+00
C05 N04 N05 7.20e-04
R05 N04 N05 6.96e-01
C06 N05 N06 6.36e-04
R06 N05 N06 8.37e-02
C07 N06 N07 6.77e-04
R07 N06 N07 8.97e-03
C08 N07 N08 4.86e-04
R08 N07 N08 2.44e-03
L09 N08 N09 2.03e-11
R09 N08 N09 5.23e-02
L10 N09 N10 5.04e-11
R10 N09 N10 1.69e-02
L11 N10 N11 4.26e-10
R11 N10 N11 1.13e-02
C12 N11 N12 7.07e-05
L12 N11 N12 5.08e-11
R12 N11 N12 2.40e-03
C13 N12 N13 4.93e-05
L13 N12 N13 3.97e-11
R13 N12 N13 2.50e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.95e-11
R14 N13 N14 7.31e+00
C15 N14 N15 9.48e-12
L15 N14 N15 3.47e-11
R15 N14 N15 9.04e+00
C16 N15 Port2 2.41e-12
L16 N15 Port2 1.03e-10
R16 N15 Port2 1.00e+05
.ENDS GRT21BR61E226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT21BR61E475KA02
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61E475KA02 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRT21BR61E475KA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT21BR61H225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61H225KE13 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRT21BR61H225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRT21BR61H475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61H475KE13 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.11e-11
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 9.27e-12
L14 N13 N14 8.46e-11
R14 N13 N14 1.12e+01
C15 N14 Port2 1.60e-12
L15 N14 Port2 1.35e-10
R15 N14 Port2 4.36e+01
.ENDS GRT21BR61H475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRT21BR70J106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR70J106KE13 Port1 Port2
C01 Port1 N01 6.49e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.55e-10
R03 N02 N03 3.00e-03
C04 N03 N04 1.15e-04
R04 N03 N04 4.60e+01
C05 N04 N05 1.94e-04
R05 N04 N05 1.69e+00
C06 N05 N06 1.75e-04
R06 N05 N06 1.30e-01
C07 N06 N07 1.36e-04
R07 N06 N07 1.21e-02
C08 N07 N08 5.68e-04
R08 N07 N08 2.29e-04
L09 N08 N09 4.13e-11
R09 N08 N09 3.53e-02
L10 N09 N10 3.30e-10
R10 N09 N10 1.75e-02
C11 N10 N11 2.90e-05
L11 N10 N11 4.14e-11
R11 N10 N11 4.76e-03
C12 N11 N12 1.56e-05
L12 N11 N12 3.95e-11
R12 N11 N12 4.16e-03
C13 N12 Port2 6.42e-12
L13 N12 Port2 1.04e-10
R13 N12 Port2 1.01e+01
.ENDS GRT21BR70J106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT21BR71A106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71A106KE13 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GRT21BR71A106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRT21BR71A475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71A475KE13 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GRT21BR71A475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRT21BR71C225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71C225KE01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRT21BR71C225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT21BR71C475KE13
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71C475KE13 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 6.11e-11
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 9.27e-12
L14 N13 N14 8.46e-11
R14 N13 N14 1.12e+01
C15 N14 Port2 1.60e-12
L15 N14 Port2 1.35e-10
R15 N14 Port2 4.36e+01
.ENDS GRT21BR71C475KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRT21BR71E105KE13
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71E105KE13 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 8.58e-11
R03 N02 N03 4.89e-03
C04 N03 N04 2.36e-05
R04 N03 N04 3.04e+02
C05 N04 N05 1.12e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.00e-01
C07 N06 N07 9.26e-05
R07 N06 N07 3.66e-02
C08 N07 N08 6.76e-05
R08 N07 N08 5.29e-03
L09 N08 N09 1.84e-11
R09 N08 N09 5.34e-02
L10 N09 N10 1.99e-10
R10 N09 N10 3.69e-02
C11 N10 N11 2.43e-06
L11 N10 N11 7.08e-11
R11 N10 N11 1.57e-02
C12 N11 N12 1.83e-06
L12 N11 N12 4.21e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.51e-11
L13 N12 N13 7.39e-11
R13 N12 N13 8.53e+00
C14 N13 Port2 1.91e-12
L14 N13 Port2 1.76e-10
R14 N13 Port2 3.37e+01
.ENDS GRT21BR71E105KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRT21BR71E225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71E225KE13 Port1 Port2
C01 Port1 N01 1.85e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.56e-11
R03 N02 N03 4.83e-03
C04 N03 N04 1.77e-05
R04 N03 N04 3.86e+02
C05 N04 N05 5.67e-05
R05 N04 N05 8.49e+00
C06 N05 N06 4.92e-05
R06 N05 N06 9.87e-01
C07 N06 N07 3.91e-05
R07 N06 N07 1.23e-01
C08 N07 N08 2.92e-05
R08 N07 N08 1.64e-02
L09 N08 N09 7.30e-12
R09 N08 N09 4.41e-02
L10 N09 N10 2.22e-11
R10 N09 N10 3.12e-02
L11 N10 N11 2.40e-10
R11 N10 N11 3.08e-02
C12 N11 N12 5.46e-06
L12 N11 N12 4.73e-11
R12 N11 N12 1.20e-02
C13 N12 N13 2.78e-06
L13 N12 N13 4.65e-11
R13 N12 N13 1.18e-02
C14 N13 N14 8.94e-12
L14 N13 N14 8.64e-11
R14 N13 N14 1.02e+01
C15 N14 Port2 1.61e-12
L15 N14 Port2 1.33e-10
R15 N14 Port2 7.29e+01
.ENDS GRT21BR71E225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRT21BR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71H105KE01 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 7.42e-11
R03 N02 N03 3.95e-03
C04 N03 N04 2.83e-05
R04 N03 N04 2.36e+02
C05 N04 N05 1.58e-04
R05 N04 N05 1.60e+00
C06 N05 N06 1.60e-04
R06 N05 N06 1.45e-01
C07 N06 N07 1.35e-04
R07 N06 N07 1.68e-02
C08 N07 N08 1.32e-04
R08 N07 N08 1.80e-03
L09 N08 N09 1.85e-10
R09 N08 N09 3.32e-02
L10 N09 N10 1.32e-11
R10 N09 N10 2.59e-02
C11 N10 N11 3.39e-06
L11 N10 N11 4.78e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.96e-06
L12 N11 N12 3.67e-11
R12 N11 N12 1.82e-02
C13 N12 N13 1.19e-11
L13 N12 N13 9.44e-11
R13 N12 N13 9.28e+00
C14 N13 Port2 1.87e-12
L14 N13 Port2 1.62e-10
R14 N13 Port2 4.64e+01
.ENDS GRT21BR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRT21BR71H474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR71H474KE01 Port1 Port2
C01 Port1 N01 4.52e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.60e-10
R03 N02 N03 6.95e-03
C04 N03 N04 8.62e-05
R04 N03 N04 1.17e-01
C05 N04 N05 6.84e-05
R05 N04 N05 6.15e-02
C06 N05 N06 1.59e-04
R06 N05 N06 1.69e-02
C07 N06 N07 3.75e-05
R07 N06 N07 1.46e-02
C08 N07 N08 1.17e-04
R08 N07 N08 7.75e-04
L09 N08 N09 1.36e-10
R09 N08 N09 4.20e-02
L10 N09 N10 1.25e-11
R10 N09 N10 2.94e-02
C11 N10 N11 1.65e-06
L11 N10 N11 4.45e-11
R11 N10 N11 2.43e-02
C12 N11 N12 5.80e-07
L12 N11 N12 5.43e-11
R12 N11 N12 2.44e-02
C13 N12 N13 1.36e-11
L13 N12 N13 7.11e-11
R13 N12 N13 9.55e+00
C14 N13 Port2 2.23e-12
L14 N13 Port2 1.57e-10
R14 N13 Port2 2.57e+01
.ENDS GRT21BR71H474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRT3195C2A103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A103JA02 Port1 Port2
C01 Port1 N01 9.98e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.15e-10
R03 N02 N03 7.67e-03
L04 N03 N04 1.23e-10
R04 N03 N04 3.54e-01
L05 N04 N05 1.01e-10
R05 N04 N05 1.22e-02
C06 N05 N06 4.35e-08
L06 N05 N06 4.53e-11
R06 N05 N06 1.98e-01
C07 N06 N07 1.15e-08
L07 N06 N07 6.51e-11
R07 N06 N07 3.14e-01
C08 N07 N08 9.30e-08
L08 N07 N08 4.06e-12
R08 N07 N08 2.31e-02
C09 N08 N09 9.06e-09
L09 N08 N09 2.33e-11
R09 N08 N09 1.48e-01
C10 N09 N10 1.28e-12
L10 N09 N10 3.52e-10
R10 N09 N10 1.00e+05
C11 N10 Port2 7.16e-12
L11 N10 Port2 6.17e-11
R11 N10 Port2 1.45e+01
.ENDS GRT3195C2A103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GRT3195C2A183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A183JA02 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 5.56e+10
L02 N01 N02 4.80e-11
R03 N02 N03 6.37e-03
L04 N03 N04 2.84e-11
R04 N03 N04 1.10e+00
L05 N04 N05 1.02e-10
R05 N04 N05 1.81e-01
L06 N05 N06 5.19e-11
R06 N05 N06 7.68e-03
L07 N06 N07 1.82e-10
R07 N06 N07 2.92e-03
C08 N07 N08 8.59e-08
L08 N07 N08 2.99e-11
R08 N07 N08 1.57e-01
C09 N08 N09 1.76e-08
L09 N08 N09 5.80e-11
R09 N08 N09 2.35e-01
C10 N09 Port2 8.46e-13
L10 N09 Port2 4.64e-10
R10 N09 Port2 1.18e+03
.ENDS GRT3195C2A183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRT3195C2A223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A223JA02 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+10
L02 N01 N02 5.00e-11
R03 N02 N03 6.49e-03
L04 N03 N04 1.25e-10
R04 N03 N04 2.04e-01
L05 N04 N05 1.01e-11
R05 N04 N05 1.65e-01
L06 N05 N06 7.77e-11
R06 N05 N06 6.57e-03
C07 N06 N07 7.52e-08
L07 N06 N07 4.72e-11
R07 N06 N07 1.80e-01
C08 N07 N08 2.55e-08
L08 N07 N08 5.57e-11
R08 N07 N08 2.52e-01
C09 N08 N09 9.33e-08
L09 N08 N09 6.87e-12
R09 N08 N09 3.05e-02
C10 N09 N10 3.46e-08
L10 N09 N10 1.12e-11
R10 N09 N10 6.20e-02
C11 N10 Port2 8.75e-13
L11 N10 Port2 4.29e-10
R11 N10 Port2 1.00e+03
.ENDS GRT3195C2A223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GRT3195C2A392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A392JA02 Port1 Port2
C01 Port1 N01 3.98e-09
R01 Port1 N01 2.56e+11
L02 N01 N02 9.83e-12
R03 N02 N03 7.74e-03
L04 N03 N04 1.04e-10
R04 N03 N04 5.04e-01
L05 N04 N05 8.04e-11
R05 N04 N05 1.76e-02
L06 N05 N06 2.06e-10
R06 N05 N06 3.90e-03
C07 N06 N07 1.85e-08
L07 N06 N07 3.88e-11
R07 N06 N07 3.09e-01
C08 N07 N08 4.75e-09
L08 N07 N08 5.00e-11
R08 N07 N08 4.62e-01
C09 N08 Port2 8.02e-13
L09 N08 Port2 5.83e-10
R09 N08 Port2 9.31e+02
.ENDS GRT3195C2A392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRT3195C2A472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 2.13e+11
L02 N01 N02 6.50e-11
R03 N02 N03 8.82e-03
L04 N03 N04 1.29e-10
R04 N03 N04 4.56e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.44e-02
C06 N05 N06 2.52e-08
L06 N05 N06 3.45e-11
R06 N05 N06 2.85e-01
C07 N06 N07 6.70e-09
L07 N06 N07 4.49e-11
R07 N06 N07 3.99e-01
C08 N07 N08 7.43e-08
L08 N07 N08 2.08e-12
R08 N07 N08 1.68e-02
C09 N08 N09 8.56e-09
L09 N08 N09 9.67e-12
R09 N08 N09 1.04e-01
C10 N09 N10 9.75e-13
L10 N09 N10 3.85e-10
R10 N09 N10 2.00e+07
C11 N10 Port2 2.77e-12
L11 N10 Port2 1.07e-10
R11 N10 Port2 2.76e+01
.ENDS GRT3195C2A472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GRT3195C2A562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A562JA02 Port1 Port2
C01 Port1 N01 5.70e-09
R01 Port1 N01 1.79e+11
L02 N01 N02 6.61e-11
R03 N02 N03 8.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 4.27e-01
L05 N04 N05 7.94e-11
R05 N04 N05 1.29e-02
C06 N05 N06 2.52e-08
L06 N05 N06 4.36e-11
R06 N05 N06 3.66e-01
C07 N06 N07 7.85e-09
L07 N06 N07 5.26e-11
R07 N06 N07 5.30e-01
C08 N07 Port2 9.50e-13
L08 N07 Port2 4.43e-10
R08 N07 Port2 2.08e+02
.ENDS GRT3195C2A562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRT3195C2A682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A682JA02 Port1 Port2
C01 Port1 N01 6.73e-09
R01 Port1 N01 1.47e+11
L02 N01 N02 5.00e-11
R03 N02 N03 9.57e-03
L04 N03 N04 1.11e-10
R04 N03 N04 3.20e-01
L05 N04 N05 1.32e-10
R05 N04 N05 1.24e-02
C06 N05 N06 3.38e-08
L06 N05 N06 3.53e-11
R06 N05 N06 1.72e-01
C07 N06 N07 8.34e-09
L07 N06 N07 4.64e-11
R07 N06 N07 3.32e-01
C08 N07 N08 1.30e-07
L08 N07 N08 1.70e-12
R08 N07 N08 1.05e-02
C09 N08 N09 1.03e-08
L09 N08 N09 9.95e-12
R09 N08 N09 8.99e-02
C10 N09 Port2 8.81e-13
L10 N09 Port2 5.96e-10
R10 N09 Port2 1.00e+03
.ENDS GRT3195C2A682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GRT3195C2A822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT3195C2A822JA02 Port1 Port2
C01 Port1 N01 8.12e-09
R01 Port1 N01 1.22e+11
L02 N01 N02 3.13e-11
R03 N02 N03 6.88e-03
L04 N03 N04 1.86e-11
R04 N03 N04 4.97e-01
L05 N04 N05 1.15e-10
R05 N04 N05 2.75e-01
L06 N05 N06 4.32e-11
R06 N05 N06 7.17e-03
L07 N06 N07 1.41e-10
R07 N06 N07 4.97e-03
C08 N07 N08 4.69e-08
L08 N07 N08 3.20e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.14e-08
L09 N08 N09 4.74e-11
R09 N08 N09 3.22e-01
C10 N09 Port2 7.65e-13
L10 N09 Port2 5.61e-10
R10 N09 Port2 6.42e+02
.ENDS GRT3195C2A822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GRT31C5C1C124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1C124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 8.33e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GRT31C5C1C124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRT31C5C1E104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1E104JA02 Port1 Port2
C01 Port1 N01 9.75e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-11
R03 N02 N03 3.57e-03
L04 N03 N04 1.82e-11
R04 N03 N04 2.43e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.28e-01
L06 N05 N06 4.95e-11
R06 N05 N06 1.20e-02
C07 N06 N07 2.06e-07
L07 N06 N07 1.26e-10
R07 N06 N07 1.90e-01
C08 N07 N08 1.87e-07
L08 N07 N08 6.53e-11
R08 N07 N08 1.78e-01
C09 N08 N09 5.49e-07
L09 N08 N09 1.18e-11
R09 N08 N09 5.07e-02
C10 N09 N10 1.38e-07
L10 N09 N10 2.98e-11
R10 N09 N10 5.85e-02
C11 N10 N11 1.35e-07
L11 N10 N11 1.70e-11
R11 N10 N11 3.93e-02
C12 N11 Port2 8.47e-13
L12 N11 Port2 4.01e-10
R12 N11 Port2 5.01e+02
.ENDS GRT31C5C1E104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GRT31C5C1E124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1E124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 8.33e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GRT31C5C1E124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRT31C5C1H104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1H104JA02 Port1 Port2
C01 Port1 N01 9.75e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-11
R03 N02 N03 3.57e-03
L04 N03 N04 1.82e-11
R04 N03 N04 2.43e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.28e-01
L06 N05 N06 4.95e-11
R06 N05 N06 1.20e-02
C07 N06 N07 2.06e-07
L07 N06 N07 1.26e-10
R07 N06 N07 1.90e-01
C08 N07 N08 1.87e-07
L08 N07 N08 6.53e-11
R08 N07 N08 1.78e-01
C09 N08 N09 5.49e-07
L09 N08 N09 1.18e-11
R09 N08 N09 5.07e-02
C10 N09 N10 1.38e-07
L10 N09 N10 2.98e-11
R10 N09 N10 5.85e-02
C11 N10 N11 1.35e-07
L11 N10 N11 1.70e-11
R11 N10 N11 3.93e-02
C12 N11 Port2 8.47e-13
L12 N11 Port2 4.01e-10
R12 N11 Port2 5.01e+02
.ENDS GRT31C5C1H104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GRT31C5C1H563JA02
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1H563JA02 Port1 Port2
C01 Port1 N01 5.61e-08
R01 Port1 N01 1.79e+10
L02 N01 N02 1.36e-11
R03 N02 N03 3.44e-03
L04 N03 N04 1.80e-10
R04 N03 N04 1.28e-01
L05 N04 N05 5.96e-12
R05 N04 N05 3.29e-02
L06 N05 N06 1.87e-10
R06 N05 N06 3.16e-03
C07 N06 N07 2.37e-07
L07 N06 N07 5.87e-11
R07 N06 N07 2.12e-01
C08 N07 N08 8.93e-08
L08 N07 N08 7.01e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.47e-07
L09 N08 N09 2.12e-11
R09 N08 N09 6.26e-02
C10 N09 N10 1.14e-07
L10 N09 N10 1.69e-11
R10 N09 N10 7.16e-02
C11 N10 Port2 9.39e-13
L11 N10 Port2 5.29e-10
R11 N10 Port2 7.76e+02
.ENDS GRT31C5C1H563JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GRT31C5C1H683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1H683JA02 Port1 Port2
C01 Port1 N01 6.66e-08
R01 Port1 N01 1.47e+10
L02 N01 N02 2.88e-12
R03 N02 N03 3.97e-03
L04 N03 N04 1.61e-11
R04 N03 N04 2.79e-01
L05 N04 N05 1.83e-10
R05 N04 N05 1.31e-01
L06 N05 N06 2.89e-11
R06 N05 N06 6.16e-03
C07 N06 N07 2.14e-07
L07 N06 N07 7.47e-11
R07 N06 N07 1.68e-01
C08 N07 N08 8.34e-08
L08 N07 N08 8.56e-11
R08 N07 N08 1.92e-01
C09 N08 N09 2.68e-07
L09 N08 N09 1.31e-11
R09 N08 N09 3.29e-02
C10 N09 N10 1.21e-07
L10 N09 N10 1.84e-11
R10 N09 N10 5.42e-02
C11 N10 N11 2.23e-07
L11 N10 N11 5.08e-12
R11 N10 N11 1.87e-02
C12 N11 Port2 7.41e-13
L12 N11 Port2 4.94e-10
R12 N11 Port2 7.24e+02
.ENDS GRT31C5C1H683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GRT31C5C1H823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31C5C1H823JA02 Port1 Port2
C01 Port1 N01 8.17e-08
R01 Port1 N01 1.22e+10
L02 N01 N02 1.60e-10
R03 N02 N03 3.14e-03
L04 N03 N04 1.92e-10
R04 N03 N04 1.47e-01
L05 N04 N05 1.69e-10
R05 N04 N05 2.87e-03
C06 N05 N06 2.23e-07
L06 N05 N06 9.69e-11
R06 N05 N06 2.18e-01
C07 N06 N07 1.26e-07
L07 N06 N07 8.03e-11
R07 N06 N07 1.95e-01
C08 N07 N08 2.26e-07
L08 N07 N08 2.31e-11
R08 N07 N08 6.90e-02
C09 N08 N09 1.30e-07
L09 N08 N09 2.61e-11
R09 N08 N09 8.41e-02
C10 N09 Port2 1.33e-12
L10 N09 Port2 2.96e-10
R10 N09 Port2 2.00e+02
.ENDS GRT31C5C1H823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRT31CC80G226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC80G226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CC80G226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRT31CC80G476ME01
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC80G476ME01 Port1 Port2
C01 Port1 N01 3.65e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.15e-11
R03 N02 N03 1.73e-03
C04 N03 N04 1.71e-03
R04 N03 N04 3.49e+00
C05 N04 N05 2.23e-03
R05 N04 N05 2.66e-01
C06 N05 N06 2.09e-03
R06 N05 N06 3.42e-02
C07 N06 N07 2.43e-03
R07 N06 N07 3.53e-03
C08 N07 N08 1.59e-03
R08 N07 N08 4.60e-04
L09 N08 N09 2.28e-11
R09 N08 N09 4.93e-02
L10 N09 N10 9.62e-11
R10 N09 N10 2.23e-02
L11 N10 N11 5.63e-10
R11 N10 N11 1.08e-02
C12 N11 N12 9.99e-05
L12 N11 N12 1.30e-10
R12 N11 N12 1.90e-03
C13 N12 N13 8.22e-05
L13 N12 N13 8.20e-11
R13 N12 N13 1.76e-03
C14 N13 N14 3.77e-11
L14 N13 N14 5.29e-11
R14 N13 N14 3.81e+00
C15 N14 Port2 1.13e-12
L15 N14 Port2 3.91e-10
R15 N14 Port2 1.07e+02
.ENDS GRT31CC80G476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT31CC80J226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC80J226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CC80J226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRT31CC80J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC80J476KE13 Port1 Port2
C01 Port1 N01 3.65e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.15e-11
R03 N02 N03 1.73e-03
C04 N03 N04 1.71e-03
R04 N03 N04 3.49e+00
C05 N04 N05 2.23e-03
R05 N04 N05 2.66e-01
C06 N05 N06 2.09e-03
R06 N05 N06 3.42e-02
C07 N06 N07 2.43e-03
R07 N06 N07 3.53e-03
C08 N07 N08 1.59e-03
R08 N07 N08 4.60e-04
L09 N08 N09 2.28e-11
R09 N08 N09 4.93e-02
L10 N09 N10 9.62e-11
R10 N09 N10 2.23e-02
L11 N10 N11 5.63e-10
R11 N10 N11 1.08e-02
C12 N11 N12 9.99e-05
L12 N11 N12 1.30e-10
R12 N11 N12 1.90e-03
C13 N12 N13 8.22e-05
L13 N12 N13 8.20e-11
R13 N12 N13 1.76e-03
C14 N13 N14 3.77e-11
L14 N13 N14 5.29e-11
R14 N13 N14 3.81e+00
C15 N14 Port2 1.13e-12
L15 N14 Port2 3.91e-10
R15 N14 Port2 1.07e+02
.ENDS GRT31CC80J476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT31CC81A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81A106KE01 Port1 Port2
C01 Port1 N01 9.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.27e-11
R03 N02 N03 2.56e-03
C04 N03 N04 1.25e-03
R04 N03 N04 2.64e+00
C05 N04 N05 1.71e-03
R05 N04 N05 3.76e-01
C06 N05 N06 1.17e-03
R06 N05 N06 8.46e-02
C07 N06 N07 1.29e-03
R07 N06 N07 1.12e-02
C08 N07 N08 1.10e-03
R08 N07 N08 2.07e-03
L09 N08 N09 2.31e-11
R09 N08 N09 7.11e-02
L10 N09 N10 6.46e-11
R10 N09 N10 2.72e-02
L11 N10 N11 4.78e-10
R11 N10 N11 1.79e-02
C12 N11 N12 2.96e-05
L12 N11 N12 1.07e-10
R12 N11 N12 5.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 8.05e-11
R13 N12 N13 5.10e-03
C14 N13 N14 2.07e-11
L14 N13 N14 4.06e-11
R14 N13 N14 2.85e+00
C15 N14 Port2 1.37e-12
L15 N14 Port2 2.50e-10
R15 N14 Port2 9.70e+01
.ENDS GRT31CC81A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT31CC81A106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81A106ME01 Port1 Port2
C01 Port1 N01 9.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.27e-11
R03 N02 N03 2.56e-03
C04 N03 N04 1.25e-03
R04 N03 N04 2.64e+00
C05 N04 N05 1.71e-03
R05 N04 N05 3.76e-01
C06 N05 N06 1.17e-03
R06 N05 N06 8.46e-02
C07 N06 N07 1.29e-03
R07 N06 N07 1.12e-02
C08 N07 N08 1.10e-03
R08 N07 N08 2.07e-03
L09 N08 N09 2.31e-11
R09 N08 N09 7.11e-02
L10 N09 N10 6.46e-11
R10 N09 N10 2.72e-02
L11 N10 N11 4.78e-10
R11 N10 N11 1.79e-02
C12 N11 N12 2.96e-05
L12 N11 N12 1.07e-10
R12 N11 N12 5.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 8.05e-11
R13 N12 N13 5.10e-03
C14 N13 N14 2.07e-11
L14 N13 N14 4.06e-11
R14 N13 N14 2.85e+00
C15 N14 Port2 1.37e-12
L15 N14 Port2 2.50e-10
R15 N14 Port2 9.70e+01
.ENDS GRT31CC81A106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT31CC81A226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81A226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CC81A226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT31CC81C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CC81C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT31CC81C106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CC81C106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRT31CC81C226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CC81C226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT31CC81C475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C475KE01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CC81C475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT31CC81C475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C475ME01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CC81C475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT31CC81E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81E106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CC81E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT31CC81E475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81E475KE01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CC81E475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT31CC81H225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81H225KE01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.30e-11
R03 N02 N03 4.10e-03
C04 N03 N04 4.57e-04
R04 N03 N04 5.45e+00
C05 N04 N05 4.29e-04
R05 N04 N05 8.45e-01
C06 N05 N06 2.95e-04
R06 N05 N06 1.76e-01
C07 N06 N07 2.53e-04
R07 N06 N07 2.75e-02
C08 N07 N08 1.79e-04
R08 N07 N08 4.72e-03
L09 N08 N09 2.33e-11
R09 N08 N09 5.93e-02
L10 N09 N10 3.38e-10
R10 N09 N10 3.33e-02
L11 N10 N11 1.90e-11
R11 N10 N11 1.67e-02
C12 N11 N12 5.98e-06
L12 N11 N12 9.74e-11
R12 N11 N12 1.57e-02
C13 N12 N13 3.55e-06
L13 N12 N13 7.24e-11
R13 N12 N13 1.45e-02
C14 N13 N14 2.68e-11
L14 N13 N14 4.31e-11
R14 N13 N14 3.91e+00
C15 N14 Port2 1.06e-12
L15 N14 Port2 3.23e-10
R15 N14 Port2 1.50e+02
.ENDS GRT31CC81H225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRT31CC8YA106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC8YA106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CC8YA106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRT31CC8YA106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC8YA106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CC8YA106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT31CR60J226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR60J226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CR60J226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRT31CR60J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR60J476KE13 Port1 Port2
C01 Port1 N01 3.65e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.15e-11
R03 N02 N03 1.73e-03
C04 N03 N04 1.71e-03
R04 N03 N04 3.49e+00
C05 N04 N05 2.23e-03
R05 N04 N05 2.66e-01
C06 N05 N06 2.09e-03
R06 N05 N06 3.42e-02
C07 N06 N07 2.43e-03
R07 N06 N07 3.53e-03
C08 N07 N08 1.59e-03
R08 N07 N08 4.60e-04
L09 N08 N09 2.28e-11
R09 N08 N09 4.93e-02
L10 N09 N10 9.62e-11
R10 N09 N10 2.23e-02
L11 N10 N11 5.63e-10
R11 N10 N11 1.08e-02
C12 N11 N12 9.99e-05
L12 N11 N12 1.30e-10
R12 N11 N12 1.90e-03
C13 N12 N13 8.22e-05
L13 N12 N13 8.20e-11
R13 N12 N13 1.76e-03
C14 N13 N14 3.77e-11
L14 N13 N14 5.29e-11
R14 N13 N14 3.81e+00
C15 N14 Port2 1.13e-12
L15 N14 Port2 3.91e-10
R15 N14 Port2 1.07e+02
.ENDS GRT31CR60J476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT31CR61A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61A106KE01 Port1 Port2
C01 Port1 N01 9.09e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.00e-10
R03 N02 N03 2.65e-03
C04 N03 N04 1.10e-03
R04 N03 N04 4.23e+00
C05 N04 N05 1.19e-03
R05 N04 N05 4.20e-01
C06 N05 N06 1.02e-03
R06 N05 N06 6.02e-02
C07 N06 N07 1.90e-03
R07 N06 N07 8.05e-03
C08 N07 N08 8.61e-04
R08 N07 N08 3.44e-03
L09 N08 N09 3.25e-11
R09 N08 N09 1.18e-01
L10 N09 N10 9.35e-11
R10 N09 N10 4.84e-02
L11 N10 N11 4.37e-10
R11 N10 N11 1.68e-02
C12 N11 N12 3.34e-05
L12 N11 N12 9.17e-11
R12 N11 N12 4.76e-03
C13 N12 N13 1.29e-05
L13 N12 N13 1.10e-10
R13 N12 N13 5.58e-03
C14 N13 N14 1.71e-11
L14 N13 N14 7.87e-11
R14 N13 N14 4.92e+00
C15 N14 Port2 1.64e-12
L15 N14 Port2 2.66e-10
R15 N14 Port2 1.53e+02
.ENDS GRT31CR61A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT31CR61A226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61A226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CR61A226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRT31CR61A476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61A476KE13 Port1 Port2
C01 Port1 N01 3.65e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.15e-11
R03 N02 N03 1.73e-03
C04 N03 N04 1.71e-03
R04 N03 N04 3.49e+00
C05 N04 N05 2.23e-03
R05 N04 N05 2.66e-01
C06 N05 N06 2.09e-03
R06 N05 N06 3.42e-02
C07 N06 N07 2.43e-03
R07 N06 N07 3.53e-03
C08 N07 N08 1.59e-03
R08 N07 N08 4.60e-04
L09 N08 N09 2.28e-11
R09 N08 N09 4.93e-02
L10 N09 N10 9.62e-11
R10 N09 N10 2.23e-02
L11 N10 N11 5.63e-10
R11 N10 N11 1.08e-02
C12 N11 N12 9.99e-05
L12 N11 N12 1.30e-10
R12 N11 N12 1.90e-03
C13 N12 N13 8.22e-05
L13 N12 N13 8.20e-11
R13 N12 N13 1.76e-03
C14 N13 N14 3.77e-11
L14 N13 N14 5.29e-11
R14 N13 N14 3.81e+00
C15 N14 Port2 1.13e-12
L15 N14 Port2 3.91e-10
R15 N14 Port2 1.07e+02
.ENDS GRT31CR61A476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT31CR61C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61C106KE01 Port1 Port2
C01 Port1 N01 9.55e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 6.68e-11
R03 N02 N03 3.07e-03
C04 N03 N04 1.27e-03
R04 N03 N04 3.24e+00
C05 N04 N05 1.56e-03
R05 N04 N05 4.23e-01
C06 N05 N06 1.03e-03
R06 N05 N06 9.41e-02
C07 N06 N07 9.42e-04
R07 N06 N07 1.25e-02
C08 N07 N08 1.04e-03
R08 N07 N08 1.86e-03
L09 N08 N09 1.09e-10
R09 N08 N09 5.49e-02
L10 N09 N10 3.60e-10
R10 N09 N10 1.70e-02
C11 N10 N11 3.68e-05
L11 N10 N11 9.07e-11
R11 N10 N11 4.32e-03
C12 N11 N12 1.24e-05
L12 N11 N12 1.24e-10
R12 N11 N12 5.51e-03
C13 N12 N13 7.29e-10
L13 N12 N13 6.26e-11
R13 N12 N13 1.93e-01
C14 N13 N14 2.14e-11
L14 N13 N14 5.20e-11
R14 N13 N14 3.38e+00
C15 N14 Port2 1.11e-12
L15 N14 Port2 3.10e-10
R15 N14 Port2 1.20e+02
.ENDS GRT31CR61C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRT31CR61C226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61C226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CR61C226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT31CR61C475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61C475KE01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CR61C475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT31CR61C475ME01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61C475ME01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CR61C475ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT31CR61E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CR61E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT31CR61E106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CR61E106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRT31CR61E226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E226KE01 Port1 Port2
C01 Port1 N01 1.78e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.19e-11
R03 N02 N03 2.04e-03
C04 N03 N04 8.84e-04
R04 N03 N04 6.29e+00
C05 N04 N05 9.43e-04
R05 N04 N05 5.36e-01
C06 N05 N06 8.69e-04
R06 N05 N06 6.07e-02
C07 N06 N07 8.87e-04
R07 N06 N07 5.92e-03
C08 N07 N08 3.77e-04
R08 N07 N08 8.38e-04
L09 N08 N09 6.38e-11
R09 N08 N09 2.87e-02
L10 N09 N10 9.57e-12
R10 N09 N10 2.68e-02
L11 N10 N11 5.33e-10
R11 N10 N11 1.39e-02
C12 N11 N12 6.04e-05
L12 N11 N12 8.25e-11
R12 N11 N12 2.94e-03
C13 N12 N13 2.51e-05
L13 N12 N13 9.23e-11
R13 N12 N13 3.18e-03
C14 N13 N14 1.15e-11
L14 N13 N14 9.41e-11
R14 N13 N14 9.58e+00
C15 N14 Port2 1.31e-12
L15 N14 Port2 3.14e-10
R15 N14 Port2 1.26e+02
.ENDS GRT31CR61E226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/3.30e+00[uF]/25[V]
* Murata P/N :GRT31CR61E335KE01
* Property : C = 3.30e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E335KE01 Port1 Port2
C01 Port1 N01 3.20e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 1.23e-10
R03 N02 N03 4.33e-03
C04 N03 N04 7.28e-04
R04 N03 N04 6.27e+00
C05 N04 N05 7.67e-04
R05 N04 N05 8.98e-01
C06 N05 N06 4.64e-04
R06 N05 N06 2.48e-01
C07 N06 N07 4.29e-04
R07 N06 N07 3.63e-02
C08 N07 N08 2.47e-04
R08 N07 N08 5.96e-03
L09 N08 N09 5.14e-11
R09 N08 N09 4.37e-02
L10 N09 N10 3.71e-10
R10 N09 N10 2.40e-02
C11 N10 N11 1.97e-05
L11 N10 N11 4.46e-11
R11 N10 N11 5.58e-03
C12 N11 N12 7.25e-06
L12 N11 N12 5.13e-11
R12 N11 N12 6.76e-03
C13 N12 N13 3.15e-11
L13 N12 N13 7.06e-11
R13 N12 N13 6.99e+00
C14 N13 Port2 1.38e-12
L14 N13 Port2 4.30e-10
R14 N13 Port2 5.79e+01
.ENDS GRT31CR61E335KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT31CR61E475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E475KE01 Port1 Port2
C01 Port1 N01 4.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-11
R03 N02 N03 3.16e-03
C04 N03 N04 6.60e-04
R04 N03 N04 6.56e+00
C05 N04 N05 9.25e-04
R05 N04 N05 1.02e+00
C06 N05 N06 7.02e-04
R06 N05 N06 2.83e-01
C07 N06 N07 5.70e-04
R07 N06 N07 5.64e-02
C08 N07 N08 7.82e-04
R08 N07 N08 7.08e-03
C09 N08 N09 4.82e-04
R09 N08 N09 2.69e-03
L10 N09 N10 1.27e-11
R10 N09 N10 3.91e-02
L11 N10 N11 4.14e-11
R11 N10 N11 2.89e-02
L12 N11 N12 3.68e-10
R12 N11 N12 2.19e-02
C13 N12 N13 1.56e-05
L13 N12 N13 8.52e-11
R13 N12 N13 8.46e-03
C14 N13 N14 6.66e-06
L14 N13 N14 9.05e-11
R14 N13 N14 8.92e-03
C15 N14 N15 1.88e-11
L15 N14 N15 6.52e-11
R15 N14 N15 4.47e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.79e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CR61E475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRT31CR61H106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61H106KE01 Port1 Port2
C01 Port1 N01 7.09e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 6.17e-11
R03 N02 N03 2.97e-03
C04 N03 N04 2.58e-04
R04 N03 N04 1.79e+01
C05 N04 N05 2.46e-04
R05 N04 N05 1.74e+00
C06 N05 N06 2.65e-04
R06 N05 N06 1.59e-01
C07 N06 N07 2.29e-04
R07 N06 N07 2.21e-02
C08 N07 N08 1.29e-04
R08 N07 N08 5.43e-03
L09 N08 N09 6.61e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.85e-10
R10 N09 N10 1.66e-02
C11 N10 N11 4.49e-05
L11 N10 N11 3.97e-11
R11 N10 N11 4.31e-03
C12 N11 N12 2.18e-05
L12 N11 N12 3.99e-11
R12 N11 N12 4.28e-03
C13 N12 N13 8.03e-12
L13 N12 N13 1.42e-10
R13 N12 N13 1.99e+01
C14 N13 Port2 1.63e-12
L14 N13 Port2 2.91e-10
R14 N13 Port2 1.16e+02
.ENDS GRT31CR61H106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT31CR61H225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61H225KE01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.30e-11
R03 N02 N03 4.10e-03
C04 N03 N04 4.57e-04
R04 N03 N04 5.45e+00
C05 N04 N05 4.29e-04
R05 N04 N05 8.45e-01
C06 N05 N06 2.95e-04
R06 N05 N06 1.76e-01
C07 N06 N07 2.53e-04
R07 N06 N07 2.75e-02
C08 N07 N08 1.79e-04
R08 N07 N08 4.72e-03
L09 N08 N09 2.33e-11
R09 N08 N09 5.93e-02
L10 N09 N10 3.38e-10
R10 N09 N10 3.33e-02
L11 N10 N11 1.90e-11
R11 N10 N11 1.67e-02
C12 N11 N12 5.98e-06
L12 N11 N12 9.74e-11
R12 N11 N12 1.57e-02
C13 N12 N13 3.55e-06
L13 N12 N13 7.24e-11
R13 N12 N13 1.45e-02
C14 N13 N14 2.68e-11
L14 N13 N14 4.31e-11
R14 N13 N14 3.91e+00
C15 N14 Port2 1.06e-12
L15 N14 Port2 3.23e-10
R15 N14 Port2 1.50e+02
.ENDS GRT31CR61H225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRT31CR6YA106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR6YA106KE01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CR6YA106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRT31CR6YA106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR6YA106ME01 Port1 Port2
C01 Port1 N01 8.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.93e-11
R03 N02 N03 3.18e-03
C04 N03 N04 4.71e-04
R04 N03 N04 1.13e+01
C05 N04 N05 4.78e-04
R05 N04 N05 1.24e+00
C06 N05 N06 4.39e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.14e-04
R07 N06 N07 1.51e-02
C08 N07 N08 4.15e-04
R08 N07 N08 1.61e-03
L09 N08 N09 5.94e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.22e-10
R10 N09 N10 1.88e-02
C11 N10 N11 2.04e-05
L11 N10 N11 1.03e-10
R11 N10 N11 5.46e-03
C12 N11 N12 2.20e-05
L12 N11 N12 4.66e-11
R12 N11 N12 4.74e-03
C13 N12 N13 3.52e-11
L13 N12 N13 5.52e-11
R13 N12 N13 4.12e+00
C14 N13 Port2 9.88e-13
L14 N13 Port2 3.71e-10
R14 N13 Port2 8.41e+01
.ENDS GRT31CR6YA106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT31CR70J226KE13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR70J226KE13 Port1 Port2
C01 Port1 N01 1.57e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 9.52e-11
R03 N02 N03 2.55e-03
C04 N03 N04 3.18e-04
R04 N03 N04 1.79e+01
C05 N04 N05 4.26e-04
R05 N04 N05 1.19e+00
C06 N05 N06 4.20e-04
R06 N05 N06 1.20e-01
C07 N06 N07 3.56e-04
R07 N06 N07 1.44e-02
C08 N07 N08 3.23e-04
R08 N07 N08 1.57e-03
L09 N08 N09 1.93e-11
R09 N08 N09 3.44e-02
L10 N09 N10 6.02e-11
R10 N09 N10 2.23e-02
L11 N10 N11 4.30e-10
R11 N10 N11 1.41e-02
C12 N11 N12 4.06e-05
L12 N11 N12 9.85e-11
R12 N11 N12 4.28e-03
C13 N12 N13 1.86e-05
L13 N12 N13 1.03e-10
R13 N12 N13 4.54e-03
C14 N13 N14 1.94e-11
L14 N13 N14 6.62e-11
R14 N13 N14 1.15e+01
C15 N14 Port2 1.29e-12
L15 N14 Port2 3.27e-10
R15 N14 Port2 9.49e+01
.ENDS GRT31CR70J226KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT31CR71E106KE13
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR71E106KE13 Port1 Port2
C01 Port1 N01 7.09e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.66e-10
R03 N02 N03 3.46e-03
C04 N03 N04 1.83e-04
R04 N03 N04 2.90e+01
C05 N04 N05 2.14e-04
R05 N04 N05 2.30e+00
C06 N05 N06 2.00e-04
R06 N05 N06 2.42e-01
C07 N06 N07 1.64e-04
R07 N06 N07 2.96e-02
C08 N07 N08 1.90e-04
R08 N07 N08 3.19e-03
L09 N08 N09 1.39e-11
R09 N08 N09 7.13e-02
L10 N09 N10 4.75e-11
R10 N09 N10 3.32e-02
L11 N10 N11 3.34e-10
R11 N10 N11 1.93e-02
C12 N11 N12 2.36e-05
L12 N11 N12 7.63e-11
R12 N11 N12 7.27e-03
C13 N12 N13 8.63e-06
L13 N12 N13 9.88e-11
R13 N12 N13 8.31e-03
C14 N13 N14 2.10e-11
L14 N13 N14 5.85e-11
R14 N13 N14 9.62e+00
C15 N14 Port2 1.69e-12
L15 N14 Port2 2.60e-10
R15 N14 Port2 1.06e+02
.ENDS GRT31CR71E106KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT31CR71H225KE13
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR71H225KE13 Port1 Port2
C01 Port1 N01 2.10e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 5.36e-11
R03 N02 N03 3.97e-03
C04 N03 N04 8.87e-05
R04 N03 N04 7.71e+01
C05 N04 N05 2.33e-04
R05 N04 N05 1.47e+00
C06 N05 N06 2.27e-04
R06 N05 N06 1.44e-01
C07 N06 N07 2.01e-04
R07 N06 N07 1.63e-02
C08 N07 N08 1.19e-04
R08 N07 N08 2.55e-03
L09 N08 N09 1.68e-11
R09 N08 N09 7.24e-02
L10 N09 N10 4.69e-11
R10 N09 N10 3.65e-02
L11 N10 N11 3.89e-10
R11 N10 N11 3.35e-02
C12 N11 N12 5.50e-06
L12 N11 N12 8.69e-11
R12 N11 N12 1.34e-02
C13 N12 N13 3.33e-06
L13 N12 N13 6.45e-11
R13 N12 N13 1.07e-02
C14 N13 N14 3.03e-11
L14 N13 N14 6.06e-11
R14 N13 N14 3.06e+00
C15 N14 Port2 1.36e-12
L15 N14 Port2 2.97e-10
R15 N14 Port2 1.36e+02
.ENDS GRT31CR71H225KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT32DC81A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DC81A106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GRT32DC81A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT32DC81C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DC81C106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GRT32DC81C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT32DC81E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DC81E106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GRT32DC81E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/3.30e+01[uF]/6.3[V]
* Murata P/N :GRT32DR60J336ME01
* Property : C = 3.30e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DR60J336ME01 Port1 Port2
C01 Port1 N01 2.45e-05
R01 Port1 N01 1.52e+06
L02 N01 N02 4.90e-11
R03 N02 N03 1.63e-03
C04 N03 N04 4.84e-04
R04 N03 N04 1.20e+01
C05 N04 N05 5.97e-04
R05 N04 N05 7.77e-01
C06 N05 N06 5.44e-04
R06 N05 N06 8.44e-02
C07 N06 N07 4.38e-04
R07 N06 N07 1.06e-02
C08 N07 N08 5.06e-04
R08 N07 N08 9.13e-04
L09 N08 N09 1.11e-11
R09 N08 N09 4.76e-02
L10 N09 N10 4.00e-11
R10 N09 N10 2.17e-02
L11 N10 N11 4.51e-10
R11 N10 N11 1.28e-02
C12 N11 N12 5.43e-05
L12 N11 N12 1.12e-10
R12 N11 N12 5.89e-03
C13 N12 N13 3.08e-05
L13 N12 N13 8.64e-11
R13 N12 N13 4.66e-03
C14 N13 N14 1.41e-11
L14 N13 N14 7.48e-11
R14 N13 N14 1.71e+01
C15 N14 Port2 2.14e-12
L15 N14 Port2 2.05e-10
R15 N14 Port2 7.73e+01
.ENDS GRT32DR60J336ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRT32DR61C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DR61C106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GRT32DR61C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT32DR61E106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DR61E106KE01 Port1 Port2
C01 Port1 N01 9.71e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.63e-11
R03 N02 N03 1.58e-03
C04 N03 N04 7.02e-04
R04 N03 N04 9.74e+00
C05 N04 N05 1.23e-03
R05 N04 N05 3.93e-01
C06 N05 N06 1.01e-03
R06 N05 N06 5.17e-02
C07 N06 N07 9.23e-04
R07 N06 N07 4.71e-03
C08 N07 N08 6.42e-04
R08 N07 N08 6.33e-04
L09 N08 N09 3.44e-11
R09 N08 N09 3.11e-02
L10 N09 N10 3.94e-10
R10 N09 N10 1.75e-02
C11 N10 N11 2.01e-05
L11 N10 N11 1.02e-10
R11 N10 N11 9.19e-03
C12 N11 N12 9.86e-06
L12 N11 N12 8.68e-11
R12 N11 N12 7.67e-03
C13 N12 N13 1.50e-11
L13 N12 N13 7.50e-11
R13 N12 N13 7.40e+00
C14 N13 Port2 2.10e-12
L14 N13 Port2 1.87e-10
R14 N13 Port2 1.40e+02
.ENDS GRT32DR61E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRT32DR61E106ME01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DR61E106ME01 Port1 Port2
C01 Port1 N01 9.71e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.63e-11
R03 N02 N03 1.58e-03
C04 N03 N04 7.02e-04
R04 N03 N04 9.74e+00
C05 N04 N05 1.23e-03
R05 N04 N05 3.93e-01
C06 N05 N06 1.01e-03
R06 N05 N06 5.17e-02
C07 N06 N07 9.23e-04
R07 N06 N07 4.71e-03
C08 N07 N08 6.42e-04
R08 N07 N08 6.33e-04
L09 N08 N09 3.44e-11
R09 N08 N09 3.11e-02
L10 N09 N10 3.94e-10
R10 N09 N10 1.75e-02
C11 N10 N11 2.01e-05
L11 N10 N11 1.02e-10
R11 N10 N11 9.19e-03
C12 N11 N12 9.86e-06
L12 N11 N12 8.68e-11
R12 N11 N12 7.67e-03
C13 N12 N13 1.50e-11
L13 N12 N13 7.50e-11
R13 N12 N13 7.40e+00
C14 N13 Port2 2.10e-12
L14 N13 Port2 1.87e-10
R14 N13 Port2 1.40e+02
.ENDS GRT32DR61E106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRT32EC80J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC80J476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GRT32EC80J476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRT32EC81A226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC81A226ME13 Port1 Port2
C01 Port1 N01 2.18e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.07e-11
R03 N02 N03 1.40e-03
C04 N03 N04 1.91e-03
R04 N03 N04 1.63e+00
C05 N04 N05 2.14e-03
R05 N04 N05 1.11e-01
C06 N05 N06 2.89e-03
R06 N05 N06 9.68e-03
C07 N06 N07 2.55e-03
R07 N06 N07 1.80e-03
L08 N07 N08 3.80e-11
R08 N07 N08 2.41e-02
L09 N08 N09 4.67e-10
R09 N08 N09 1.41e-02
C10 N09 N10 4.52e-05
L10 N09 N10 1.63e-10
R10 N09 N10 7.89e-03
C11 N10 N11 2.77e-05
L11 N10 N11 1.16e-10
R11 N10 N11 5.99e-03
C12 N11 N12 8.11e-12
L12 N11 N12 1.05e-10
R12 N11 N12 6.83e+00
C13 N12 Port2 2.03e-12
L13 N12 Port2 1.89e-10
R13 N12 Port2 9.66e+01
.ENDS GRT32EC81A226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRT32EC81A476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC81A476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GRT32EC81A476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+01[uF]/16[V]
* Murata P/N :GRT32EC81C476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC81C476KE13 Port1 Port2
C01 Port1 N01 4.01e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 6.33e-11
R03 N02 N03 1.13e-03
C04 N03 N04 1.55e-03
R04 N03 N04 3.20e+00
C05 N04 N05 1.73e-03
R05 N04 N05 3.03e-01
C06 N05 N06 1.60e-03
R06 N05 N06 3.49e-02
C07 N06 N07 1.63e-03
R07 N06 N07 3.19e-03
C08 N07 N08 3.24e-03
R08 N07 N08 1.44e-04
L09 N08 N09 6.32e-12
R09 N08 N09 1.87e-02
L10 N09 N10 4.57e-11
R10 N09 N10 1.50e-02
L11 N10 N11 5.36e-10
R11 N10 N11 1.05e-02
C12 N11 N12 6.25e-05
L12 N11 N12 2.04e-10
R12 N11 N12 5.19e-03
C13 N12 N13 8.60e-05
L13 N12 N13 6.86e-11
R13 N12 N13 3.61e-03
C14 N13 N14 2.85e-11
L14 N13 N14 6.23e-11
R14 N13 N14 5.35e+00
C15 N14 Port2 1.93e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 6.68e+01
.ENDS GRT32EC81C476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRT32EC81H475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC81H475KE01 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.31e-10
R03 N02 N03 2.13e-03
C04 N03 N04 5.56e-04
R04 N03 N04 9.93e+00
C05 N04 N05 6.32e-04
R05 N04 N05 8.47e-01
C06 N05 N06 5.88e-04
R06 N05 N06 1.23e-01
C07 N06 N07 6.50e-04
R07 N06 N07 1.46e-02
C08 N07 N08 4.72e-04
R08 N07 N08 2.84e-03
L09 N08 N09 2.55e-11
R09 N08 N09 4.00e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.49e-02
C11 N10 N11 7.67e-06
L11 N10 N11 1.48e-10
R11 N10 N11 2.30e-02
C12 N11 N12 5.89e-06
L12 N11 N12 7.78e-11
R12 N11 N12 1.35e-02
C13 N12 N13 9.62e-12
L13 N12 N13 7.00e-11
R13 N12 N13 7.94e+00
C14 N13 Port2 3.74e-12
L14 N13 Port2 9.96e-11
R14 N13 Port2 8.51e+01
.ENDS GRT32EC81H475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/1.00e+02[uF]/6.3[V]
* Murata P/N :GRT32ER60J107ME13
* Property : C = 1.00e+02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER60J107ME13 Port1 Port2
C01 Port1 N01 6.90e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 5.35e-11
R03 N02 N03 1.07e-03
C04 N03 N04 3.34e-03
R04 N03 N04 1.59e+00
C05 N04 N05 3.50e-03
R05 N04 N05 1.66e-01
C06 N05 N06 3.76e-03
R06 N05 N06 1.81e-02
C07 N06 N07 6.55e-03
R07 N06 N07 9.31e-04
C08 N07 N08 6.45e-03
R08 N07 N08 1.28e-04
L09 N08 N09 8.78e-12
R09 N08 N09 1.75e-02
L10 N09 N10 7.41e-11
R10 N09 N10 1.71e-02
L11 N10 N11 5.84e-10
R11 N10 N11 7.34e-03
C12 N11 N12 1.60e-04
L12 N11 N12 1.51e-10
R12 N11 N12 2.89e-03
C13 N12 N13 1.44e-04
L13 N12 N13 8.06e-11
R13 N12 N13 2.11e-03
C14 N13 N14 4.29e-11
L14 N13 N14 6.25e-11
R14 N13 N14 2.65e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 2.37e-10
R15 N14 Port2 8.26e+01
.ENDS GRT32ER60J107ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRT32ER61C226ME13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER61C226ME13 Port1 Port2
C01 Port1 N01 2.18e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.07e-11
R03 N02 N03 1.40e-03
C04 N03 N04 1.91e-03
R04 N03 N04 1.63e+00
C05 N04 N05 2.14e-03
R05 N04 N05 1.11e-01
C06 N05 N06 2.89e-03
R06 N05 N06 9.68e-03
C07 N06 N07 2.55e-03
R07 N06 N07 1.80e-03
L08 N07 N08 3.80e-11
R08 N07 N08 2.41e-02
L09 N08 N09 4.67e-10
R09 N08 N09 1.41e-02
C10 N09 N10 4.52e-05
L10 N09 N10 1.63e-10
R10 N09 N10 7.89e-03
C11 N10 N11 2.77e-05
L11 N10 N11 1.16e-10
R11 N10 N11 5.99e-03
C12 N11 N12 8.11e-12
L12 N11 N12 1.05e-10
R12 N11 N12 6.83e+00
C13 N12 Port2 2.03e-12
L13 N12 Port2 1.89e-10
R13 N12 Port2 9.66e+01
.ENDS GRT32ER61C226ME13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRT32ER61E226KE13
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER61E226KE13 Port1 Port2
C01 Port1 N01 1.71e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.03e-10
R03 N02 N03 2.44e-03
C04 N03 N04 6.44e-04
R04 N03 N04 1.53e+01
C05 N04 N05 1.43e-03
R05 N04 N05 2.15e+00
C06 N05 N06 7.84e-04
R06 N05 N06 1.06e+00
C07 N06 N07 4.88e-04
R07 N06 N07 2.26e-01
C08 N07 N08 5.04e-04
R08 N07 N08 2.73e-02
C09 N08 N09 3.78e-04
R09 N08 N09 5.28e-03
L10 N09 N10 4.43e-11
R10 N09 N10 2.46e-02
L11 N10 N11 4.91e-10
R11 N10 N11 1.60e-02
C12 N11 N12 3.68e-05
L12 N11 N12 1.27e-10
R12 N11 N12 8.28e-03
C13 N12 N13 2.21e-05
L13 N12 N13 9.59e-11
R13 N12 N13 6.93e-03
C14 N13 N14 2.20e-11
L14 N13 N14 8.30e-11
R14 N13 N14 8.55e+00
C15 N14 Port2 2.03e-12
L15 N14 Port2 2.34e-10
R15 N14 Port2 6.73e+01
.ENDS GRT32ER61E226KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRT32ER61H475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER61H475KE01 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.31e-10
R03 N02 N03 2.13e-03
C04 N03 N04 5.56e-04
R04 N03 N04 9.93e+00
C05 N04 N05 6.32e-04
R05 N04 N05 8.47e-01
C06 N05 N06 5.88e-04
R06 N05 N06 1.23e-01
C07 N06 N07 6.50e-04
R07 N06 N07 1.46e-02
C08 N07 N08 4.72e-04
R08 N07 N08 2.84e-03
L09 N08 N09 2.55e-11
R09 N08 N09 4.00e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.49e-02
C11 N10 N11 7.67e-06
L11 N10 N11 1.48e-10
R11 N10 N11 2.30e-02
C12 N11 N12 5.89e-06
L12 N11 N12 7.78e-11
R12 N11 N12 1.35e-02
C13 N12 N13 9.62e-12
L13 N12 N13 7.00e-11
R13 N12 N13 7.94e+00
C14 N13 Port2 3.74e-12
L14 N13 Port2 9.96e-11
R14 N13 Port2 8.51e+01
.ENDS GRT32ER61H475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRT32ER70J476KE13
* Property : C = 4.70e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER70J476KE13 Port1 Port2
C01 Port1 N01 3.28e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.86e-10
R03 N02 N03 1.49e-03
C04 N03 N04 7.17e-04
R04 N03 N04 7.57e+00
C05 N04 N05 1.00e-03
R05 N04 N05 3.80e-01
C06 N05 N06 9.35e-04
R06 N05 N06 4.04e-02
C07 N06 N07 7.45e-04
R07 N06 N07 4.99e-03
C08 N07 N08 2.56e-03
R08 N07 N08 1.78e-04
L09 N08 N09 1.28e-11
R09 N08 N09 6.18e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.00e-02
L11 N10 N11 4.74e-10
R11 N10 N11 1.08e-02
C12 N11 N12 7.29e-05
L12 N11 N12 1.35e-10
R12 N11 N12 4.95e-03
C13 N12 N13 5.25e-05
L13 N12 N13 8.77e-11
R13 N12 N13 4.13e-03
C14 N13 Port2 2.33e-12
L14 N13 Port2 2.88e-10
R14 N13 Port2 4.47e+01
.ENDS GRT32ER70J476KE13
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRT32ER71H475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER71H475KE01 Port1 Port2
C01 Port1 N01 4.63e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.52e-11
R03 N02 N03 1.99e-03
C04 N03 N04 2.97e-04
R04 N03 N04 1.75e+01
C05 N04 N05 5.77e-04
R05 N04 N05 5.32e-01
C06 N05 N06 5.38e-04
R06 N05 N06 5.61e-02
C07 N06 N07 4.67e-04
R07 N06 N07 6.02e-03
C08 N07 N08 4.51e-04
R08 N07 N08 6.06e-04
L09 N08 N09 2.46e-11
R09 N08 N09 2.97e-02
L10 N09 N10 3.58e-10
R10 N09 N10 2.52e-02
C11 N10 N11 7.37e-06
L11 N10 N11 1.58e-10
R11 N10 N11 2.15e-02
C12 N11 N12 6.24e-06
L12 N11 N12 7.52e-11
R12 N11 N12 1.22e-02
C13 N12 Port2 1.24e-12
L13 N12 Port2 2.93e-10
R13 N12 Port2 7.90e+01
.ENDS GRT32ER71H475KE01
