*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N2B02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N2B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 2.45e-10
R2 1 port2 1.70e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 9.00
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N2C02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N2C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 2.45e-10
R2 1 port2 1.70e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 9.00
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N3B02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N3B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 3.63e-10
R2 1 port2 2.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N3C02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N3C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 3.63e-10
R2 1 port2 2.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N4B02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N4B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 4.80e-10
R2 1 port2 6.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N4C02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N4C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 4.80e-10
R2 1 port2 6.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N5B02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N5B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 5.90e-10
R2 1 port2 6.00e-2
R3 port1 port2 1.20e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 4.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N5C02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N5C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 5.90e-10
R2 1 port2 6.00e-2
R3 port1 port2 1.20e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 4.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N6B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 6.90e-10
R2 1 port2 8.00e-2
R3 port1 port2 1.30e+3
L4 port1 2 3.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 5.50e-9
R6 4 port2 19.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N6C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 6.90e-10
R2 1 port2 8.00e-2
R3 port1 port2 1.30e+3
L4 port1 2 3.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 5.50e-9
R6 4 port2 19.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N7B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 8.00e-10
R2 1 port2 1.07e-1
R3 port1 port2 1.40e+3
L4 port1 2 1.20e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 6.90e-9
R6 4 port2 20.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N7C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 8.00e-10
R2 1 port2 1.07e-1
R3 port1 port2 1.40e+3
L4 port1 2 1.20e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 6.90e-9
R6 4 port2 20.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N8B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 9.28e-10
R2 1 port2 9.50e-2
R3 port1 port2 1.40e+3
L4 port1 2 8.00e-8
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 17.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N8C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 9.28e-10
R2 1 port2 9.50e-2
R3 port1 port2 1.40e+3
L4 port1 2 8.00e-8
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 17.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N9B02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.05e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.40e+3
L4 port1 2 1.20e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 15.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN0N9C02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.05e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.40e+3
L4 port1 2 1.20e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 15.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN10NH02 port1 port2
C1 port1 port2 9.30e-14
L2 port1 1 1.17e-8
R2 1 port2 1.50
R3 port1 port2 9.00e+3
L4 port1 2 1.40e-7
R4 2 port2 800
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 115
L7 port1 5 3.00e-7
R7 5 port2 120
.ENDS LQP02TN10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN10NJ02 port1 port2
C1 port1 port2 9.30e-14
L2 port1 1 1.17e-8
R2 1 port2 1.50
R3 port1 port2 9.00e+3
L4 port1 2 1.40e-7
R4 2 port2 800
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 115
L7 port1 5 3.00e-7
R7 5 port2 120
.ENDS LQP02TN10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN11NH02 port1 port2
C1 port1 port2 1.25e-13
L2 port1 1 1.30e-8
R2 1 port2 1.15
R3 port1 port2 8.50e+3
L4 port1 2 1.60e-7
R4 2 port2 800
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 120
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN11NJ02 port1 port2
C1 port1 port2 1.25e-13
L2 port1 1 1.30e-8
R2 1 port2 1.15
R3 port1 port2 8.50e+3
L4 port1 2 1.60e-7
R4 2 port2 800
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 120
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN12NH02 port1 port2
C1 port1 port2 1.29e-13
L2 port1 1 1.43e-8
R2 1 port2 1.69
R3 port1 port2 8.50e+3
L4 port1 2 1.80e-7
R4 2 port2 850
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 90.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN12NJ02 port1 port2
C1 port1 port2 1.29e-13
L2 port1 1 1.43e-8
R2 1 port2 1.69
R3 port1 port2 8.50e+3
L4 port1 2 1.80e-7
R4 2 port2 850
L5 port1 3 3.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 90.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN13NH02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.57e-8
R2 1 port2 1.53
R3 port1 port2 9.00e+3
L4 port1 2 1.85e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN13NJ02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.57e-8
R2 1 port2 1.53
R3 port1 port2 9.00e+3
L4 port1 2 1.85e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN15NH02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 1.84e-8
R2 1 port2 1.95
R3 port1 port2 9.00e+3
L4 port1 2 2.10e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN15NJ02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 1.84e-8
R2 1 port2 1.95
R3 port1 port2 9.00e+3
L4 port1 2 2.10e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN16NH02 port1 port2
C1 port1 port2 1.33e-13
L2 port1 1 2.00e-8
R2 1 port2 1.85
R3 port1 port2 9.00e+3
L4 port1 2 2.00e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN16NJ02 port1 port2
C1 port1 port2 1.33e-13
L2 port1 1 2.00e-8
R2 1 port2 1.85
R3 port1 port2 9.00e+3
L4 port1 2 2.00e-7
R4 2 port2 850
L5 port1 3 5.00e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 50.0
L7 port1 5 3.00e-7
R7 5 port2 100
.ENDS LQP02TN16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN18NH02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.31e-8
R2 1 port2 2.40
R3 port1 port2 9.70e+3
L4 port1 2 2.00e-7
R4 2 port2 850
L5 port1 3 4.30e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 48.0
L7 port1 5 3.00e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 9.36e-15
R8 7 port2 75.6
.ENDS LQP02TN18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN18NJ02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.31e-8
R2 1 port2 2.40
R3 port1 port2 9.70e+3
L4 port1 2 2.00e-7
R4 2 port2 850
L5 port1 3 4.30e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 48.0
L7 port1 5 3.00e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 9.36e-15
R8 7 port2 75.6
.ENDS LQP02TN18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N0B02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 1.19e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.45e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N0C02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 1.19e-9
R2 1 port2 1.05e-1
R3 port1 port2 1.45e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 8.00e-9
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N1B02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 1.30e-9
R2 1 port2 1.35e-1
R3 port1 port2 1.60e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 9.50e-9
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N1C02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 1.30e-9
R2 1 port2 1.35e-1
R3 port1 port2 1.60e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 9.50e-9
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N2B02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.40e-9
R2 1 port2 1.75e-1
R3 port1 port2 1.60e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.15e-8
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N2C02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.40e-9
R2 1 port2 1.75e-1
R3 port1 port2 1.60e+3
L4 port1 2 2.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.15e-8
R6 4 port2 14.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N3B02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.50e-9
R2 1 port2 1.85e-1
R3 port1 port2 1.90e+3
L4 port1 2 1.20e-6
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.40e-8
R6 4 port2 18.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N3C02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.50e-9
R2 1 port2 1.85e-1
R3 port1 port2 1.90e+3
L4 port1 2 1.20e-6
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.40e-8
R6 4 port2 18.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N4B02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.61e-9
R2 1 port2 2.05e-1
R3 port1 port2 2.20e+3
L4 port1 2 1.20e-6
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.50e-8
R6 4 port2 16.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N4C02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 1.61e-9
R2 1 port2 2.05e-1
R3 port1 port2 2.20e+3
L4 port1 2 1.20e-6
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 1.50e-8
R6 4 port2 16.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N5B02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 1.71e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.80e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.70e-8
R6 4 port2 30.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N5C02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 1.71e-9
R2 1 port2 1.70e-1
R3 port1 port2 1.80e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.70e-8
R6 4 port2 30.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TN1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N6B02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.85e-9
R2 1 port2 1.94e-1
R3 port1 port2 2.25e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.80e-8
R6 4 port2 21.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N6C02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.85e-9
R2 1 port2 1.94e-1
R3 port1 port2 2.25e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.80e-8
R6 4 port2 21.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N7B02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 2.30e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.80e-8
R6 4 port2 22.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N7C02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 1.97e-9
R2 1 port2 1.80e-1
R3 port1 port2 2.30e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 1.80e-8
R6 4 port2 22.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N8B02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 2.08e-9
R2 1 port2 1.90e-1
R3 port1 port2 2.40e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 2.00e-8
R6 4 port2 22.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N8C02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 2.08e-9
R2 1 port2 1.90e-1
R3 port1 port2 2.40e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 2.00e-8
R6 4 port2 22.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N9B02 port1 port2
C1 port1 port2 9.16e-14
L2 port1 1 2.17e-9
R2 1 port2 2.20e-1
R3 port1 port2 3.00e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 2.50e-8
R6 4 port2 25.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN1N9C02 port1 port2
C1 port1 port2 9.16e-14
L2 port1 1 2.17e-9
R2 1 port2 2.20e-1
R3 port1 port2 3.00e+3
L4 port1 2 1.50e-6
R4 2 port2 800
L5 port1 3 3.70e-8
R5 3 port2 220
L6 port1 4 2.50e-8
R6 4 port2 25.0
L7 port1 5 1.20e-7
R7 5 port2 400
.ENDS LQP02TN1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN20NH02 port1 port2
C1 port1 port2 1.30e-13
L2 port1 1 2.68e-8
R2 1 port2 2.25
R3 port1 port2 7.50e+3
L4 port1 2 1.70e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 1.15e-14
R8 7 port2 90.0
.ENDS LQP02TN20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN20NJ02 port1 port2
C1 port1 port2 1.30e-13
L2 port1 1 2.68e-8
R2 1 port2 2.25
R3 port1 port2 7.50e+3
L4 port1 2 1.70e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 1.15e-14
R8 7 port2 90.0
.ENDS LQP02TN20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN22NH02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 3.05e-8
R2 1 port2 2.83
R3 port1 port2 7.50e+3
L4 port1 2 1.70e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 95.0
L8 port1 6 1.20e-8
C8 6 7 1.16e-14
R8 7 port2 95.0
.ENDS LQP02TN22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN22NJ02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 3.05e-8
R2 1 port2 2.83
R3 port1 port2 7.50e+3
L4 port1 2 1.70e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 95.0
L8 port1 6 1.20e-8
C8 6 7 1.16e-14
R8 7 port2 95.0
.ENDS LQP02TN22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN24NH02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN24NH02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 3.36e-8
R2 1 port2 2.90
R3 port1 port2 7.30e+3
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 4.80e-7
R5 3 port2 450
L6 port1 4 2.25e-7
R6 4 port2 40.0
L7 port1 5 3.10e-7
R7 5 port2 30.0
L8 port1 6 1.20e-8
C8 6 7 1.30e-14
R8 7 port2 90.0
.ENDS LQP02TN24NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN24NJ02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN24NJ02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 3.36e-8
R2 1 port2 2.90
R3 port1 port2 7.30e+3
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 4.80e-7
R5 3 port2 450
L6 port1 4 2.25e-7
R6 4 port2 40.0
L7 port1 5 3.10e-7
R7 5 port2 30.0
L8 port1 6 1.20e-8
C8 6 7 1.30e-14
R8 7 port2 90.0
.ENDS LQP02TN24NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN27NH02 port1 port2
C1 port1 port2 1.32e-13
L2 port1 1 3.98e-8
R2 1 port2 3.43
R3 port1 port2 7.00e+3
L4 port1 2 2.20e-7
R4 2 port2 600
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 70.0
L8 port1 6 1.20e-8
C8 6 7 1.55e-14
R8 7 port2 90.0
.ENDS LQP02TN27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN27NJ02 port1 port2
C1 port1 port2 1.32e-13
L2 port1 1 3.98e-8
R2 1 port2 3.43
R3 port1 port2 7.00e+3
L4 port1 2 2.20e-7
R4 2 port2 600
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 40.0
L7 port1 5 3.00e-7
R7 5 port2 70.0
L8 port1 6 1.20e-8
C8 6 7 1.55e-14
R8 7 port2 90.0
.ENDS LQP02TN27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N0B02 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.36e-9
R2 1 port2 2.63e-1
R3 port1 port2 2.65e+3
L4 port1 2 7.50e-7
R4 2 port2 1.25e+3
L5 port1 3 3.80e-8
R5 3 port2 220
L6 port1 4 2.00e-8
R6 4 port2 12.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N0C02 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.36e-9
R2 1 port2 2.63e-1
R3 port1 port2 2.65e+3
L4 port1 2 7.50e-7
R4 2 port2 1.25e+3
L5 port1 3 3.80e-8
R5 3 port2 220
L6 port1 4 2.00e-8
R6 4 port2 12.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N1B02 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.48e-9
R2 1 port2 2.83e-1
R3 port1 port2 2.85e+3
L4 port1 2 4.00e-7
R4 2 port2 1.25e+3
L5 port1 3 3.80e-8
R5 3 port2 220
L6 port1 4 2.10e-8
R6 4 port2 12.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N1C02 port1 port2
C1 port1 port2 1.03e-13
L2 port1 1 2.48e-9
R2 1 port2 2.83e-1
R3 port1 port2 2.85e+3
L4 port1 2 4.00e-7
R4 2 port2 1.25e+3
L5 port1 3 3.80e-8
R5 3 port2 220
L6 port1 4 2.10e-8
R6 4 port2 12.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N2B02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 2.59e-9
R2 1 port2 1.80e-1
R3 port1 port2 2.55e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.50e-8
R5 3 port2 220
L6 port1 4 2.20e-8
R6 4 port2 20.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N2C02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 2.59e-9
R2 1 port2 1.80e-1
R3 port1 port2 2.55e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.50e-8
R5 3 port2 220
L6 port1 4 2.20e-8
R6 4 port2 20.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N3B02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.73e-9
R2 1 port2 2.30e-1
R3 port1 port2 2.55e+3
L4 port1 2 2.30e-7
R4 2 port2 1.25e+3
L5 port1 3 4.50e-8
R5 3 port2 220
L6 port1 4 2.20e-8
R6 4 port2 20.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N3C02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.73e-9
R2 1 port2 2.30e-1
R3 port1 port2 2.55e+3
L4 port1 2 2.30e-7
R4 2 port2 1.25e+3
L5 port1 3 4.50e-8
R5 3 port2 220
L6 port1 4 2.20e-8
R6 4 port2 20.0
L7 port1 5 1.50e-7
R7 5 port2 350
.ENDS LQP02TN2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N4B02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.77e-9
R2 1 port2 2.20e-1
R3 port1 port2 2.60e+3
L4 port1 2 4.50e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 28.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N4C02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.77e-9
R2 1 port2 2.20e-1
R3 port1 port2 2.60e+3
L4 port1 2 4.50e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 28.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N5B02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 2.90e-9
R2 1 port2 2.50e-1
R3 port1 port2 2.60e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 26.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N5C02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 2.90e-9
R2 1 port2 2.50e-1
R3 port1 port2 2.60e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 26.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N6B02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.03e-9
R2 1 port2 2.95e-1
R3 port1 port2 2.85e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 23.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N6C02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.03e-9
R2 1 port2 2.95e-1
R3 port1 port2 2.85e+3
L4 port1 2 2.80e-7
R4 2 port2 1.25e+3
L5 port1 3 4.60e-8
R5 3 port2 220
L6 port1 4 3.00e-8
R6 4 port2 23.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N7B02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 3.07e-9
R2 1 port2 3.05e-1
R3 port1 port2 3.10e+3
L4 port1 2 2.20e-7
R4 2 port2 1.25e+3
L5 port1 3 5.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 35.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N7C02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 3.07e-9
R2 1 port2 3.05e-1
R3 port1 port2 3.10e+3
L4 port1 2 2.20e-7
R4 2 port2 1.25e+3
L5 port1 3 5.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 35.0
L7 port1 5 1.90e-7
R7 5 port2 350
.ENDS LQP02TN2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N8B02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 3.21e-9
R2 1 port2 4.95e-1
R3 port1 port2 3.50e+3
L4 port1 2 1.20e-7
R4 2 port2 950
L5 port1 3 5.00e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 35.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N8C02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 3.21e-9
R2 1 port2 4.95e-1
R3 port1 port2 3.50e+3
L4 port1 2 1.20e-7
R4 2 port2 950
L5 port1 3 5.00e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 35.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N9B02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 3.34e-9
R2 1 port2 5.00e-1
R3 port1 port2 3.70e+3
L4 port1 2 1.10e-7
R4 2 port2 950
L5 port1 3 5.60e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 25.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN2N9C02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 3.34e-9
R2 1 port2 5.00e-1
R3 port1 port2 3.70e+3
L4 port1 2 1.10e-7
R4 2 port2 950
L5 port1 3 5.60e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 25.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN30NH02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN30NH02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 4.58e-8
R2 1 port2 3.50
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.25e-7
R6 4 port2 30.0
L7 port1 5 3.00e-7
R7 5 port2 58.0
L8 port1 6 1.20e-8
C8 6 7 1.55e-14
R8 7 port2 90.0
.ENDS LQP02TN30NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN30NJ02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN30NJ02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 4.58e-8
R2 1 port2 3.50
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 550
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.25e-7
R6 4 port2 30.0
L7 port1 5 3.00e-7
R7 5 port2 58.0
L8 port1 6 1.20e-8
C8 6 7 1.55e-14
R8 7 port2 90.0
.ENDS LQP02TN30NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN33NH02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 5.05e-8
R2 1 port2 4.35
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 39.0
L7 port1 5 3.00e-7
R7 5 port2 70.0
L8 port1 6 1.20e-8
C8 6 7 2.00e-14
R8 7 port2 180
.ENDS LQP02TN33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN33NJ02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 5.05e-8
R2 1 port2 4.35
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 39.0
L7 port1 5 3.00e-7
R7 5 port2 70.0
L8 port1 6 1.20e-8
C8 6 7 2.00e-14
R8 7 port2 180
.ENDS LQP02TN33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN36NH02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN36NH02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 5.59e-8
R2 1 port2 4.70
R3 port1 port2 7.30e+3
L4 port1 2 2.90e-7
R4 2 port2 900
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.40e-7
R6 4 port2 33.0
L7 port1 5 3.20e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 2.00e-14
R8 7 port2 180
.ENDS LQP02TN36NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN36NJ02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN36NJ02 port1 port2
C1 port1 port2 1.20e-13
L2 port1 1 5.59e-8
R2 1 port2 4.70
R3 port1 port2 7.30e+3
L4 port1 2 2.90e-7
R4 2 port2 900
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.40e-7
R6 4 port2 33.0
L7 port1 5 3.20e-7
R7 5 port2 80.0
L8 port1 6 1.20e-8
C8 6 7 2.00e-14
R8 7 port2 180
.ENDS LQP02TN36NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN39NH02 port1 port2
C1 port1 port2 1.38e-13
L2 port1 1 6.50e-8
R2 1 port2 5.38
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 23.0
L7 port1 5 3.00e-7
R7 5 port2 85.0
L8 port1 6 2.00e-8
C8 6 7 1.40e-14
R8 7 port2 200
.ENDS LQP02TN39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN39NJ02 port1 port2
C1 port1 port2 1.38e-13
L2 port1 1 6.50e-8
R2 1 port2 5.38
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.80e-7
R5 3 port2 550
L6 port1 4 2.30e-7
R6 4 port2 23.0
L7 port1 5 3.00e-7
R7 5 port2 85.0
L8 port1 6 2.00e-8
C8 6 7 1.40e-14
R8 7 port2 200
.ENDS LQP02TN39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N0B02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 3.47e-9
R2 1 port2 5.80e-1
R3 port1 port2 3.70e+3
L4 port1 2 1.03e-7
R4 2 port2 950
L5 port1 3 6.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 21.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N0C02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 3.47e-9
R2 1 port2 5.80e-1
R3 port1 port2 3.70e+3
L4 port1 2 1.03e-7
R4 2 port2 950
L5 port1 3 6.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 21.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N1B02 port1 port2
C1 port1 port2 5.76e-14
L2 port1 1 3.60e-9
R2 1 port2 6.20e-1
R3 port1 port2 3.90e+3
L4 port1 2 1.05e-7
R4 2 port2 950
L5 port1 3 7.00e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 17.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N1C02 port1 port2
C1 port1 port2 5.76e-14
L2 port1 1 3.60e-9
R2 1 port2 6.20e-1
R3 port1 port2 3.90e+3
L4 port1 2 1.05e-7
R4 2 port2 950
L5 port1 3 7.00e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 17.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N2B02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 3.70e-9
R2 1 port2 3.98e-1
R3 port1 port2 4.00e+3
L4 port1 2 9.70e-8
R4 2 port2 950
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 45.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N2C02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 3.70e-9
R2 1 port2 3.98e-1
R3 port1 port2 4.00e+3
L4 port1 2 9.70e-8
R4 2 port2 950
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 4.20e-8
R6 4 port2 45.0
L7 port1 5 2.00e-7
R7 5 port2 350
.ENDS LQP02TN3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N3B02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.79e-9
R2 1 port2 3.88e-1
R3 port1 port2 4.50e+3
L4 port1 2 9.50e-8
R4 2 port2 950
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 4.50e-8
R6 4 port2 45.0
L7 port1 5 2.60e-7
R7 5 port2 350
.ENDS LQP02TN3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N3C02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.79e-9
R2 1 port2 3.88e-1
R3 port1 port2 4.50e+3
L4 port1 2 9.50e-8
R4 2 port2 950
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 4.50e-8
R6 4 port2 45.0
L7 port1 5 2.60e-7
R7 5 port2 350
.ENDS LQP02TN3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N4B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 3.90e-9
R2 1 port2 4.65e-1
R3 port1 port2 4.30e+3
L4 port1 2 9.50e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 5.00e-8
R6 4 port2 60.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N4C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 3.90e-9
R2 1 port2 4.65e-1
R3 port1 port2 4.30e+3
L4 port1 2 9.50e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 5.00e-8
R6 4 port2 60.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N5B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 3.99e-9
R2 1 port2 4.55e-1
R3 port1 port2 4.80e+3
L4 port1 2 8.70e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 6.00e-8
R6 4 port2 68.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N5C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 3.99e-9
R2 1 port2 4.55e-1
R3 port1 port2 4.80e+3
L4 port1 2 8.70e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 6.00e-8
R6 4 port2 68.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N6B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.12e-9
R2 1 port2 4.70e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.00e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 6.00e-8
R6 4 port2 60.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N6C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.12e-9
R2 1 port2 4.70e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.00e-8
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 220
L6 port1 4 6.00e-8
R6 4 port2 60.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N7B02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 4.20e-9
R2 1 port2 5.20e-1
R3 port1 port2 5.20e+3
L4 port1 2 8.50e-8
R4 2 port2 800
L5 port1 3 9.00e-8
R5 3 port2 220
L6 port1 4 6.70e-8
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N7C02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 4.20e-9
R2 1 port2 5.20e-1
R3 port1 port2 5.20e+3
L4 port1 2 8.50e-8
R4 2 port2 800
L5 port1 3 9.00e-8
R5 3 port2 220
L6 port1 4 6.70e-8
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N8B02 port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 4.26e-9
R2 1 port2 5.35e-1
R3 port1 port2 4.70e+3
L4 port1 2 9.80e-8
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 1.00e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N8C02 port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 4.26e-9
R2 1 port2 5.35e-1
R3 port1 port2 4.70e+3
L4 port1 2 9.80e-8
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 1.00e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N9B02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.38e-9
R2 1 port2 5.50e-1
R3 port1 port2 4.70e+3
L4 port1 2 9.80e-8
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 1.00e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN3N9C02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.38e-9
R2 1 port2 5.50e-1
R3 port1 port2 4.70e+3
L4 port1 2 9.80e-8
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 1.00e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N0B02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 4.50e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.20e+3
L4 port1 2 1.00e-7
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 250
L6 port1 4 1.00e-7
R6 4 port2 120
L7 port1 5 2.00e-7
R7 5 port2 120
.ENDS LQP02TN4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N0C02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 4.50e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.20e+3
L4 port1 2 1.00e-7
R4 2 port2 800
L5 port1 3 7.50e-8
R5 3 port2 250
L6 port1 4 1.00e-7
R6 4 port2 120
L7 port1 5 2.00e-7
R7 5 port2 120
.ENDS LQP02TN4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N1B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.58e-9
R2 1 port2 6.15e-1
R3 port1 port2 4.90e+3
L4 port1 2 1.00e-7
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 250
L6 port1 4 1.30e-7
R6 4 port2 120
L7 port1 5 2.00e-7
R7 5 port2 120
.ENDS LQP02TN4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N1C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.58e-9
R2 1 port2 6.15e-1
R3 port1 port2 4.90e+3
L4 port1 2 1.00e-7
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 250
L6 port1 4 1.30e-7
R6 4 port2 120
L7 port1 5 2.00e-7
R7 5 port2 120
.ENDS LQP02TN4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N2B02 port1 port2
C1 port1 port2 8.30e-14
L2 port1 1 4.83e-9
R2 1 port2 4.40e-1
R3 port1 port2 4.40e+3
L4 port1 2 8.50e-8
R4 2 port2 500
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 8.00e-8
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N2C02 port1 port2
C1 port1 port2 8.30e-14
L2 port1 1 4.83e-9
R2 1 port2 4.40e-1
R3 port1 port2 4.40e+3
L4 port1 2 8.50e-8
R4 2 port2 500
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 8.00e-8
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N3H02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 4.93e-9
R2 1 port2 5.00e-1
R3 port1 port2 4.70e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 8.00e-8
R6 4 port2 75.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N3J02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 4.93e-9
R2 1 port2 5.00e-1
R3 port1 port2 4.70e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 8.00e-8
R5 3 port2 220
L6 port1 4 8.00e-8
R6 4 port2 75.0
L7 port1 5 2.50e-7
R7 5 port2 180
.ENDS LQP02TN4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N7H02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 5.36e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 9.00e-8
R5 3 port2 220
L6 port1 4 1.10e-7
R6 4 port2 110
L7 port1 5 2.50e-7
R7 5 port2 120
.ENDS LQP02TN4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN4N7J02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 5.36e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 9.00e-8
R5 3 port2 220
L6 port1 4 1.10e-7
R6 4 port2 110
L7 port1 5 2.50e-7
R7 5 port2 120
.ENDS LQP02TN4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN5N1H02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 5.81e-9
R2 1 port2 7.50e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.00e-7
R5 3 port2 220
L6 port1 4 1.30e-7
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 130
.ENDS LQP02TN5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN5N1J02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 5.81e-9
R2 1 port2 7.50e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.00e-7
R5 3 port2 220
L6 port1 4 1.30e-7
R6 4 port2 80.0
L7 port1 5 2.50e-7
R7 5 port2 130
.ENDS LQP02TN5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN5N6H02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 6.45e-9
R2 1 port2 6.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.00e-7
R5 3 port2 220
L6 port1 4 1.30e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 130
.ENDS LQP02TN5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN5N6J02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 6.45e-9
R2 1 port2 6.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.00e-7
R5 3 port2 220
L6 port1 4 1.30e-7
R6 4 port2 100
L7 port1 5 2.50e-7
R7 5 port2 130
.ENDS LQP02TN5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN6N2H02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 7.05e-9
R2 1 port2 8.20e-1
R3 port1 port2 8.40e+3
L4 port1 2 1.08e-7
R4 2 port2 800
L5 port1 3 1.20e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 140
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN6N2J02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 7.05e-9
R2 1 port2 8.20e-1
R3 port1 port2 8.40e+3
L4 port1 2 1.08e-7
R4 2 port2 800
L5 port1 3 1.20e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 140
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN6N8H02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 7.74e-9
R2 1 port2 1.18
R3 port1 port2 8.80e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.60e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 140
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN6N8J02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 7.74e-9
R2 1 port2 1.18
R3 port1 port2 8.80e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.60e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 140
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN7N5H02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 8.61e-9
R2 1 port2 1.16
R3 port1 port2 8.80e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.70e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN7N5J02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 8.61e-9
R2 1 port2 1.16
R3 port1 port2 8.80e+3
L4 port1 2 1.10e-7
R4 2 port2 800
L5 port1 3 1.70e-7
R5 3 port2 220
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN8N2H02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 9.34e-9
R2 1 port2 1.16
R3 port1 port2 9.00e+3
L4 port1 2 1.25e-7
R4 2 port2 800
L5 port1 3 2.80e-7
R5 3 port2 350
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN8N2J02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 9.34e-9
R2 1 port2 1.16
R3 port1 port2 9.00e+3
L4 port1 2 1.25e-7
R4 2 port2 800
L5 port1 3 2.80e-7
R5 3 port2 350
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 130
.ENDS LQP02TN8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN9N1H02 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 1.05e-8
R2 1 port2 1.16
R3 port1 port2 9.00e+3
L4 port1 2 1.34e-7
R4 2 port2 800
L5 port1 3 2.50e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 120
.ENDS LQP02TN9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TN9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TN9N1J02 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 1.05e-8
R2 1 port2 1.16
R3 port1 port2 9.00e+3
L4 port1 2 1.34e-7
R4 2 port2 800
L5 port1 3 2.50e-7
R5 3 port2 400
L6 port1 4 2.00e-7
R6 4 port2 150
L7 port1 5 3.00e-7
R7 5 port2 120
.ENDS LQP02TN9N1J02
*----------------------------------------------------------------------
