*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GXM1552C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GXM1552C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXM1552C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GXM1552C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GXM1552C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GXM1552C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GXM1552C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GXM1552C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GXM1552C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GXM1552C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXM1552C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GXM1552C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1552C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GXM1552C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXM1552C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GXM1552C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GXM1552C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GXM1552C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXM1552C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1552C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GXM1552C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXM1552C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GXM1552C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GXM1552C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXM1552C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GXM1552C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXM1552C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1552C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GXM1552C1H4R3CA02
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H4R3CA02 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.25e-01
L04 N03 N04 2.45e-11
R04 N03 N04 4.53e-01
C05 N04 N05 2.43e-11
L05 N04 N05 1.46e-11
R05 N04 N05 5.70e+00
C06 N05 Port2 3.88e-12
L06 N05 Port2 5.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C1H4R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GXM1552C1H4R7CA02
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H4R7CA02 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.54e-11
R04 N03 N04 5.44e-01
C05 N04 N05 6.59e-11
L05 N04 N05 5.88e-12
R05 N04 N05 1.57e+00
C06 N05 Port2 9.88e-12
L06 N05 Port2 2.60e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C1H4R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GXM1552C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXM1552C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1552C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GXM1552C1H5R1DA02
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H5R1DA02 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1552C1H5R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GXM1552C1H5R6DA02
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H5R6DA02 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.90e-11
R04 N03 N04 3.10e-01
C05 N04 N05 1.64e-11
L05 N04 N05 2.89e-11
R05 N04 N05 1.00e+01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.25e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C1H5R6DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GXM1552C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXM1552C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1552C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GXM1552C1H6R2DA02
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H6R2DA02 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.08e-01
L04 N03 N04 2.12e-11
R04 N03 N04 4.12e-01
C05 N04 N05 5.50e-11
L05 N04 N05 8.41e-12
R05 N04 N05 1.79e+00
C06 N05 Port2 4.66e-12
L06 N05 Port2 4.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C1H6R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GXM1552C1H6R8DA02
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H6R8DA02 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H6R8DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GXM1552C1H7R5DA02
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H7R5DA02 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 1.98e-01
L04 N03 N04 8.75e-12
R04 N03 N04 1.63e-01
C05 N04 N05 1.48e-11
L05 N04 N05 3.82e-11
R05 N04 N05 1.02e+01
C06 N05 Port2 8.77e-12
L06 N05 Port2 3.82e-11
R06 N05 Port2 1.36e+01
.ENDS GXM1552C1H7R5DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GXM1552C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXM1552C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXM1552C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1552C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GXM1552C1H8R2DA02
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H8R2DA02 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C1H8R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GXM1552C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1552C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GXM1552C1H9R1DA02
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C1H9R1DA02 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1552C1H9R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GXM1552C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GXM1552C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GXM1552C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GXM1552C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GXM1552C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXM1552C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GXM1552C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXM1552C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GXM1552C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GXM1552C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GXM1552C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GXM1552C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1552C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GXM1552C2A4R3CA02
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A4R3CA02 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.25e-01
L04 N03 N04 2.45e-11
R04 N03 N04 4.53e-01
C05 N04 N05 2.43e-11
L05 N04 N05 1.46e-11
R05 N04 N05 5.70e+00
C06 N05 Port2 3.88e-12
L06 N05 Port2 5.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C2A4R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GXM1552C2A4R7CA02
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A4R7CA02 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.54e-11
R04 N03 N04 5.44e-01
C05 N04 N05 6.59e-11
L05 N04 N05 5.88e-12
R05 N04 N05 1.57e+00
C06 N05 Port2 9.88e-12
L06 N05 Port2 2.60e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C2A4R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GXM1552C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1552C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GXM1552C2A5R1DA02
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A5R1DA02 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1552C2A5R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GXM1552C2A5R6DA02
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A5R6DA02 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.90e-11
R04 N03 N04 3.10e-01
C05 N04 N05 1.64e-11
L05 N04 N05 2.89e-11
R05 N04 N05 1.00e+01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.25e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C2A5R6DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GXM1552C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1552C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GXM1552C2A6R2DA02
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A6R2DA02 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.08e-01
L04 N03 N04 2.12e-11
R04 N03 N04 4.12e-01
C05 N04 N05 5.50e-11
L05 N04 N05 8.41e-12
R05 N04 N05 1.79e+00
C06 N05 Port2 4.66e-12
L06 N05 Port2 4.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1552C2A6R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GXM1552C2A6R8DA02
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A6R8DA02 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A6R8DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GXM1552C2A7R5DA02
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A7R5DA02 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 1.98e-01
L04 N03 N04 8.75e-12
R04 N03 N04 1.63e-01
C05 N04 N05 1.48e-11
L05 N04 N05 3.82e-11
R05 N04 N05 1.02e+01
C06 N05 Port2 8.77e-12
L06 N05 Port2 3.82e-11
R06 N05 Port2 1.36e+01
.ENDS GXM1552C2A7R5DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GXM1552C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXM1552C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GXM1552C2A8R2DA02
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A8R2DA02 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1552C2A8R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GXM1552C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1552C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CH(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GXM1552C2A9R1DA02
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1552C2A9R1DA02 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1552C2A9R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GXM1553C1H2R2CA02
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H2R2CA02 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C1H2R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GXM1553C1H2R4CA02
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H2R4CA02 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.22e-10
R03 N02 N03 3.20e-01
C04 N03 N04 1.53e-11
L04 N03 N04 2.02e-11
R04 N03 N04 2.67e+00
C05 N04 Port2 1.23e-10
L05 N04 Port2 2.31e-12
R05 N04 Port2 1.01e+05
.ENDS GXM1553C1H2R4CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GXM1553C1H2R7CA02
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H2R7CA02 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 3.00e-01
C04 N03 N04 1.52e-11
L04 N03 N04 2.08e-11
R04 N03 N04 2.44e+00
C05 N04 Port2 1.54e-11
L05 N04 Port2 1.84e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C1H2R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GXM1553C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GXM1553C1H3R3CA02
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H3R3CA02 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.97e-01
C05 N04 N05 1.94e-11
L05 N04 N05 1.57e-11
R05 N04 N05 3.17e+00
C06 N05 Port2 3.32e-12
L06 N05 Port2 6.96e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1553C1H3R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GXM1553C1H3R6CA02
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H3R6CA02 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 2.50e-01
C04 N03 N04 8.41e-12
L04 N03 N04 3.69e-11
R04 N03 N04 5.14e+00
C05 N04 Port2 1.26e-11
L05 N04 Port2 2.43e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C1H3R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GXM1553C1H3R9CA02
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C1H3R9CA02 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1553C1H3R9CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GXM1553C2A2R2CA02
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A2R2CA02 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C2A2R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GXM1553C2A2R4CA02
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A2R4CA02 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.22e-10
R03 N02 N03 3.20e-01
C04 N03 N04 1.53e-11
L04 N03 N04 2.02e-11
R04 N03 N04 2.67e+00
C05 N04 Port2 1.23e-10
L05 N04 Port2 2.31e-12
R05 N04 Port2 1.01e+05
.ENDS GXM1553C2A2R4CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GXM1553C2A2R7CA02
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A2R7CA02 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 3.00e-01
C04 N03 N04 1.52e-11
L04 N03 N04 2.08e-11
R04 N03 N04 2.44e+00
C05 N04 Port2 1.54e-11
L05 N04 Port2 1.84e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C2A2R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GXM1553C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GXM1553C2A3R3CA02
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A3R3CA02 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.97e-01
C05 N04 N05 1.94e-11
L05 N04 N05 1.57e-11
R05 N04 N05 3.17e+00
C06 N05 Port2 3.32e-12
L06 N05 Port2 6.96e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1553C2A3R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GXM1553C2A3R6CA02
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A3R6CA02 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 2.50e-01
C04 N03 N04 8.41e-12
L04 N03 N04 3.69e-11
R04 N03 N04 5.14e+00
C05 N04 Port2 1.26e-11
L05 N04 Port2 2.43e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1553C2A3R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CJ(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GXM1553C2A3R9CA02
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553C2A3R9CA02 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1553C2A3R9CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/1.20e-03[uF]/10[V]
* Murata P/N :GXM1553U1A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A122JA02 Port1 Port2
C01 Port1 N01 1.23e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.41e-02
L04 N03 N04 5.33e-11
R04 N03 N04 6.17e-01
L05 N04 N05 7.03e-11
R05 N04 N05 2.87e-02
C06 N05 N06 1.64e-08
L06 N05 N06 5.54e-12
R06 N05 N06 7.77e-02
C07 N06 N07 1.90e-09
L07 N06 N07 2.02e-11
R07 N06 N07 3.05e-01
C08 N07 Port2 2.99e-12
L08 N07 Port2 9.53e-11
R08 N07 Port2 2.45e+01
.ENDS GXM1553U1A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/1.50e-03[uF]/10[V]
* Murata P/N :GXM1553U1A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A152JA02 Port1 Port2
C01 Port1 N01 1.47e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 2.24e-02
L04 N03 N04 5.67e-11
R04 N03 N04 6.78e-01
L05 N04 N05 7.41e-11
R05 N04 N05 3.87e-02
C06 N05 N06 1.77e-08
L06 N05 N06 6.57e-12
R06 N05 N06 8.97e-02
C07 N06 N07 2.60e-09
L07 N06 N07 1.97e-11
R07 N06 N07 2.79e-01
C08 N07 Port2 3.95e-12
L08 N07 Port2 7.57e-11
R08 N07 Port2 3.53e+01
.ENDS GXM1553U1A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/1.80e-03[uF]/10[V]
* Murata P/N :GXM1553U1A182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 1.12e-02
L04 N03 N04 6.07e-11
R04 N03 N04 4.28e-01
L05 N04 N05 5.27e-11
R05 N04 N05 2.29e-02
L06 N05 N06 1.00e-10
R06 N05 N06 6.06e-03
C07 N06 N07 2.17e-08
L07 N06 N07 6.67e-12
R07 N06 N07 1.19e-01
C08 N07 N08 3.15e-09
L08 N07 N08 2.08e-11
R08 N07 N08 2.87e-01
C09 N08 Port2 7.33e-12
L09 N08 Port2 3.98e-11
R09 N08 Port2 1.83e+01
.ENDS GXM1553U1A182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/2.20e-03[uF]/10[V]
* Murata P/N :GXM1553U1A222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A222JA02 Port1 Port2
C01 Port1 N01 2.22e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 2.09e-02
L04 N03 N04 7.81e-11
R04 N03 N04 1.89e-01
L05 N04 N05 4.48e-11
R05 N04 N05 6.19e-03
C06 N05 N06 4.82e-07
L06 N05 N06 3.62e-13
R06 N05 N06 3.05e-02
C07 N06 N07 4.58e-09
L07 N06 N07 1.56e-11
R07 N06 N07 1.60e-01
C08 N07 N08 1.10e-11
L08 N07 N08 2.70e-11
R08 N07 N08 7.73e-01
C09 N08 Port2 1.75e-12
L09 N08 Port2 1.26e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1553U1A222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/2.70e-03[uF]/10[V]
* Murata P/N :GXM1553U1A272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A272JA02 Port1 Port2
C01 Port1 N01 2.61e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.76e-10
R03 N02 N03 1.55e-02
L04 N03 N04 5.48e-11
R04 N03 N04 3.48e-01
L05 N04 N05 2.98e-11
R05 N04 N05 3.38e-02
L06 N05 N06 5.98e-11
R06 N05 N06 1.38e-02
C07 N06 N07 3.89e-08
L07 N06 N07 5.71e-12
R07 N06 N07 5.30e-02
C08 N07 N08 4.41e-09
L08 N07 N08 2.39e-11
R08 N07 N08 2.15e-01
C09 N08 Port2 8.76e-12
L09 N08 Port2 3.29e-11
R09 N08 Port2 6.97e+00
.ENDS GXM1553U1A272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/3.30e-03[uF]/10[V]
* Murata P/N :GXM1553U1A332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A332JA02 Port1 Port2
C01 Port1 N01 3.22e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.34e-02
L04 N03 N04 7.26e-11
R04 N03 N04 3.50e-01
L05 N04 N05 7.97e-11
R05 N04 N05 1.75e-02
C06 N05 N06 5.89e-08
L06 N05 N06 4.72e-12
R06 N05 N06 6.54e-02
C07 N06 N07 5.66e-09
L07 N06 N07 2.35e-11
R07 N06 N07 2.28e-01
C08 N07 Port2 6.27e-12
L08 N07 Port2 4.91e-11
R08 N07 Port2 2.11e+01
.ENDS GXM1553U1A332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/3.90e-03[uF]/10[V]
* Murata P/N :GXM1553U1A392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A392JA02 Port1 Port2
C01 Port1 N01 3.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.34e-10
R03 N02 N03 1.34e-02
L04 N03 N04 7.51e-11
R04 N03 N04 3.01e-01
L05 N04 N05 7.35e-11
R05 N04 N05 1.99e-02
C06 N05 N06 4.98e-08
L06 N05 N06 7.05e-12
R06 N05 N06 7.76e-02
C07 N06 N07 9.14e-09
L07 N06 N07 1.82e-11
R07 N06 N07 1.81e-01
C08 N07 Port2 9.97e-12
L08 N07 Port2 3.06e-11
R08 N07 Port2 1.06e+01
.ENDS GXM1553U1A392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/UJ(-25to85[deg])/4.70e-03[uF]/10[V]
* Murata P/N :GXM1553U1A472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1553U1A472JA02 Port1 Port2
C01 Port1 N01 4.69e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 1.02e-02
L04 N03 N04 9.05e-11
R04 N03 N04 3.06e-01
L05 N04 N05 6.77e-11
R05 N04 N05 1.44e-02
C06 N05 N06 4.81e-08
L06 N05 N06 9.53e-12
R06 N05 N06 9.35e-02
C07 N06 N07 1.09e-08
L07 N06 N07 2.01e-11
R07 N06 N07 1.69e-01
C08 N07 Port2 4.53e-12
L08 N07 Port2 5.78e-11
R08 N07 Port2 2.07e+01
.ENDS GXM1553U1A472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R1CA02
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R1CA02 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R1CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R2CA02
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R2CA02 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R3CA02
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R3CA02 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R5CA02
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R5CA02 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R5CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.60e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R6CA02
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R6CA02 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GXM1554C1H1R8CA02
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H1R8CA02 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 4.20e-01
C04 N03 N04 1.70e-11
L04 N03 N04 1.80e-11
R04 N03 N04 3.70e+00
C05 N04 Port2 6.87e-12
L05 N04 Port2 4.01e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H1R8CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GXM1554C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1554C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR10WA02
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR10WA02 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.90e-10
R03 N02 N03 9.53e-01
C04 N03 Port2 3.64e-11
L04 N03 Port2 9.27e-13
R04 N03 Port2 8.74e-01
.ENDS GXM1554C1HR10WA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR20BA02
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR20BA02 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 9.27e-01
C04 N03 N04 3.28e-11
L04 N03 N04 1.71e-12
R04 N03 N04 1.11e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.60e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR20BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/3.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR30BA02
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR30BA02 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 9.02e-01
C04 N03 N04 3.32e-12
L04 N03 N04 1.63e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 5.89e-12
L05 N04 Port2 8.29e-12
R05 N04 Port2 1.03e+01
.ENDS GXM1554C1HR30BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR40BA02
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR40BA02 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 8.82e-01
C04 N03 N04 2.48e-12
L04 N03 N04 1.97e-11
R04 N03 N04 1.23e+01
C05 N04 Port2 8.97e-13
L05 N04 Port2 5.42e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR40BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR50BA02
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR50BA02 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.53e-10
R03 N02 N03 8.63e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.42e-11
R04 N03 N04 7.03e+00
C05 N04 Port2 6.63e-13
L05 N04 Port2 7.29e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR50BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/6.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR60BA02
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR60BA02 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 8.41e-01
C04 N03 N04 1.50e-12
L04 N03 N04 3.42e-11
R04 N03 N04 1.69e+01
C05 N04 Port2 6.12e-13
L05 N04 Port2 7.90e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR60BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/7.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR70BA02
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR70BA02 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.97e-10
R03 N02 N03 8.04e-01
C04 N03 N04 1.02e-12
L04 N03 N04 5.01e-11
R04 N03 N04 3.19e+01
C05 N04 Port2 4.05e-13
L05 N04 Port2 1.09e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR70BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/8.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR80BA02
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR80BA02 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-10
R03 N02 N03 7.64e-01
C04 N03 N04 1.34e-12
L04 N03 N04 4.41e-11
R04 N03 N04 3.17e+01
C05 N04 Port2 4.34e-13
L05 N04 Port2 1.07e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR80BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/9.00e-07[uF]/50[V]
* Murata P/N :GXM1554C1HR90BA02
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C1HR90BA02 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 7.43e-01
C04 N03 N04 1.11e-12
L04 N03 N04 5.44e-11
R04 N03 N04 4.04e+01
C05 N04 Port2 4.92e-13
L05 N04 Port2 1.01e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C1HR90BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R1CA02
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R1CA02 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R1CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R2CA02
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R2CA02 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R3CA02
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R3CA02 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R5CA02
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R5CA02 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R5CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R6CA02
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R6CA02 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GXM1554C2A1R8CA02
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A1R8CA02 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 4.20e-01
C04 N03 N04 1.70e-11
L04 N03 N04 1.80e-11
R04 N03 N04 3.70e+00
C05 N04 Port2 6.87e-12
L05 N04 Port2 4.01e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A1R8CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GXM1554C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1554C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/1.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR10WA02
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR10WA02 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.90e-10
R03 N02 N03 9.53e-01
C04 N03 Port2 3.64e-11
L04 N03 Port2 9.27e-13
R04 N03 Port2 8.74e-01
.ENDS GXM1554C2AR10WA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/2.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR20BA02
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR20BA02 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 9.27e-01
C04 N03 N04 3.28e-11
L04 N03 N04 1.71e-12
R04 N03 N04 1.11e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.60e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR20BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/3.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR30BA02
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR30BA02 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 9.02e-01
C04 N03 N04 3.32e-12
L04 N03 N04 1.63e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 5.89e-12
L05 N04 Port2 8.29e-12
R05 N04 Port2 1.03e+01
.ENDS GXM1554C2AR30BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/4.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR40BA02
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR40BA02 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 8.82e-01
C04 N03 N04 2.48e-12
L04 N03 N04 1.97e-11
R04 N03 N04 1.23e+01
C05 N04 Port2 8.97e-13
L05 N04 Port2 5.42e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR40BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/5.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR50BA02
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR50BA02 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.53e-10
R03 N02 N03 8.63e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.42e-11
R04 N03 N04 7.03e+00
C05 N04 Port2 6.63e-13
L05 N04 Port2 7.29e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR50BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/6.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR60BA02
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR60BA02 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 8.41e-01
C04 N03 N04 1.50e-12
L04 N03 N04 3.42e-11
R04 N03 N04 1.69e+01
C05 N04 Port2 6.12e-13
L05 N04 Port2 7.90e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR60BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/7.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR70BA02
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR70BA02 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.97e-10
R03 N02 N03 8.04e-01
C04 N03 N04 1.02e-12
L04 N03 N04 5.01e-11
R04 N03 N04 3.19e+01
C05 N04 Port2 4.05e-13
L05 N04 Port2 1.09e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR70BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/8.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR80BA02
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR80BA02 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-10
R03 N02 N03 7.64e-01
C04 N03 N04 1.34e-12
L04 N03 N04 4.41e-11
R04 N03 N04 3.17e+01
C05 N04 Port2 4.34e-13
L05 N04 Port2 1.07e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR80BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/CK(-55to125[deg])/9.00e-07[uF]/100[V]
* Murata P/N :GXM1554C2AR90BA02
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1554C2AR90BA02 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 7.43e-01
C04 N03 N04 1.11e-12
L04 N03 N04 5.44e-11
R04 N03 N04 4.04e+01
C05 N04 Port2 4.92e-13
L05 N04 Port2 1.01e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1554C2AR90BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GXM1555C1H100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GXM1555C1H101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXM1555C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H102JA02 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.26e-11
R03 N02 N03 1.46e-02
L04 N03 N04 1.36e-10
R04 N03 N04 2.95e-02
C05 N04 N05 5.86e-09
L05 N04 N05 1.40e-11
R05 N04 N05 2.91e-01
C06 N05 N06 1.79e-09
L06 N05 N06 2.06e-11
R06 N05 N06 4.45e-01
C07 N06 N07 2.01e-12
L07 N06 N07 1.29e-10
R07 N06 N07 1.00e+05
C08 N07 Port2 6.84e-13
L08 N07 Port2 6.98e-11
R08 N07 Port2 9.47e-01
.ENDS GXM1555C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GXM1555C1H120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-04[uF]/50[V]
* Murata P/N :GXM1555C1H121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.94e-11
R03 N02 N03 1.15e-01
C04 N03 N04 1.04e-09
L04 N03 N04 8.96e-12
R04 N03 N04 5.12e-01
C05 N04 N05 2.75e-10
L05 N04 N05 1.45e-11
R05 N04 N05 1.05e+00
C06 N05 N06 5.38e-12
L06 N05 N06 5.45e-11
R06 N05 N06 1.42e+00
C07 N06 Port2 3.01e-13
L07 N06 Port2 2.43e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GXM1555C1H150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GXM1555C1H151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 9.06e-02
L04 N03 N04 8.02e-12
R04 N03 N04 2.56e-02
C05 N04 N05 1.23e-09
L05 N04 N05 8.59e-12
R05 N04 N05 3.37e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.49e-11
R06 N05 N06 8.69e-01
C07 N06 N07 6.81e-12
L07 N06 N07 5.02e-11
R07 N06 N07 1.48e+00
C08 N07 Port2 2.03e-12
L08 N07 Port2 1.12e-10
R08 N07 Port2 1.26e+05
.ENDS GXM1555C1H151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GXM1555C1H180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXM1555C1H180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-04[uF]/50[V]
* Murata P/N :GXM1555C1H181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 7.66e-02
L04 N03 N04 3.40e-11
R04 N03 N04 1.14e+00
L05 N04 N05 2.55e-11
R05 N04 N05 4.56e-01
C06 N05 N06 2.31e-09
L06 N05 N06 6.02e-12
R06 N05 N06 3.47e-01
C07 N06 N07 3.55e-10
L07 N06 N07 1.73e-11
R07 N06 N07 8.02e-01
C08 N07 N08 8.78e-11
L08 N07 N08 4.58e-12
R08 N07 N08 9.07e-01
C09 N08 Port2 3.70e-12
L09 N08 Port2 6.56e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1555C1H181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1H1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R1CA02
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R1CA02 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R1CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R2CA02
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R2CA02 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R3CA02
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R3CA02 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R5CA02
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R5CA02 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R5CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R6CA02
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R6CA02 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GXM1555C1H1R8CA02
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H1R8CA02 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 4.20e-01
C04 N03 N04 1.70e-11
L04 N03 N04 1.80e-11
R04 N03 N04 3.70e+00
C05 N04 Port2 6.87e-12
L05 N04 Port2 4.01e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H1R8CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GXM1555C1H220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXM1555C1H220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GXM1555C1H221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.37e-11
R04 N03 N04 1.06e+00
C05 N04 N05 2.16e-09
L05 N04 N05 6.41e-12
R05 N04 N05 1.87e-01
C06 N05 N06 4.14e-10
L06 N05 N06 1.36e-11
R06 N05 N06 5.70e-01
C07 N06 N07 5.54e-11
L07 N06 N07 5.97e-12
R07 N06 N07 3.61e-01
C08 N07 Port2 2.85e-12
L08 N07 Port2 8.91e-11
R08 N07 Port2 5.66e+08
.ENDS GXM1555C1H221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GXM1555C1H270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXM1555C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 8.50e-02
L04 N03 N04 5.93e-11
R04 N03 N04 1.31e+00
L05 N04 N05 3.37e-12
R05 N04 N05 8.32e-03
C06 N05 N06 4.11e-09
L06 N05 N06 4.87e-12
R06 N05 N06 1.41e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.31e-11
R07 N06 N07 4.84e-01
C08 N07 N08 2.44e-11
L08 N07 N08 1.54e-11
R08 N07 N08 3.82e+00
C09 N08 Port2 1.39e-12
L09 N08 Port2 1.79e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1555C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GXM1555C1H2R2CA02
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H2R2CA02 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H2R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GXM1555C1H2R4CA02
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H2R4CA02 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.22e-10
R03 N02 N03 3.20e-01
C04 N03 N04 1.53e-11
L04 N03 N04 2.02e-11
R04 N03 N04 2.67e+00
C05 N04 Port2 1.23e-10
L05 N04 Port2 2.31e-12
R05 N04 Port2 1.01e+05
.ENDS GXM1555C1H2R4CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GXM1555C1H2R7CA02
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H2R7CA02 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 3.00e-01
C04 N03 N04 1.52e-11
L04 N03 N04 2.08e-11
R04 N03 N04 2.44e+00
C05 N04 Port2 1.54e-11
L05 N04 Port2 1.84e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H2R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GXM1555C1H330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXM1555C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 6.98e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.05e+00
C05 N04 N05 3.07e-09
L05 N04 N05 8.22e-12
R05 N04 N05 1.95e-01
C06 N05 N06 5.91e-10
L06 N05 N06 1.82e-11
R06 N05 N06 6.02e-01
C07 N06 N07 2.17e-12
L07 N06 N07 9.96e-11
R07 N06 N07 1.00e+05
C08 N07 Port2 3.01e-12
L08 N07 Port2 5.03e-11
R08 N07 Port2 4.07e+01
.ENDS GXM1555C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GXM1555C1H390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXM1555C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 6.00e-02
L04 N03 N04 6.85e-11
R04 N03 N04 7.01e-01
C05 N04 N05 7.11e-09
L05 N04 N05 4.32e-12
R05 N04 N05 1.84e-01
C06 N05 N06 1.16e-09
L06 N05 N06 1.16e-11
R06 N05 N06 4.33e-01
C07 N06 N07 3.87e-11
L07 N06 N07 1.04e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 3.02e-12
L08 N07 Port2 8.02e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GXM1555C1H3R3CA02
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H3R3CA02 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.97e-01
C05 N04 N05 1.94e-11
L05 N04 N05 1.57e-11
R05 N04 N05 3.17e+00
C06 N05 Port2 3.32e-12
L06 N05 Port2 6.96e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H3R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GXM1555C1H3R6CA02
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H3R6CA02 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 2.50e-01
C04 N03 N04 8.41e-12
L04 N03 N04 3.69e-11
R04 N03 N04 5.14e+00
C05 N04 Port2 1.26e-11
L05 N04 Port2 2.43e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C1H3R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GXM1555C1H3R9CA02
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H3R9CA02 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1555C1H3R9CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GXM1555C1H470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXM1555C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.64e-11
R04 N03 N04 4.09e-01
L05 N04 N05 2.96e-11
R05 N04 N05 3.72e-01
C06 N05 N06 5.30e-09
L06 N05 N06 7.26e-12
R06 N05 N06 2.25e-01
C07 N06 N07 1.09e-09
L07 N06 N07 1.61e-11
R07 N06 N07 4.96e-01
C08 N07 Port2 2.49e-12
L08 N07 Port2 8.90e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1555C1H4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GXM1555C1H4R3CA02
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H4R3CA02 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.25e-01
L04 N03 N04 2.45e-11
R04 N03 N04 4.53e-01
C05 N04 N05 2.43e-11
L05 N04 N05 1.46e-11
R05 N04 N05 5.70e+00
C06 N05 Port2 3.88e-12
L06 N05 Port2 5.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H4R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GXM1555C1H4R7CA02
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H4R7CA02 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.54e-11
R04 N03 N04 5.44e-01
C05 N04 N05 6.59e-11
L05 N04 N05 5.88e-12
R05 N04 N05 1.57e+00
C06 N05 Port2 9.88e-12
L06 N05 Port2 2.60e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H4R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/50[V]
* Murata P/N :GXM1555C1H560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXM1555C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 5.00e-02
L04 N03 N04 3.63e-11
R04 N03 N04 1.70e+00
L05 N04 N05 3.30e-11
R05 N04 N05 3.88e-01
C06 N05 N06 6.08e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.75e-01
C07 N06 N07 7.94e-10
L07 N06 N07 2.01e-11
R07 N06 N07 4.15e-01
C08 N07 Port2 3.66e-12
L08 N07 Port2 7.36e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1555C1H5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GXM1555C1H5R1DA02
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H5R1DA02 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1555C1H5R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GXM1555C1H5R6DA02
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H5R6DA02 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.90e-11
R04 N03 N04 3.10e-01
C05 N04 N05 1.64e-11
L05 N04 N05 2.89e-11
R05 N04 N05 1.00e+01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.25e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H5R6DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GXM1555C1H680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C1H680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXM1555C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.92e-11
R03 N02 N03 5.50e-02
L04 N03 N04 9.11e-12
R04 N03 N04 8.98e-01
L05 N04 N05 4.27e-11
R05 N04 N05 7.33e-01
C06 N05 N06 4.02e-09
L06 N05 N06 1.28e-11
R06 N05 N06 2.27e-01
C07 N06 N07 1.18e-09
L07 N06 N07 1.82e-11
R07 N06 N07 4.36e-01
C08 N07 N08 1.76e-09
L08 N07 N08 4.22e-12
R08 N07 N08 1.10e-01
C09 N08 N09 7.01e-10
L09 N08 N09 1.49e-12
R09 N08 N09 5.98e-01
C10 N09 Port2 1.04e-12
L10 N09 Port2 1.94e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1555C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GXM1555C1H6R2DA02
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H6R2DA02 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.08e-01
L04 N03 N04 2.12e-11
R04 N03 N04 4.12e-01
C05 N04 N05 5.50e-11
L05 N04 N05 8.41e-12
R05 N04 N05 1.79e+00
C06 N05 Port2 4.66e-12
L06 N05 Port2 4.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C1H6R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GXM1555C1H6R8DA02
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H6R8DA02 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H6R8DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GXM1555C1H7R5DA02
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H7R5DA02 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 1.98e-01
L04 N03 N04 8.75e-12
R04 N03 N04 1.63e-01
C05 N04 N05 1.48e-11
L05 N04 N05 3.82e-11
R05 N04 N05 1.02e+01
C06 N05 Port2 8.77e-12
L06 N05 Port2 3.82e-11
R06 N05 Port2 1.36e+01
.ENDS GXM1555C1H7R5DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/50[V]
* Murata P/N :GXM1555C1H820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXM1555C1H820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXM1555C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.71e-11
R04 N03 N04 9.87e-01
C05 N04 N05 5.29e-09
L05 N04 N05 1.24e-11
R05 N04 N05 2.65e-01
C06 N05 N06 1.20e-09
L06 N05 N06 2.37e-11
R06 N05 N06 5.33e-01
C07 N06 N07 9.06e-10
L07 N06 N07 1.04e-11
R07 N06 N07 2.21e-01
C08 N07 N08 1.47e-09
L08 N07 N08 2.91e-12
R08 N07 N08 1.19e-01
C09 N08 Port2 1.23e-12
L09 N08 Port2 7.59e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1555C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GXM1555C1H8R2DA02
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H8R2DA02 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C1H8R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GXM1555C1H9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1555C1H9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GXM1555C1H9R1DA02
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1H9R1DA02 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1555C1H9R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR10WA02
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR10WA02 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.90e-10
R03 N02 N03 9.53e-01
C04 N03 Port2 3.64e-11
L04 N03 Port2 9.27e-13
R04 N03 Port2 8.74e-01
.ENDS GXM1555C1HR10WA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR20BA02
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR20BA02 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 9.27e-01
C04 N03 N04 3.28e-11
L04 N03 N04 1.71e-12
R04 N03 N04 1.11e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.60e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR20BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR30BA02
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR30BA02 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 9.02e-01
C04 N03 N04 3.32e-12
L04 N03 N04 1.63e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 5.89e-12
L05 N04 Port2 8.29e-12
R05 N04 Port2 1.03e+01
.ENDS GXM1555C1HR30BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR40BA02
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR40BA02 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 8.82e-01
C04 N03 N04 2.48e-12
L04 N03 N04 1.97e-11
R04 N03 N04 1.23e+01
C05 N04 Port2 8.97e-13
L05 N04 Port2 5.42e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR40BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR50BA02
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR50BA02 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.53e-10
R03 N02 N03 8.63e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.42e-11
R04 N03 N04 7.03e+00
C05 N04 Port2 6.63e-13
L05 N04 Port2 7.29e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR50BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR60BA02
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR60BA02 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 8.41e-01
C04 N03 N04 1.50e-12
L04 N03 N04 3.42e-11
R04 N03 N04 1.69e+01
C05 N04 Port2 6.12e-13
L05 N04 Port2 7.90e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR60BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR70BA02
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR70BA02 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.97e-10
R03 N02 N03 8.04e-01
C04 N03 N04 1.02e-12
L04 N03 N04 5.01e-11
R04 N03 N04 3.19e+01
C05 N04 Port2 4.05e-13
L05 N04 Port2 1.09e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR70BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR80BA02
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR80BA02 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-10
R03 N02 N03 7.64e-01
C04 N03 N04 1.34e-12
L04 N03 N04 4.41e-11
R04 N03 N04 3.17e+01
C05 N04 Port2 4.34e-13
L05 N04 Port2 1.07e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR80BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/50[V]
* Murata P/N :GXM1555C1HR90BA02
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C1HR90BA02 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 7.43e-01
C04 N03 N04 1.11e-12
L04 N03 N04 5.44e-11
R04 N03 N04 4.04e+01
C05 N04 Port2 4.92e-13
L05 N04 Port2 1.01e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C1HR90BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GXM1555C2A100JA02
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A100JA02 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.81e-11
R03 N02 N03 1.40e-01
L04 N03 N04 2.26e-11
R04 N03 N04 2.35e-01
C05 N04 N05 2.76e-11
L05 N04 N05 2.92e-11
R05 N04 N05 7.28e+00
C06 N05 N06 1.06e-11
L06 N05 N06 3.15e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 9.28e-13
L07 N06 Port2 2.13e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A100JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GXM1555C2A101JA02
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A101JA02 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.10e-01
L04 N03 N04 7.82e-12
R04 N03 N04 3.42e-02
C05 N04 N05 8.96e-10
L05 N04 N05 7.70e-12
R05 N04 N05 3.52e-01
C06 N05 N06 1.74e-10
L06 N05 N06 1.63e-11
R06 N05 N06 1.02e+00
C07 N06 N07 7.08e-12
L07 N06 N07 3.54e-11
R07 N06 N07 1.70e+00
C08 N07 Port2 2.12e-12
L08 N07 Port2 9.97e-11
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A101JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/100[V]
* Murata P/N :GXM1555C2A120JA02
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A120JA02 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.47e-01
C05 N04 N05 8.69e-11
L05 N04 N05 1.21e-11
R05 N04 N05 2.88e+00
C06 N05 N06 1.16e-11
L06 N05 N06 2.91e-11
R06 N05 N06 5.24e+00
C07 N06 Port2 1.10e-12
L07 N06 Port2 1.75e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A120JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GXM1555C2A150JA02
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A150JA02 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.50e-01
L04 N03 N04 2.52e-11
R04 N03 N04 4.18e-01
C05 N04 N05 1.22e-10
L05 N04 N05 8.84e-12
R05 N04 N05 1.71e+00
C06 N05 N06 1.47e-11
L06 N05 N06 2.31e-11
R06 N05 N06 4.50e+00
C07 N06 Port2 1.37e-12
L07 N06 Port2 1.51e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A150JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GXM1555C2A180JA02
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A180JA02 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.40e-11
R04 N03 N04 2.05e-01
C05 N04 N05 1.21e-10
L05 N04 N05 1.12e-11
R05 N04 N05 1.92e+00
C06 N05 N06 7.86e-12
L06 N05 N06 4.32e-11
R06 N05 N06 5.99e+00
C07 N06 Port2 1.02e-12
L07 N06 Port2 1.84e-10
R07 N06 Port2 1.17e+09
.ENDS GXM1555C2A180JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R0CA02
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R0CA02 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 7.33e-01
C04 N03 N04 1.26e-12
L04 N03 N04 5.19e-11
R04 N03 N04 3.11e+01
C05 N04 Port2 1.20e-13
L05 N04 Port2 2.65e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2A1R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R1CA02
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R1CA02 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R1CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R2CA02
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R2CA02 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R3CA02
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R3CA02 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 6.50e-01
C04 N03 N04 1.65e-11
L04 N03 N04 1.54e-11
R04 N03 N04 2.26e+00
C05 N04 Port2 1.10e-12
L05 N04 Port2 1.50e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R5CA02
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R5CA02 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R5CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R6CA02
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R6CA02 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-01
C04 N03 N04 2.70e-11
L04 N03 N04 1.16e-11
R04 N03 N04 1.56e+00
C05 N04 Port2 2.35e-13
L05 N04 Port2 2.58e-10
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/100[V]
* Murata P/N :GXM1555C2A1R8CA02
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A1R8CA02 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 4.20e-01
C04 N03 N04 1.70e-11
L04 N03 N04 1.80e-11
R04 N03 N04 3.70e+00
C05 N04 Port2 6.87e-12
L05 N04 Port2 4.01e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A1R8CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GXM1555C2A220JA02
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A220JA02 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 1.20e-01
L04 N03 N04 2.63e-11
R04 N03 N04 3.17e-01
C05 N04 N05 1.88e-10
L05 N04 N05 8.62e-12
R05 N04 N05 1.01e+00
C06 N05 N06 1.71e-11
L06 N05 N06 2.42e-11
R06 N05 N06 3.67e+00
C07 N06 Port2 9.64e-13
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.27e+09
.ENDS GXM1555C2A220JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/100[V]
* Murata P/N :GXM1555C2A270JA02
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A270JA02 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.26e-11
R03 N02 N03 1.15e-01
L04 N03 N04 4.18e-11
R04 N03 N04 1.49e+00
C05 N04 N05 3.62e-10
L05 N04 N05 5.64e-12
R05 N04 N05 8.64e-01
C06 N05 N06 1.30e-10
L06 N05 N06 5.01e-12
R06 N05 N06 1.36e+00
C07 N06 N07 1.33e-11
L07 N06 N07 2.30e-11
R07 N06 N07 2.51e+00
C08 N07 Port2 6.65e-13
L08 N07 Port2 2.45e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A270JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A2R0CA02
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A2R0CA02 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A2R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/100[V]
* Murata P/N :GXM1555C2A2R2CA02
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A2R2CA02 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 3.70e-01
C04 N03 N04 4.14e-11
L04 N03 N04 9.56e-12
R04 N03 N04 6.77e-01
C05 N04 Port2 2.06e-11
L05 N04 Port2 1.40e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A2R2CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/100[V]
* Murata P/N :GXM1555C2A2R4CA02
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A2R4CA02 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.22e-10
R03 N02 N03 3.20e-01
C04 N03 N04 1.53e-11
L04 N03 N04 2.02e-11
R04 N03 N04 2.67e+00
C05 N04 Port2 1.23e-10
L05 N04 Port2 2.31e-12
R05 N04 Port2 1.01e+05
.ENDS GXM1555C2A2R4CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/100[V]
* Murata P/N :GXM1555C2A2R7CA02
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A2R7CA02 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 3.00e-01
C04 N03 N04 1.52e-11
L04 N03 N04 2.08e-11
R04 N03 N04 2.44e+00
C05 N04 Port2 1.54e-11
L05 N04 Port2 1.84e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A2R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GXM1555C2A330JA02
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A330JA02 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.31e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.74e-11
R04 N03 N04 1.60e-01
C05 N04 N05 4.83e-10
L05 N04 N05 5.12e-12
R05 N04 N05 4.47e-01
C06 N05 N06 3.86e-11
L06 N05 N06 2.08e-11
R06 N05 N06 2.36e+00
C07 N06 N07 1.39e-11
L07 N06 N07 2.37e-11
R07 N06 N07 4.89e+00
C08 N07 Port2 8.18e-13
L08 N07 Port2 2.25e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A330JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/100[V]
* Murata P/N :GXM1555C2A390JA02
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A390JA02 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.47e-11
R04 N03 N04 1.29e-01
C05 N04 N05 4.13e-10
L05 N04 N05 7.65e-12
R05 N04 N05 7.79e-01
C06 N05 N06 7.42e-11
L06 N05 N06 1.24e-11
R06 N05 N06 1.56e+00
C07 N06 N07 1.27e-11
L07 N06 N07 2.57e-11
R07 N06 N07 4.20e+00
C08 N07 Port2 7.58e-13
L08 N07 Port2 1.93e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A390JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A3R0CA02
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A3R0CA02 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 2.80e-01
C04 N03 N04 1.05e-11
L04 N03 N04 2.61e-11
R04 N03 N04 3.04e+00
C05 N04 Port2 3.66e-12
L05 N04 Port2 6.90e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A3R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/100[V]
* Murata P/N :GXM1555C2A3R3CA02
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A3R3CA02 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 2.60e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.97e-01
C05 N04 N05 1.94e-11
L05 N04 N05 1.57e-11
R05 N04 N05 3.17e+00
C06 N05 Port2 3.32e-12
L06 N05 Port2 6.96e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A3R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GXM1555C2A3R6CA02
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A3R6CA02 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 2.50e-01
C04 N03 N04 8.41e-12
L04 N03 N04 3.69e-11
R04 N03 N04 5.14e+00
C05 N04 Port2 1.26e-11
L05 N04 Port2 2.43e-11
R05 N04 Port2 1.00e+05
.ENDS GXM1555C2A3R6CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/100[V]
* Murata P/N :GXM1555C2A3R9CA02
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A3R9CA02 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1555C2A3R9CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GXM1555C2A470JA02
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A470JA02 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.48e-11
R03 N02 N03 1.00e-01
L04 N03 N04 1.30e-11
R04 N03 N04 1.44e-01
C05 N04 N05 3.94e-10
L05 N04 N05 1.00e-11
R05 N04 N05 9.37e-01
C06 N05 N06 7.38e-11
L06 N05 N06 1.73e-11
R06 N05 N06 1.86e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.64e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 8.21e-13
L08 N07 Port2 2.00e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A470JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A4R0CA02
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A4R0CA02 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 1.89e-12
L04 N03 Port2 1.39e-10
R04 N03 Port2 6.00e+01
.ENDS GXM1555C2A4R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/100[V]
* Murata P/N :GXM1555C2A4R3CA02
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A4R3CA02 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.25e-01
L04 N03 N04 2.45e-11
R04 N03 N04 4.53e-01
C05 N04 N05 2.43e-11
L05 N04 N05 1.46e-11
R05 N04 N05 5.70e+00
C06 N05 Port2 3.88e-12
L06 N05 Port2 5.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A4R3CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/100[V]
* Murata P/N :GXM1555C2A4R7CA02
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A4R7CA02 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.54e-11
R04 N03 N04 5.44e-01
C05 N04 N05 6.59e-11
L05 N04 N05 5.88e-12
R05 N04 N05 1.57e+00
C06 N05 Port2 9.88e-12
L06 N05 Port2 2.60e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A4R7CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-05[uF]/100[V]
* Murata P/N :GXM1555C2A560JA02
* Property : C = 5.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A560JA02 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.25e-11
R04 N03 N04 1.02e-01
C05 N04 N05 4.70e-10
L05 N04 N05 8.55e-12
R05 N04 N05 7.60e-01
C06 N05 N06 8.85e-11
L06 N05 N06 1.89e-11
R06 N05 N06 1.83e+00
C07 N06 N07 9.17e-12
L07 N06 N07 3.41e-11
R07 N06 N07 3.30e+00
C08 N07 Port2 1.36e-12
L08 N07 Port2 1.33e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A560JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A5R0CA02
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A5R0CA02 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1555C2A5R0CA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/100[V]
* Murata P/N :GXM1555C2A5R1DA02
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A5R1DA02 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.10e-01
L04 N03 N04 2.04e-11
R04 N03 N04 5.60e-01
C05 N04 Port2 1.55e-11
L05 N04 Port2 2.65e-11
R05 N04 Port2 9.58e+00
.ENDS GXM1555C2A5R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/100[V]
* Murata P/N :GXM1555C2A5R6DA02
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A5R6DA02 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.50e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.90e-11
R04 N03 N04 3.10e-01
C05 N04 N05 1.64e-11
L05 N04 N05 2.89e-11
R05 N04 N05 1.00e+01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.25e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A5R6DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GXM1555C2A680JA02
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A680JA02 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.10e-01
L04 N03 N04 2.49e-11
R04 N03 N04 1.70e-01
C05 N04 N05 6.40e-10
L05 N04 N05 5.85e-12
R05 N04 N05 3.42e-01
C06 N05 N06 6.14e-11
L06 N05 N06 2.21e-11
R06 N05 N06 1.60e+00
C07 N06 N07 2.42e-11
L07 N06 N07 1.60e-11
R07 N06 N07 1.91e+00
C08 N07 Port2 1.95e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1555C2A680JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A6R0DA02
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A6R0DA02 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.10e-01
L04 N03 N04 1.57e-11
R04 N03 N04 3.40e-01
C05 N04 N05 2.18e-11
L05 N04 N05 1.96e-11
R05 N04 N05 3.24e+00
C06 N05 Port2 3.96e-12
L06 N05 Port2 6.86e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A6R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/100[V]
* Murata P/N :GXM1555C2A6R2DA02
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A6R2DA02 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 2.08e-01
L04 N03 N04 2.12e-11
R04 N03 N04 4.12e-01
C05 N04 N05 5.50e-11
L05 N04 N05 8.41e-12
R05 N04 N05 1.79e+00
C06 N05 Port2 4.66e-12
L06 N05 Port2 4.91e-11
R06 N05 Port2 1.00e+05
.ENDS GXM1555C2A6R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/100[V]
* Murata P/N :GXM1555C2A6R8DA02
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A6R8DA02 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A6R8DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A7R0DA02
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A7R0DA02 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 2.00e-01
L04 N03 N04 2.29e-11
R04 N03 N04 3.39e-01
C05 N04 N05 1.27e-10
L05 N04 N05 4.41e-12
R05 N04 N05 1.12e+00
C06 N05 N06 7.05e-11
L06 N05 N06 5.00e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.34e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A7R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/100[V]
* Murata P/N :GXM1555C2A7R5DA02
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A7R5DA02 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 1.98e-01
L04 N03 N04 8.75e-12
R04 N03 N04 1.63e-01
C05 N04 N05 1.48e-11
L05 N04 N05 3.82e-11
R05 N04 N05 1.02e+01
C06 N05 Port2 8.77e-12
L06 N05 Port2 3.82e-11
R06 N05 Port2 1.36e+01
.ENDS GXM1555C2A7R5DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-05[uF]/100[V]
* Murata P/N :GXM1555C2A820JA02
* Property : C = 8.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A820JA02 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.32e-11
R04 N03 N04 6.92e-02
C05 N04 N05 1.03e-09
L05 N04 N05 5.14e-12
R05 N04 N05 3.36e-01
C06 N05 N06 1.16e-10
L06 N05 N06 1.74e-11
R06 N05 N06 1.21e+00
C07 N06 N07 5.17e-12
L07 N06 N07 4.62e-11
R07 N06 N07 3.15e+00
C08 N07 Port2 1.52e-12
L08 N07 Port2 1.45e-10
R08 N07 Port2 9.23e+08
.ENDS GXM1555C2A820JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A8R0DA02
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A8R0DA02 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A8R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/100[V]
* Murata P/N :GXM1555C2A8R2DA02
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A8R2DA02 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 1.96e-01
L04 N03 N04 2.21e-11
R04 N03 N04 3.42e-01
C05 N04 N05 1.93e-10
L05 N04 N05 3.33e-12
R05 N04 N05 6.28e-01
C06 N05 N06 3.93e-11
L06 N05 N06 8.74e-12
R06 N05 N06 1.61e+00
C07 N06 Port2 7.98e-12
L07 N06 Port2 3.45e-11
R07 N06 Port2 1.00e+05
.ENDS GXM1555C2A8R2DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GXM1555C2A9R0DA02
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A9R0DA02 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1555C2A9R0DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/100[V]
* Murata P/N :GXM1555C2A9R1DA02
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2A9R1DA02 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 1.90e-01
L04 N03 N04 9.16e-12
R04 N03 N04 1.57e-01
C05 N04 N05 1.86e-11
L05 N04 N05 3.75e-11
R05 N04 N05 8.66e+00
C06 N05 Port2 3.36e-12
L06 N05 Port2 8.36e-11
R06 N05 Port2 4.32e+01
.ENDS GXM1555C2A9R1DA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR10WA02
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR10WA02 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.90e-10
R03 N02 N03 9.53e-01
C04 N03 Port2 3.64e-11
L04 N03 Port2 9.27e-13
R04 N03 Port2 8.74e-01
.ENDS GXM1555C2AR10WA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR20BA02
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR20BA02 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 9.27e-01
C04 N03 N04 3.28e-11
L04 N03 N04 1.71e-12
R04 N03 N04 1.11e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.60e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR20BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR30BA02
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR30BA02 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 9.02e-01
C04 N03 N04 3.32e-12
L04 N03 N04 1.63e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 5.89e-12
L05 N04 Port2 8.29e-12
R05 N04 Port2 1.03e+01
.ENDS GXM1555C2AR30BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR40BA02
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR40BA02 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 8.82e-01
C04 N03 N04 2.48e-12
L04 N03 N04 1.97e-11
R04 N03 N04 1.23e+01
C05 N04 Port2 8.97e-13
L05 N04 Port2 5.42e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR40BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR50BA02
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR50BA02 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.53e-10
R03 N02 N03 8.63e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.42e-11
R04 N03 N04 7.03e+00
C05 N04 Port2 6.63e-13
L05 N04 Port2 7.29e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR50BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR60BA02
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR60BA02 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.42e-10
R03 N02 N03 8.41e-01
C04 N03 N04 1.50e-12
L04 N03 N04 3.42e-11
R04 N03 N04 1.69e+01
C05 N04 Port2 6.12e-13
L05 N04 Port2 7.90e-11
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR60BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR70BA02
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR70BA02 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.97e-10
R03 N02 N03 8.04e-01
C04 N03 N04 1.02e-12
L04 N03 N04 5.01e-11
R04 N03 N04 3.19e+01
C05 N04 Port2 4.05e-13
L05 N04 Port2 1.09e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR70BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR80BA02
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR80BA02 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-10
R03 N02 N03 7.64e-01
C04 N03 N04 1.34e-12
L04 N03 N04 4.41e-11
R04 N03 N04 3.17e+01
C05 N04 Port2 4.34e-13
L05 N04 Port2 1.07e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR80BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/100[V]
* Murata P/N :GXM1555C2AR90BA02
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1555C2AR90BA02 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 7.43e-01
C04 N03 N04 1.11e-12
L04 N03 N04 5.44e-11
R04 N03 N04 4.04e+01
C05 N04 Port2 4.92e-13
L05 N04 Port2 1.01e-10
R05 N04 Port2 1.00e+08
.ENDS GXM1555C2AR90BA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/1.20e-03[uF]/10[V]
* Murata P/N :GXM1557U1A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A122JA02 Port1 Port2
C01 Port1 N01 1.23e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 2.41e-02
L04 N03 N04 5.33e-11
R04 N03 N04 6.17e-01
L05 N04 N05 7.03e-11
R05 N04 N05 2.87e-02
C06 N05 N06 1.64e-08
L06 N05 N06 5.54e-12
R06 N05 N06 7.77e-02
C07 N06 N07 1.90e-09
L07 N06 N07 2.02e-11
R07 N06 N07 3.05e-01
C08 N07 Port2 2.99e-12
L08 N07 Port2 9.53e-11
R08 N07 Port2 2.45e+01
.ENDS GXM1557U1A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/1.50e-03[uF]/10[V]
* Murata P/N :GXM1557U1A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A152JA02 Port1 Port2
C01 Port1 N01 1.47e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 2.24e-02
L04 N03 N04 5.67e-11
R04 N03 N04 6.78e-01
L05 N04 N05 7.41e-11
R05 N04 N05 3.87e-02
C06 N05 N06 1.77e-08
L06 N05 N06 6.57e-12
R06 N05 N06 8.97e-02
C07 N06 N07 2.60e-09
L07 N06 N07 1.97e-11
R07 N06 N07 2.79e-01
C08 N07 Port2 3.95e-12
L08 N07 Port2 7.57e-11
R08 N07 Port2 3.53e+01
.ENDS GXM1557U1A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/1.80e-03[uF]/10[V]
* Murata P/N :GXM1557U1A182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 1.12e-02
L04 N03 N04 6.07e-11
R04 N03 N04 4.28e-01
L05 N04 N05 5.27e-11
R05 N04 N05 2.29e-02
L06 N05 N06 1.00e-10
R06 N05 N06 6.06e-03
C07 N06 N07 2.17e-08
L07 N06 N07 6.67e-12
R07 N06 N07 1.19e-01
C08 N07 N08 3.15e-09
L08 N07 N08 2.08e-11
R08 N07 N08 2.87e-01
C09 N08 Port2 7.33e-12
L09 N08 Port2 3.98e-11
R09 N08 Port2 1.83e+01
.ENDS GXM1557U1A182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/2.20e-03[uF]/10[V]
* Murata P/N :GXM1557U1A222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A222JA02 Port1 Port2
C01 Port1 N01 2.22e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 2.09e-02
L04 N03 N04 7.81e-11
R04 N03 N04 1.89e-01
L05 N04 N05 4.48e-11
R05 N04 N05 6.19e-03
C06 N05 N06 4.82e-07
L06 N05 N06 3.62e-13
R06 N05 N06 3.05e-02
C07 N06 N07 4.58e-09
L07 N06 N07 1.56e-11
R07 N06 N07 1.60e-01
C08 N07 N08 1.10e-11
L08 N07 N08 2.70e-11
R08 N07 N08 7.73e-01
C09 N08 Port2 1.75e-12
L09 N08 Port2 1.26e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1557U1A222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/2.70e-03[uF]/10[V]
* Murata P/N :GXM1557U1A272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A272JA02 Port1 Port2
C01 Port1 N01 2.61e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.76e-10
R03 N02 N03 1.55e-02
L04 N03 N04 5.48e-11
R04 N03 N04 3.48e-01
L05 N04 N05 2.98e-11
R05 N04 N05 3.38e-02
L06 N05 N06 5.98e-11
R06 N05 N06 1.38e-02
C07 N06 N07 3.89e-08
L07 N06 N07 5.71e-12
R07 N06 N07 5.30e-02
C08 N07 N08 4.41e-09
L08 N07 N08 2.39e-11
R08 N07 N08 2.15e-01
C09 N08 Port2 8.76e-12
L09 N08 Port2 3.29e-11
R09 N08 Port2 6.97e+00
.ENDS GXM1557U1A272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/3.30e-03[uF]/10[V]
* Murata P/N :GXM1557U1A332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A332JA02 Port1 Port2
C01 Port1 N01 3.22e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.34e-02
L04 N03 N04 7.26e-11
R04 N03 N04 3.50e-01
L05 N04 N05 7.97e-11
R05 N04 N05 1.75e-02
C06 N05 N06 5.89e-08
L06 N05 N06 4.72e-12
R06 N05 N06 6.54e-02
C07 N06 N07 5.66e-09
L07 N06 N07 2.35e-11
R07 N06 N07 2.28e-01
C08 N07 Port2 6.27e-12
L08 N07 Port2 4.91e-11
R08 N07 Port2 2.11e+01
.ENDS GXM1557U1A332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/3.90e-03[uF]/10[V]
* Murata P/N :GXM1557U1A392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A392JA02 Port1 Port2
C01 Port1 N01 3.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.34e-10
R03 N02 N03 1.34e-02
L04 N03 N04 7.51e-11
R04 N03 N04 3.01e-01
L05 N04 N05 7.35e-11
R05 N04 N05 1.99e-02
C06 N05 N06 4.98e-08
L06 N05 N06 7.05e-12
R06 N05 N06 7.76e-02
C07 N06 N07 9.14e-09
L07 N06 N07 1.82e-11
R07 N06 N07 1.81e-01
C08 N07 Port2 9.97e-12
L08 N07 Port2 3.06e-11
R08 N07 Port2 1.06e+01
.ENDS GXM1557U1A392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/U2J(-55to125[deg])/4.70e-03[uF]/10[V]
* Murata P/N :GXM1557U1A472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1557U1A472JA02 Port1 Port2
C01 Port1 N01 4.69e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 1.02e-02
L04 N03 N04 9.05e-11
R04 N03 N04 3.06e-01
L05 N04 N05 6.77e-11
R05 N04 N05 1.44e-02
C06 N05 N06 4.81e-08
L06 N05 N06 9.53e-12
R06 N05 N06 9.35e-02
C07 N06 N07 1.09e-08
L07 N06 N07 2.01e-11
R07 N06 N07 1.69e-01
C08 N07 Port2 4.53e-12
L08 N07 Port2 5.78e-11
R08 N07 Port2 2.07e+01
.ENDS GXM1557U1A472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXM1882C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1882C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM1882C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GXM1882C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM1882C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1882C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM1882C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1882C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM1882C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H182JA02 Port1 Port2
C01 Port1 N01 1.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.05e-02
L04 N03 N04 5.19e-11
R04 N03 N04 2.29e-02
C05 N04 N05 1.64e-08
L05 N04 N05 1.29e-11
R05 N04 N05 1.80e-01
C06 N05 N06 3.02e-09
L06 N05 N06 2.50e-11
R06 N05 N06 3.70e-01
C07 N06 N07 8.34e-10
L07 N06 N07 2.40e-11
R07 N06 N07 2.24e-01
C08 N07 N08 8.66e-12
L08 N07 N08 4.55e-11
R08 N07 N08 8.81e-01
C09 N08 Port2 9.61e-13
L09 N08 Port2 2.31e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1882C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM1882C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H222JA02 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.20e-10
R03 N02 N03 1.62e-02
L04 N03 N04 4.87e-11
R04 N03 N04 5.51e-01
L05 N04 N05 7.26e-11
R05 N04 N05 2.02e-02
C06 N05 N06 1.76e-08
L06 N05 N06 1.51e-11
R06 N05 N06 1.94e-01
C07 N06 N07 3.11e-09
L07 N06 N07 3.33e-11
R07 N06 N07 4.17e-01
C08 N07 N08 1.80e-09
L08 N07 N08 1.85e-11
R08 N07 N08 2.06e-01
C09 N08 N09 7.70e-12
L09 N08 N09 3.27e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 3.82e-12
L10 N09 Port2 4.88e-11
R10 N09 Port2 4.39e+01
.ENDS GXM1882C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXM1882C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXM1882C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM1882C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H272JA02 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.10e-10
R03 N02 N03 8.85e-03
L04 N03 N04 6.97e-11
R04 N03 N04 3.95e-01
L05 N04 N05 5.39e-11
R05 N04 N05 1.70e-02
L06 N05 N06 1.10e-10
R06 N05 N06 5.60e-03
C07 N06 N07 2.25e-08
L07 N06 N07 1.50e-11
R07 N06 N07 2.27e-01
C08 N07 N08 4.93e-09
L08 N07 N08 3.05e-11
R08 N07 N08 3.76e-01
C09 N08 N09 5.43e-09
L09 N08 N09 9.13e-12
R09 N08 N09 1.31e-01
C10 N09 Port2 3.95e-12
L10 N09 Port2 8.52e-11
R10 N09 Port2 3.84e+01
.ENDS GXM1882C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXM1882C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1882C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM1882C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H332JA02 Port1 Port2
C01 Port1 N01 3.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.30e-02
L04 N03 N04 6.85e-11
R04 N03 N04 3.59e-01
L05 N04 N05 5.87e-11
R05 N04 N05 9.32e-03
C06 N05 N06 1.87e-08
L06 N05 N06 2.12e-11
R06 N05 N06 2.45e-01
C07 N06 N07 4.92e-09
L07 N06 N07 3.73e-11
R07 N06 N07 4.02e-01
C08 N07 N08 4.77e-09
L08 N07 N08 1.37e-11
R08 N07 N08 1.46e-01
C09 N08 N09 3.76e-11
L09 N08 N09 9.32e-12
R09 N08 N09 1.98e+00
C10 N09 Port2 4.05e-12
L10 N09 Port2 6.98e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1882C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXM1882C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXM1882C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM1882C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H392JA02 Port1 Port2
C01 Port1 N01 3.84e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 7.60e-03
L04 N03 N04 1.02e-10
R04 N03 N04 3.69e-01
L05 N04 N05 5.34e-11
R05 N04 N05 1.33e-02
L06 N05 N06 1.38e-10
R06 N05 N06 5.29e-03
C07 N06 N07 2.13e-08
L07 N06 N07 2.39e-11
R07 N06 N07 3.03e-01
C08 N07 N08 8.43e-09
L08 N07 N08 2.82e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 1.70e-11
L09 N08 Port2 2.15e-11
R09 N08 Port2 5.93e+00
.ENDS GXM1882C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXM1882C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM1882C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GXM1882C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXM1882C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXM1882C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM1882C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GXM1882C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXM1882C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM1882C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GXM1882C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXM1882C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXM1882C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM1882C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C1H822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GXM1882C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GXM1882C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1882C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GXM1882C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GXM1882C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GXM1882C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 1.02e-02
L04 N03 N04 5.61e-11
R04 N03 N04 5.09e-01
L05 N04 N05 6.27e-11
R05 N04 N05 2.60e-02
L06 N05 N06 1.55e-10
R06 N05 N06 1.01e-02
C07 N06 N07 1.30e-08
L07 N06 N07 9.93e-12
R07 N06 N07 1.52e-01
C08 N07 N08 1.95e-09
L08 N07 N08 2.77e-11
R08 N07 N08 4.83e-01
C09 N08 N09 3.31e-12
L09 N08 N09 1.00e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 6.28e-12
L10 N09 Port2 4.44e-11
R10 N09 Port2 9.95e+00
.ENDS GXM1882C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GXM1882C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GXM1882C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1882C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GXM1882C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GXM1882C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GXM1882C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GXM1882C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXM1882C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GXM1882C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1882C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GXM1882C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXM1882C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GXM1882C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GXM1882C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXM1882C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GXM1882C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1882C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/CH(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GXM1882C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1882C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXM1882C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.20e-02[uF]/10[V]
* Murata P/N :GXM1883U1A123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1A123JA02 Port1 Port2
C01 Port1 N01 1.17e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.56e-10
R03 N02 N03 1.09e-02
L04 N03 N04 7.89e-11
R04 N03 N04 2.27e-01
L05 N04 N05 1.03e-10
R05 N04 N05 1.31e-02
C06 N05 N06 8.91e-08
L06 N05 N06 1.54e-11
R06 N05 N06 6.50e-02
C07 N06 N07 1.99e-08
L07 N06 N07 2.99e-11
R07 N06 N07 1.59e-01
C08 N07 Port2 4.01e-12
L08 N07 Port2 7.30e-11
R08 N07 Port2 2.34e+01
.ENDS GXM1883U1A123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.50e-02[uF]/10[V]
* Murata P/N :GXM1883U1A153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1A153JA02 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 7.67e-03
L04 N03 N04 1.84e-11
R04 N03 N04 7.42e-01
L05 N04 N05 9.61e-11
R05 N04 N05 1.85e-01
L06 N05 N06 7.35e-11
R06 N05 N06 7.94e-03
C07 N06 N07 8.17e-08
L07 N06 N07 2.24e-11
R07 N06 N07 7.49e-02
C08 N07 N08 2.54e-08
L08 N07 N08 3.30e-11
R08 N07 N08 1.38e-01
C09 N08 N09 4.75e-08
L09 N08 N09 6.29e-12
R09 N08 N09 4.34e-02
C10 N09 N10 1.19e-11
L10 N09 N10 1.99e-11
R10 N09 N10 2.13e+00
C11 N10 Port2 5.23e-13
L11 N10 Port2 3.48e-10
R11 N10 Port2 1.00e+05
.ENDS GXM1883U1A153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.80e-02[uF]/10[V]
* Murata P/N :GXM1883U1A183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1A183JA02 Port1 Port2
C01 Port1 N01 1.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.44e-10
R03 N02 N03 9.60e-03
L04 N03 N04 9.59e-11
R04 N03 N04 1.72e-01
L05 N04 N05 6.83e-11
R05 N04 N05 7.87e-03
C06 N05 N06 1.23e-07
L06 N05 N06 1.90e-11
R06 N05 N06 6.74e-02
C07 N06 N07 2.58e-08
L07 N06 N07 4.09e-11
R07 N06 N07 1.38e-01
C08 N07 Port2 2.82e-12
L08 N07 Port2 9.92e-11
R08 N07 Port2 3.93e+01
.ENDS GXM1883U1A183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/2.20e-02[uF]/10[V]
* Murata P/N :GXM1883U1A223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1A223JA02 Port1 Port2
C01 Port1 N01 2.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-11
R03 N02 N03 6.68e-03
L04 N03 N04 1.32e-11
R04 N03 N04 3.32e-01
L05 N04 N05 9.71e-11
R05 N04 N05 1.88e-01
L06 N05 N06 6.77e-11
R06 N05 N06 4.64e-03
C07 N06 N07 9.21e-08
L07 N06 N07 3.33e-11
R07 N06 N07 8.98e-02
C08 N07 N08 3.53e-08
L08 N07 N08 4.41e-11
R08 N07 N08 1.41e-01
C09 N08 N09 1.89e-08
L09 N08 N09 2.73e-11
R09 N08 N09 7.19e-02
C10 N09 N10 4.75e-11
L10 N09 N10 7.37e-12
R10 N09 N10 9.90e-01
C11 N10 Port2 7.13e-13
L11 N10 Port2 2.70e-10
R11 N10 Port2 1.00e+05
.ENDS GXM1883U1A223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXM1883U1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H102JA02 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.61e-10
R03 N02 N03 2.80e-02
L04 N03 N04 6.78e-11
R04 N03 N04 5.54e-01
L05 N04 N05 7.83e-11
R05 N04 N05 3.13e-02
C06 N05 N06 1.50e-08
L06 N05 N06 8.50e-12
R06 N05 N06 1.40e-01
C07 N06 N07 2.08e-09
L07 N06 N07 2.71e-11
R07 N06 N07 4.46e-01
C08 N07 Port2 2.63e-12
L08 N07 Port2 1.27e-10
R08 N07 Port2 6.31e+01
.ENDS GXM1883U1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM1883U1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H103JA02 Port1 Port2
C01 Port1 N01 9.98e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 1.06e-02
L04 N03 N04 5.89e-11
R04 N03 N04 2.47e-01
L05 N04 N05 5.27e-11
R05 N04 N05 9.27e-03
C06 N05 N06 6.01e-08
L06 N05 N06 2.19e-11
R06 N05 N06 1.08e-01
C07 N06 N07 1.94e-08
L07 N06 N07 3.25e-11
R07 N06 N07 1.88e-01
C08 N07 N08 7.48e-09
L08 N07 N08 2.88e-11
R08 N07 N08 9.91e-02
C09 N08 N09 1.33e-11
L09 N08 N09 2.54e-11
R09 N08 N09 4.78e+00
C10 N09 Port2 2.57e-12
L10 N09 Port2 1.15e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1883U1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM1883U1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H122JA02 Port1 Port2
C01 Port1 N01 1.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 2.77e-02
L04 N03 N04 7.47e-11
R04 N03 N04 7.07e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.96e-02
C06 N05 N06 1.14e-08
L06 N05 N06 1.35e-11
R06 N05 N06 1.51e-01
C07 N06 N07 1.92e-09
L07 N06 N07 3.43e-11
R07 N06 N07 4.20e-01
C08 N07 Port2 1.07e-12
L08 N07 Port2 3.37e-10
R08 N07 Port2 8.18e+02
.ENDS GXM1883U1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM1883U1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H152JA02 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.13e-02
L04 N03 N04 8.79e-11
R04 N03 N04 5.89e-01
L05 N04 N05 8.17e-11
R05 N04 N05 1.85e-02
C06 N05 N06 1.45e-08
L06 N05 N06 1.44e-11
R06 N05 N06 2.37e-01
C07 N06 N07 2.92e-09
L07 N06 N07 3.30e-11
R07 N06 N07 4.41e-01
C08 N07 Port2 2.80e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 3.66e+01
.ENDS GXM1883U1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM1883U1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H182JA02 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.66e-02
L04 N03 N04 6.15e-11
R04 N03 N04 3.04e-01
L05 N04 N05 7.88e-11
R05 N04 N05 3.55e-02
L06 N05 N06 3.23e-11
R06 N05 N06 1.74e-03
C07 N06 N07 2.70e-09
L07 N06 N07 3.02e-11
R07 N06 N07 2.29e-01
C08 N07 Port2 8.22e-13
L08 N07 Port2 4.07e-10
R08 N07 Port2 1.84e+02
.ENDS GXM1883U1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM1883U1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H222JA02 Port1 Port2
C01 Port1 N01 2.21e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 3.39e-02
L04 N03 N04 8.09e-11
R04 N03 N04 6.21e-01
L05 N04 N05 8.04e-11
R05 N04 N05 4.09e-02
C06 N05 N06 4.42e-08
L06 N05 N06 5.46e-12
R06 N05 N06 4.31e-02
C07 N06 N07 3.76e-09
L07 N06 N07 2.88e-11
R07 N06 N07 2.29e-01
C08 N07 Port2 9.93e-13
L08 N07 Port2 3.28e-10
R08 N07 Port2 2.19e+02
.ENDS GXM1883U1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM1883U1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H272JA02 Port1 Port2
C01 Port1 N01 2.64e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 2.21e-02
L04 N03 N04 7.42e-11
R04 N03 N04 3.50e-01
L05 N04 N05 9.18e-11
R05 N04 N05 2.75e-02
C06 N05 N06 8.21e-08
L06 N05 N06 4.08e-12
R06 N05 N06 3.82e-02
C07 N06 N07 4.52e-09
L07 N06 N07 3.29e-11
R07 N06 N07 2.36e-01
C08 N07 Port2 2.15e-12
L08 N07 Port2 1.66e-10
R08 N07 Port2 1.03e+02
.ENDS GXM1883U1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM1883U1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H332JA02 Port1 Port2
C01 Port1 N01 3.27e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 2.39e-02
L04 N03 N04 7.94e-11
R04 N03 N04 3.80e-01
L05 N04 N05 6.78e-11
R05 N04 N05 2.64e-02
C06 N05 N06 6.89e-08
L06 N05 N06 6.34e-12
R06 N05 N06 4.57e-02
C07 N06 N07 5.73e-09
L07 N06 N07 3.48e-11
R07 N06 N07 2.08e-01
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.93e-10
R08 N07 Port2 1.81e+02
.ENDS GXM1883U1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM1883U1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H392JA02 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 1.68e-02
L04 N03 N04 8.97e-11
R04 N03 N04 3.04e-01
L05 N04 N05 7.70e-11
R05 N04 N05 2.05e-02
C06 N05 N06 5.43e-08
L06 N05 N06 1.00e-11
R06 N05 N06 5.87e-02
C07 N06 N07 6.72e-09
L07 N06 N07 3.56e-11
R07 N06 N07 2.15e-01
C08 N07 Port2 5.30e-13
L08 N07 Port2 3.03e-10
R08 N07 Port2 1.18e+02
.ENDS GXM1883U1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM1883U1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H472JA02 Port1 Port2
C01 Port1 N01 4.61e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 1.57e-02
L04 N03 N04 1.11e-10
R04 N03 N04 3.01e-01
L05 N04 N05 1.23e-10
R05 N04 N05 1.10e-02
C06 N05 N06 7.09e-08
L06 N05 N06 9.87e-12
R06 N05 N06 7.18e-02
C07 N06 N07 9.41e-09
L07 N06 N07 3.50e-11
R07 N06 N07 2.07e-01
C08 N07 Port2 6.48e-12
L08 N07 Port2 5.09e-11
R08 N07 Port2 7.11e+00
.ENDS GXM1883U1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM1883U1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H562JA02 Port1 Port2
C01 Port1 N01 5.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.46e-10
R03 N02 N03 1.34e-02
L04 N03 N04 1.07e-10
R04 N03 N04 2.49e-01
L05 N04 N05 4.67e-12
R05 N04 N05 8.54e-02
L06 N05 N06 7.53e-11
R06 N05 N06 1.32e-02
C07 N06 N07 6.61e-08
L07 N06 N07 1.26e-11
R07 N06 N07 8.34e-02
C08 N07 N08 1.36e-08
L08 N07 N08 2.96e-11
R08 N07 N08 1.93e-01
C09 N08 Port2 4.80e-12
L09 N08 Port2 5.29e-11
R09 N08 Port2 1.86e+01
.ENDS GXM1883U1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM1883U1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H682JA02 Port1 Port2
C01 Port1 N01 6.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.62e-11
R03 N02 N03 1.36e-02
L04 N03 N04 6.83e-11
R04 N03 N04 3.01e-01
L05 N04 N05 5.92e-11
R05 N04 N05 9.79e-03
C06 N05 N06 4.62e-08
L06 N05 N06 1.74e-11
R06 N05 N06 7.98e-02
C07 N06 N07 1.14e-08
L07 N06 N07 3.14e-11
R07 N06 N07 1.75e-01
C08 N07 N08 6.81e-09
L08 N07 N08 1.47e-11
R08 N07 N08 6.66e-02
C09 N08 N09 6.37e-12
L09 N08 N09 4.76e-11
R09 N08 N09 2.17e+01
C10 N09 Port2 9.47e-13
L10 N09 Port2 2.81e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1883U1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/UJ(-25to85[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM1883U1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1883U1H822JA02 Port1 Port2
C01 Port1 N01 8.35e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.47e-11
R03 N02 N03 1.14e-02
L04 N03 N04 7.54e-11
R04 N03 N04 2.80e-01
L05 N04 N05 5.26e-11
R05 N04 N05 1.27e-02
C06 N05 N06 4.49e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.01e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.16e-11
R07 N06 N07 1.79e-01
C08 N07 N08 9.81e-09
L08 N07 N08 1.51e-11
R08 N07 N08 6.55e-02
C09 N08 N09 2.46e-12
L09 N08 N09 1.24e-10
R09 N08 N09 1.41e+02
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1883U1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GXM1885C1H102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1885C1H102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM1885C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H103JA02 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.93e-10
R03 N02 N03 6.09e-03
L04 N03 N04 8.60e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.41e-11
R05 N04 N05 9.50e-03
C06 N05 N06 4.12e-08
L06 N05 N06 3.13e-11
R06 N05 N06 1.80e-01
C07 N06 N07 1.79e-08
L07 N06 N07 3.21e-11
R07 N06 N07 2.25e-01
C08 N07 N08 8.43e-08
L08 N07 N08 3.51e-12
R08 N07 N08 3.48e-02
C09 N08 N09 2.68e-08
L09 N08 N09 7.14e-12
R09 N08 N09 8.20e-02
C10 N09 Port2 8.68e-12
L10 N09 Port2 2.83e-11
R10 N09 Port2 1.97e+00
.ENDS GXM1885C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM1885C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.18e-10
R03 N02 N03 1.29e-02
L04 N03 N04 2.07e-11
R04 N03 N04 1.15e+00
L05 N04 N05 5.37e-11
R05 N04 N05 3.95e-01
L06 N05 N06 6.27e-11
R06 N05 N06 2.48e-02
L07 N06 N07 2.83e-10
R07 N06 N07 8.21e-03
C08 N07 N08 1.31e-08
L08 N07 N08 9.66e-12
R08 N07 N08 1.84e-01
C09 N08 N09 2.12e-09
L09 N08 N09 2.36e-11
R09 N08 N09 4.78e-01
C10 N09 Port2 1.38e-11
L10 N09 Port2 2.41e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1885C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM1885C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1885C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM1885C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H182JA02 Port1 Port2
C01 Port1 N01 1.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.05e-02
L04 N03 N04 5.19e-11
R04 N03 N04 2.29e-02
C05 N04 N05 1.64e-08
L05 N04 N05 1.29e-11
R05 N04 N05 1.80e-01
C06 N05 N06 3.02e-09
L06 N05 N06 2.50e-11
R06 N05 N06 3.70e-01
C07 N06 N07 8.34e-10
L07 N06 N07 2.40e-11
R07 N06 N07 2.24e-01
C08 N07 N08 8.66e-12
L08 N07 N08 4.55e-11
R08 N07 N08 8.81e-01
C09 N08 Port2 9.61e-13
L09 N08 Port2 2.31e-10
R09 N08 Port2 1.00e+05
.ENDS GXM1885C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM1885C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H222JA02 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.20e-10
R03 N02 N03 1.62e-02
L04 N03 N04 4.87e-11
R04 N03 N04 5.51e-01
L05 N04 N05 7.26e-11
R05 N04 N05 2.02e-02
C06 N05 N06 1.76e-08
L06 N05 N06 1.51e-11
R06 N05 N06 1.94e-01
C07 N06 N07 3.11e-09
L07 N06 N07 3.33e-11
R07 N06 N07 4.17e-01
C08 N07 N08 1.80e-09
L08 N07 N08 1.85e-11
R08 N07 N08 2.06e-01
C09 N08 N09 7.70e-12
L09 N08 N09 3.27e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 3.82e-12
L10 N09 Port2 4.88e-11
R10 N09 Port2 4.39e+01
.ENDS GXM1885C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/50[V]
* Murata P/N :GXM1885C1H271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXM1885C1H271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM1885C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H272JA02 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.10e-10
R03 N02 N03 8.85e-03
L04 N03 N04 6.97e-11
R04 N03 N04 3.95e-01
L05 N04 N05 5.39e-11
R05 N04 N05 1.70e-02
L06 N05 N06 1.10e-10
R06 N05 N06 5.60e-03
C07 N06 N07 2.25e-08
L07 N06 N07 1.50e-11
R07 N06 N07 2.27e-01
C08 N07 N08 4.93e-09
L08 N07 N08 3.05e-11
R08 N07 N08 3.76e-01
C09 N08 N09 5.43e-09
L09 N08 N09 9.13e-12
R09 N08 N09 1.31e-01
C10 N09 Port2 3.95e-12
L10 N09 Port2 8.52e-11
R10 N09 Port2 3.84e+01
.ENDS GXM1885C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GXM1885C1H331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1885C1H331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM1885C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H332JA02 Port1 Port2
C01 Port1 N01 3.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-10
R03 N02 N03 1.30e-02
L04 N03 N04 6.85e-11
R04 N03 N04 3.59e-01
L05 N04 N05 5.87e-11
R05 N04 N05 9.32e-03
C06 N05 N06 1.87e-08
L06 N05 N06 2.12e-11
R06 N05 N06 2.45e-01
C07 N06 N07 4.92e-09
L07 N06 N07 3.73e-11
R07 N06 N07 4.02e-01
C08 N07 N08 4.77e-09
L08 N07 N08 1.37e-11
R08 N07 N08 1.46e-01
C09 N08 N09 3.76e-11
L09 N08 N09 9.32e-12
R09 N08 N09 1.98e+00
C10 N09 Port2 4.05e-12
L10 N09 Port2 6.98e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1885C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/50[V]
* Murata P/N :GXM1885C1H391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXM1885C1H391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM1885C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H392JA02 Port1 Port2
C01 Port1 N01 3.84e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.17e-10
R03 N02 N03 7.60e-03
L04 N03 N04 1.02e-10
R04 N03 N04 3.69e-01
L05 N04 N05 5.34e-11
R05 N04 N05 1.33e-02
L06 N05 N06 1.38e-10
R06 N05 N06 5.29e-03
C07 N06 N07 2.13e-08
L07 N06 N07 2.39e-11
R07 N06 N07 3.03e-01
C08 N07 N08 8.43e-09
L08 N07 N08 2.82e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 1.70e-11
L09 N08 Port2 2.15e-11
R09 N08 Port2 5.93e+00
.ENDS GXM1885C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GXM1885C1H471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C1H471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM1885C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.25e-10
R03 N02 N03 9.02e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.85e-01
L05 N04 N05 6.79e-11
R05 N04 N05 2.12e-02
L06 N05 N06 4.07e-11
R06 N05 N06 2.49e-03
C07 N06 N07 3.81e-08
L07 N06 N07 1.27e-11
R07 N06 N07 1.01e-01
C08 N07 N08 6.37e-09
L08 N07 N08 3.15e-11
R08 N07 N08 2.81e-01
C09 N08 N09 3.37e-09
L09 N08 N09 1.74e-11
R09 N08 N09 1.33e-01
C10 N09 Port2 7.47e-12
L10 N09 Port2 3.27e-11
R10 N09 Port2 2.25e+00
.ENDS GXM1885C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GXM1885C1H561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXM1885C1H561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM1885C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H562JA02 Port1 Port2
C01 Port1 N01 5.59e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-10
R03 N02 N03 8.39e-03
L04 N03 N04 5.44e-11
R04 N03 N04 3.36e-01
L05 N04 N05 5.85e-11
R05 N04 N05 1.80e-02
L06 N05 N06 4.01e-11
R06 N05 N06 1.79e-03
C07 N06 N07 3.19e-08
L07 N06 N07 1.97e-11
R07 N06 N07 1.38e-01
C08 N07 N08 8.61e-09
L08 N07 N08 3.12e-11
R08 N07 N08 2.75e-01
C09 N08 N09 5.28e-09
L09 N08 N09 1.52e-11
R09 N08 N09 1.16e-01
C10 N09 Port2 8.30e-12
L10 N09 Port2 4.75e-11
R10 N09 Port2 1.46e+01
.ENDS GXM1885C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GXM1885C1H681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C1H681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM1885C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H682JA02 Port1 Port2
C01 Port1 N01 6.59e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 7.63e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.04e-01
L05 N04 N05 8.19e-11
R05 N04 N05 1.36e-02
C06 N05 N06 3.12e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.54e-01
C07 N06 N07 1.19e-08
L07 N06 N07 2.84e-11
R07 N06 N07 2.60e-01
C08 N07 N08 4.99e-09
L08 N07 N08 2.06e-11
R08 N07 N08 1.24e-01
C09 N08 Port2 7.37e-12
L09 N08 Port2 2.85e-11
R09 N08 Port2 3.96e+00
.ENDS GXM1885C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/50[V]
* Murata P/N :GXM1885C1H821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXM1885C1H821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM1885C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C1H822JA02 Port1 Port2
C01 Port1 N01 8.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.74e-10
R03 N02 N03 6.54e-03
L04 N03 N04 7.66e-11
R04 N03 N04 2.10e-01
L05 N04 N05 7.04e-11
R05 N04 N05 1.06e-02
L06 N05 N06 8.76e-11
R06 N05 N06 2.11e-03
C07 N06 N07 3.69e-08
L07 N06 N07 2.84e-11
R07 N06 N07 1.61e-01
C08 N07 N08 1.57e-08
L08 N07 N08 2.98e-11
R08 N07 N08 2.30e-01
C09 N08 N09 8.88e-08
L09 N08 N09 2.56e-12
R09 N08 N09 3.29e-02
C10 N09 N10 1.57e-08
L10 N09 N10 9.34e-12
R10 N09 N10 8.42e-02
C11 N10 Port2 2.54e-12
L11 N10 Port2 8.47e-11
R11 N10 Port2 1.78e+01
.ENDS GXM1885C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GXM1885C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A102JA02 Port1 Port2
C01 Port1 N01 9.96e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.66e-10
R03 N02 N03 2.04e-02
L04 N03 N04 7.39e-11
R04 N03 N04 9.12e-01
L05 N04 N05 6.18e-11
R05 N04 N05 2.05e-02
C06 N05 N06 6.37e-09
L06 N05 N06 2.29e-11
R06 N05 N06 6.39e-01
C07 N06 N07 2.12e-09
L07 N06 N07 2.67e-11
R07 N06 N07 6.54e-01
C08 N07 N08 6.92e-10
L08 N07 N08 2.57e-11
R08 N07 N08 2.82e-01
C09 N08 Port2 6.16e-12
L09 N08 Port2 4.05e-11
R09 N08 Port2 1.00e+05
.ENDS GXM1885C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GXM1885C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 1.20e-01
L04 N03 N04 1.12e-10
R04 N03 N04 6.06e+00
C05 N04 N05 6.69e-13
L05 N04 N05 4.16e-10
C06 N05 N06 1.00e-11
L06 N05 N06 3.95e-11
R06 N05 N06 6.08e+00
C07 N06 N07 1.48e-10
L07 N06 N07 2.85e-11
R07 N06 N07 1.42e+00
C08 N07 Port2 1.31e-09
L08 N07 Port2 8.61e-12
R08 N07 Port2 3.36e-01
.ENDS GXM1885C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GXM1885C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A122JA02 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.12e-10
R03 N02 N03 1.02e-02
L04 N03 N04 5.61e-11
R04 N03 N04 5.09e-01
L05 N04 N05 6.27e-11
R05 N04 N05 2.60e-02
L06 N05 N06 1.55e-10
R06 N05 N06 1.01e-02
C07 N06 N07 1.30e-08
L07 N06 N07 9.93e-12
R07 N06 N07 1.52e-01
C08 N07 N08 1.95e-09
L08 N07 N08 2.77e-11
R08 N07 N08 4.83e-01
C09 N08 N09 3.31e-12
L09 N08 N09 1.00e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 6.28e-12
L10 N09 Port2 4.44e-11
R10 N09 Port2 9.95e+00
.ENDS GXM1885C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GXM1885C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.38e-10
R03 N02 N03 9.51e-02
L04 N03 N04 8.52e-11
R04 N03 N04 1.91e+00
C05 N04 N05 1.89e-09
L05 N04 N05 7.91e-12
R05 N04 N05 3.65e-01
C06 N05 N06 3.06e-10
L06 N05 N06 1.89e-11
R06 N05 N06 9.91e-01
C07 N06 N07 3.22e-11
L07 N06 N07 1.25e-11
R07 N06 N07 2.47e+00
C08 N07 Port2 2.01e-12
L08 N07 Port2 1.24e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GXM1885C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A152JA02 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.28e-10
R03 N02 N03 1.95e-02
L04 N03 N04 5.10e-11
R04 N03 N04 3.37e-01
L05 N04 N05 8.61e-11
R05 N04 N05 1.57e-02
C06 N05 N06 1.06e-08
L06 N05 N06 1.74e-11
R06 N05 N06 2.75e-01
C07 N06 N07 2.42e-09
L07 N06 N07 3.35e-11
R07 N06 N07 4.45e-01
C08 N07 N08 1.63e-09
L08 N07 N08 1.54e-11
R08 N07 N08 1.92e-01
C09 N08 N09 1.08e-11
L09 N08 N09 2.49e-11
R09 N08 N09 4.67e-01
C10 N09 Port2 3.12e-12
L10 N09 Port2 7.45e-11
R10 N09 Port2 1.00e+05
.ENDS GXM1885C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GXM1885C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 1.23e-10
R04 N03 N04 4.65e+00
C05 N04 N05 8.18e-13
L05 N04 N05 3.29e-10
C06 N05 N06 3.18e-11
L06 N05 N06 1.25e-11
R06 N05 N06 2.34e+00
C07 N06 N07 2.70e-10
L07 N06 N07 2.90e-11
R07 N06 N07 1.32e+00
C08 N07 Port2 1.23e-09
L08 N07 Port2 1.56e-11
R08 N07 Port2 6.19e-01
.ENDS GXM1885C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GXM1885C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 9.54e-02
C04 N03 N04 1.61e-09
L04 N03 N04 1.26e-11
R04 N03 N04 2.90e-01
C05 N04 N05 2.00e-10
L05 N04 N05 3.59e-11
R05 N04 N05 1.08e+00
C06 N05 N06 1.70e-10
L06 N05 N06 1.32e-11
R06 N05 N06 6.94e-01
C07 N06 N07 2.02e-11
L07 N06 N07 2.44e-11
R07 N06 N07 1.40e+00
C08 N07 Port2 6.59e-13
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GXM1885C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-12
R03 N02 N03 9.00e-02
L04 N03 N04 1.05e-10
R04 N03 N04 4.95e+00
C05 N04 N05 6.55e-13
L05 N04 N05 4.29e-10
C06 N05 N06 1.61e-11
L06 N05 N06 2.46e-11
R06 N05 N06 4.61e+00
C07 N06 N07 8.15e-10
L07 N06 N07 3.52e-12
R07 N06 N07 2.44e-01
C08 N07 N08 2.92e-10
L08 N07 N08 3.61e-11
R08 N07 N08 9.13e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 8.60e-12
R09 N08 Port2 3.11e-01
.ENDS GXM1885C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GXM1885C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 8.20e-02
L04 N03 N04 9.01e-11
R04 N03 N04 1.74e+00
C05 N04 N05 4.34e-09
L05 N04 N05 8.35e-12
R05 N04 N05 2.51e-01
C06 N05 N06 5.72e-10
L06 N05 N06 2.59e-11
R06 N05 N06 8.66e-01
C07 N06 Port2 5.47e-13
L07 N06 Port2 3.45e-10
R07 N06 Port2 1.00e+05
.ENDS GXM1885C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GXM1885C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-11
R03 N02 N03 6.00e-02
L04 N03 N04 5.49e-11
R04 N03 N04 7.60e-01
C05 N04 N05 9.78e-13
L05 N04 N05 3.85e-10
R05 N04 N05 3.20e+02
C06 N05 N06 7.59e-10
L06 N05 N06 7.13e-12
R06 N05 N06 2.62e-01
C07 N06 N07 6.22e-10
L07 N06 N07 2.83e-11
R07 N06 N07 7.43e-01
C08 N07 Port2 2.69e-09
L08 N07 Port2 1.92e-11
R08 N07 Port2 5.71e-01
.ENDS GXM1885C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GXM1885C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 5.50e-02
L04 N03 N04 6.06e-11
R04 N03 N04 1.87e+00
C05 N04 N05 2.50e-09
L05 N04 N05 2.56e-11
R05 N04 N05 5.99e-01
C06 N05 N06 7.46e-10
L06 N05 N06 2.87e-11
R06 N05 N06 7.83e-01
C07 N06 N07 3.90e-10
L07 N06 N07 1.57e-11
R07 N06 N07 3.56e-01
C08 N07 Port2 1.28e-12
L08 N07 Port2 1.71e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GXM1885C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 4.50e-02
L04 N03 N04 5.41e-11
R04 N03 N04 1.36e+00
C05 N04 N05 1.46e-12
L05 N04 N05 1.93e-10
C06 N05 N06 2.63e-12
L06 N05 N06 1.33e-10
R06 N05 N06 9.90e+01
C07 N06 N07 4.85e-10
L07 N06 N07 1.81e-11
R07 N06 N07 4.15e-01
C08 N07 N08 8.98e-10
L08 N07 N08 3.00e-11
R08 N07 N08 7.57e-01
C09 N08 Port2 3.07e-09
L09 N08 Port2 2.41e-11
R09 N08 Port2 7.18e-01
.ENDS GXM1885C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GXM1885C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 5.00e-02
L04 N03 N04 2.04e-11
R04 N03 N04 9.21e-01
L05 N04 N05 8.36e-11
R05 N04 N05 5.86e-01
C06 N05 N06 6.32e-09
L06 N05 N06 1.49e-11
R06 N05 N06 3.90e-01
C07 N06 N07 1.61e-09
L07 N06 N07 1.92e-11
R07 N06 N07 5.32e-01
C08 N07 Port2 7.45e-13
L08 N07 Port2 2.57e-10
R08 N07 Port2 1.00e+05
.ENDS GXM1885C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GXM1885C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1885C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 3.50e-02
L04 N03 N04 7.89e-11
R04 N03 N04 6.61e-01
C05 N04 N05 9.23e-13
L05 N04 N05 3.05e-10
C06 N05 N06 5.86e-12
L06 N05 N06 5.98e-11
R06 N05 N06 1.27e+01
C07 N06 N07 1.66e-09
L07 N06 N07 7.78e-12
R07 N06 N07 2.21e-01
C08 N07 N08 1.55e-09
L08 N07 N08 2.55e-11
R08 N07 N08 6.06e-01
C09 N08 Port2 4.93e-09
L09 N08 Port2 2.23e-11
R09 N08 Port2 5.20e-01
.ENDS GXM1885C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.20e-02[uF]/10[V]
* Murata P/N :GXM1887U1A123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1A123JA02 Port1 Port2
C01 Port1 N01 1.17e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.56e-10
R03 N02 N03 1.09e-02
L04 N03 N04 7.89e-11
R04 N03 N04 2.27e-01
L05 N04 N05 1.03e-10
R05 N04 N05 1.31e-02
C06 N05 N06 8.91e-08
L06 N05 N06 1.54e-11
R06 N05 N06 6.50e-02
C07 N06 N07 1.99e-08
L07 N06 N07 2.99e-11
R07 N06 N07 1.59e-01
C08 N07 Port2 4.01e-12
L08 N07 Port2 7.30e-11
R08 N07 Port2 2.34e+01
.ENDS GXM1887U1A123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.50e-02[uF]/10[V]
* Murata P/N :GXM1887U1A153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1A153JA02 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 7.67e-03
L04 N03 N04 1.84e-11
R04 N03 N04 7.42e-01
L05 N04 N05 9.61e-11
R05 N04 N05 1.85e-01
L06 N05 N06 7.35e-11
R06 N05 N06 7.94e-03
C07 N06 N07 8.17e-08
L07 N06 N07 2.24e-11
R07 N06 N07 7.49e-02
C08 N07 N08 2.54e-08
L08 N07 N08 3.30e-11
R08 N07 N08 1.38e-01
C09 N08 N09 4.75e-08
L09 N08 N09 6.29e-12
R09 N08 N09 4.34e-02
C10 N09 N10 1.19e-11
L10 N09 N10 1.99e-11
R10 N09 N10 2.13e+00
C11 N10 Port2 5.23e-13
L11 N10 Port2 3.48e-10
R11 N10 Port2 1.00e+05
.ENDS GXM1887U1A153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.80e-02[uF]/10[V]
* Murata P/N :GXM1887U1A183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1A183JA02 Port1 Port2
C01 Port1 N01 1.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.44e-10
R03 N02 N03 9.60e-03
L04 N03 N04 9.59e-11
R04 N03 N04 1.72e-01
L05 N04 N05 6.83e-11
R05 N04 N05 7.87e-03
C06 N05 N06 1.23e-07
L06 N05 N06 1.90e-11
R06 N05 N06 6.74e-02
C07 N06 N07 2.58e-08
L07 N06 N07 4.09e-11
R07 N06 N07 1.38e-01
C08 N07 Port2 2.82e-12
L08 N07 Port2 9.92e-11
R08 N07 Port2 3.93e+01
.ENDS GXM1887U1A183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/2.20e-02[uF]/10[V]
* Murata P/N :GXM1887U1A223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1A223JA02 Port1 Port2
C01 Port1 N01 2.28e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.35e-11
R03 N02 N03 6.68e-03
L04 N03 N04 1.32e-11
R04 N03 N04 3.32e-01
L05 N04 N05 9.71e-11
R05 N04 N05 1.88e-01
L06 N05 N06 6.77e-11
R06 N05 N06 4.64e-03
C07 N06 N07 9.21e-08
L07 N06 N07 3.33e-11
R07 N06 N07 8.98e-02
C08 N07 N08 3.53e-08
L08 N07 N08 4.41e-11
R08 N07 N08 1.41e-01
C09 N08 N09 1.89e-08
L09 N08 N09 2.73e-11
R09 N08 N09 7.19e-02
C10 N09 N10 4.75e-11
L10 N09 N10 7.37e-12
R10 N09 N10 9.90e-01
C11 N10 Port2 7.13e-13
L11 N10 Port2 2.70e-10
R11 N10 Port2 1.00e+05
.ENDS GXM1887U1A223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM1887U1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H103JA02 Port1 Port2
C01 Port1 N01 9.98e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 1.06e-02
L04 N03 N04 5.89e-11
R04 N03 N04 2.47e-01
L05 N04 N05 5.27e-11
R05 N04 N05 9.27e-03
C06 N05 N06 6.01e-08
L06 N05 N06 2.19e-11
R06 N05 N06 1.08e-01
C07 N06 N07 1.94e-08
L07 N06 N07 3.25e-11
R07 N06 N07 1.88e-01
C08 N07 N08 7.48e-09
L08 N07 N08 2.88e-11
R08 N07 N08 9.91e-02
C09 N08 N09 1.33e-11
L09 N08 N09 2.54e-11
R09 N08 N09 4.78e+00
C10 N09 Port2 2.57e-12
L10 N09 Port2 1.15e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1887U1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM1887U1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H122JA02 Port1 Port2
C01 Port1 N01 1.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 2.77e-02
L04 N03 N04 7.47e-11
R04 N03 N04 7.07e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.96e-02
C06 N05 N06 1.14e-08
L06 N05 N06 1.35e-11
R06 N05 N06 1.51e-01
C07 N06 N07 1.92e-09
L07 N06 N07 3.43e-11
R07 N06 N07 4.20e-01
C08 N07 Port2 1.07e-12
L08 N07 Port2 3.37e-10
R08 N07 Port2 8.18e+02
.ENDS GXM1887U1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM1887U1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H152JA02 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.13e-02
L04 N03 N04 8.79e-11
R04 N03 N04 5.89e-01
L05 N04 N05 8.17e-11
R05 N04 N05 1.85e-02
C06 N05 N06 1.45e-08
L06 N05 N06 1.44e-11
R06 N05 N06 2.37e-01
C07 N06 N07 2.92e-09
L07 N06 N07 3.30e-11
R07 N06 N07 4.41e-01
C08 N07 Port2 2.80e-12
L08 N07 Port2 1.15e-10
R08 N07 Port2 3.66e+01
.ENDS GXM1887U1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM1887U1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H182JA02 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.66e-02
L04 N03 N04 6.15e-11
R04 N03 N04 3.04e-01
L05 N04 N05 7.88e-11
R05 N04 N05 3.55e-02
L06 N05 N06 3.23e-11
R06 N05 N06 1.74e-03
C07 N06 N07 2.70e-09
L07 N06 N07 3.02e-11
R07 N06 N07 2.29e-01
C08 N07 Port2 8.22e-13
L08 N07 Port2 4.07e-10
R08 N07 Port2 1.84e+02
.ENDS GXM1887U1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM1887U1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H222JA02 Port1 Port2
C01 Port1 N01 2.21e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.19e-10
R03 N02 N03 3.39e-02
L04 N03 N04 8.09e-11
R04 N03 N04 6.21e-01
L05 N04 N05 8.04e-11
R05 N04 N05 4.09e-02
C06 N05 N06 4.42e-08
L06 N05 N06 5.46e-12
R06 N05 N06 4.31e-02
C07 N06 N07 3.76e-09
L07 N06 N07 2.88e-11
R07 N06 N07 2.29e-01
C08 N07 Port2 9.93e-13
L08 N07 Port2 3.28e-10
R08 N07 Port2 2.19e+02
.ENDS GXM1887U1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM1887U1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H272JA02 Port1 Port2
C01 Port1 N01 2.64e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.67e-10
R03 N02 N03 2.21e-02
L04 N03 N04 7.42e-11
R04 N03 N04 3.50e-01
L05 N04 N05 9.18e-11
R05 N04 N05 2.75e-02
C06 N05 N06 8.21e-08
L06 N05 N06 4.08e-12
R06 N05 N06 3.82e-02
C07 N06 N07 4.52e-09
L07 N06 N07 3.29e-11
R07 N06 N07 2.36e-01
C08 N07 Port2 2.15e-12
L08 N07 Port2 1.66e-10
R08 N07 Port2 1.03e+02
.ENDS GXM1887U1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM1887U1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H332JA02 Port1 Port2
C01 Port1 N01 3.27e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 2.39e-02
L04 N03 N04 7.94e-11
R04 N03 N04 3.80e-01
L05 N04 N05 6.78e-11
R05 N04 N05 2.64e-02
C06 N05 N06 6.89e-08
L06 N05 N06 6.34e-12
R06 N05 N06 4.57e-02
C07 N06 N07 5.73e-09
L07 N06 N07 3.48e-11
R07 N06 N07 2.08e-01
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.93e-10
R08 N07 Port2 1.81e+02
.ENDS GXM1887U1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM1887U1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H392JA02 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.78e-10
R03 N02 N03 1.68e-02
L04 N03 N04 8.97e-11
R04 N03 N04 3.04e-01
L05 N04 N05 7.70e-11
R05 N04 N05 2.05e-02
C06 N05 N06 5.43e-08
L06 N05 N06 1.00e-11
R06 N05 N06 5.87e-02
C07 N06 N07 6.72e-09
L07 N06 N07 3.56e-11
R07 N06 N07 2.15e-01
C08 N07 Port2 5.30e-13
L08 N07 Port2 3.03e-10
R08 N07 Port2 1.18e+02
.ENDS GXM1887U1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM1887U1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H472JA02 Port1 Port2
C01 Port1 N01 4.61e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.01e-10
R03 N02 N03 1.57e-02
L04 N03 N04 1.11e-10
R04 N03 N04 3.01e-01
L05 N04 N05 1.23e-10
R05 N04 N05 1.10e-02
C06 N05 N06 7.09e-08
L06 N05 N06 9.87e-12
R06 N05 N06 7.18e-02
C07 N06 N07 9.41e-09
L07 N06 N07 3.50e-11
R07 N06 N07 2.07e-01
C08 N07 Port2 6.48e-12
L08 N07 Port2 5.09e-11
R08 N07 Port2 7.11e+00
.ENDS GXM1887U1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM1887U1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H562JA02 Port1 Port2
C01 Port1 N01 5.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.46e-10
R03 N02 N03 1.34e-02
L04 N03 N04 1.07e-10
R04 N03 N04 2.49e-01
L05 N04 N05 4.67e-12
R05 N04 N05 8.54e-02
L06 N05 N06 7.53e-11
R06 N05 N06 1.32e-02
C07 N06 N07 6.61e-08
L07 N06 N07 1.26e-11
R07 N06 N07 8.34e-02
C08 N07 N08 1.36e-08
L08 N07 N08 2.96e-11
R08 N07 N08 1.93e-01
C09 N08 Port2 4.80e-12
L09 N08 Port2 5.29e-11
R09 N08 Port2 1.86e+01
.ENDS GXM1887U1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM1887U1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H682JA02 Port1 Port2
C01 Port1 N01 6.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.62e-11
R03 N02 N03 1.36e-02
L04 N03 N04 6.83e-11
R04 N03 N04 3.01e-01
L05 N04 N05 5.92e-11
R05 N04 N05 9.79e-03
C06 N05 N06 4.62e-08
L06 N05 N06 1.74e-11
R06 N05 N06 7.98e-02
C07 N06 N07 1.14e-08
L07 N06 N07 3.14e-11
R07 N06 N07 1.75e-01
C08 N07 N08 6.81e-09
L08 N07 N08 1.47e-11
R08 N07 N08 6.66e-02
C09 N08 N09 6.37e-12
L09 N08 N09 4.76e-11
R09 N08 N09 2.17e+01
C10 N09 Port2 9.47e-13
L10 N09 Port2 2.81e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1887U1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/U2J(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM1887U1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM1887U1H822JA02 Port1 Port2
C01 Port1 N01 8.35e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.47e-11
R03 N02 N03 1.14e-02
L04 N03 N04 7.54e-11
R04 N03 N04 2.80e-01
L05 N04 N05 5.26e-11
R05 N04 N05 1.27e-02
C06 N05 N06 4.49e-08
L06 N05 N06 2.40e-11
R06 N05 N06 1.01e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.16e-11
R07 N06 N07 1.79e-01
C08 N07 N08 9.81e-09
L08 N07 N08 1.51e-11
R08 N07 N08 6.55e-02
C09 N08 N09 2.46e-12
L09 N08 N09 1.24e-10
R09 N08 N09 1.41e+02
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GXM1887U1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM2162C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H122JA02 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GXM2162C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM2162C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H152JA02 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2162C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM2162C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2162C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM2162C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H222JA02 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GXM2162C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM2162C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H272JA02 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GXM2162C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM2162C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H332JA02 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2162C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM2162C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H392JA02 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2162C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM2162C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2162C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GXM2162C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A102JA02 Port1 Port2
C01 Port1 N01 9.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-11
R03 N02 N03 2.28e-02
C04 N03 N04 1.24e-08
L04 N03 N04 8.80e-11
R04 N03 N04 2.65e-02
C05 N04 N05 3.72e-09
L05 N04 N05 1.32e-11
R05 N04 N05 1.37e-01
C06 N05 N06 5.49e-10
L06 N05 N06 2.53e-11
R06 N05 N06 3.34e-01
C07 N06 N07 4.72e-12
L07 N06 N07 5.28e-11
R07 N06 N07 8.20e-01
C08 N07 Port2 5.35e-13
L08 N07 Port2 4.19e-10
R08 N07 Port2 9.12e+04
.ENDS GXM2162C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GXM2162C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.76e-11
R03 N02 N03 9.81e-02
L04 N03 N04 1.09e-11
R04 N03 N04 7.43e-02
C05 N04 N05 4.44e-10
L05 N04 N05 1.55e-11
R05 N04 N05 1.04e+00
C06 N05 N06 9.74e-11
L06 N05 N06 2.16e-11
R06 N05 N06 1.95e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 2.93e-10
R07 N06 Port2 2.42e+02
.ENDS GXM2162C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GXM2162C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A122JA02 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GXM2162C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GXM2162C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 9.34e-02
C04 N03 N04 4.52e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.70e-01
C05 N04 N05 1.13e-10
L05 N04 N05 2.46e-11
R05 N04 N05 1.75e+00
C06 N05 N06 1.22e-11
L06 N05 N06 3.85e-11
R06 N05 N06 2.18e+00
C07 N06 Port2 1.09e-12
L07 N06 Port2 2.07e-10
R07 N06 Port2 1.00e+05
.ENDS GXM2162C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GXM2162C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A152JA02 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2162C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GXM2162C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.45e-11
R03 N02 N03 9.25e-02
L04 N03 N04 9.25e-11
R04 N03 N04 1.34e+01
C05 N04 N05 7.21e-10
L05 N04 N05 1.42e-11
R05 N04 N05 6.75e-01
C06 N05 N06 1.49e-10
L06 N05 N06 2.12e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.71e-12
L07 N06 Port2 2.75e-10
R07 N06 Port2 3.15e+02
.ENDS GXM2162C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GXM2162C2A182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2162C2A182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GXM2162C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-11
R03 N02 N03 7.72e-02
C04 N03 N04 5.84e-10
L04 N03 N04 2.45e-11
R04 N03 N04 8.99e-01
C05 N04 N05 1.71e-10
L05 N04 N05 2.79e-11
R05 N04 N05 1.59e+00
C06 N05 N06 3.45e-10
L06 N05 N06 5.95e-12
R06 N05 N06 3.77e-01
C07 N06 N07 7.62e-11
L07 N06 N07 1.40e-11
R07 N06 N07 1.10e+00
C08 N07 N08 2.81e-11
L08 N07 N08 1.64e-11
R08 N07 N08 2.02e+00
C09 N08 Port2 5.26e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2162C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GXM2162C2A222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A222JA02 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GXM2162C2A222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GXM2162C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.08e-11
R03 N02 N03 6.90e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.90e+00
C05 N04 N05 1.04e-09
L05 N04 N05 1.98e-11
R05 N04 N05 9.94e-01
C06 N05 N06 3.04e-10
L06 N05 N06 2.35e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.29e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 3.39e+02
.ENDS GXM2162C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GXM2162C2A272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A272JA02 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GXM2162C2A272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GXM2162C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2162C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GXM2162C2A332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A332JA02 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2162C2A332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GXM2162C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 5.29e-02
L04 N03 N04 3.19e-11
R04 N03 N04 7.68e-01
L05 N04 N05 2.05e-11
R05 N04 N05 3.64e-02
C06 N05 N06 1.61e-09
L06 N05 N06 1.07e-11
R06 N05 N06 2.17e-01
C07 N06 N07 3.53e-10
L07 N06 N07 1.38e-11
R07 N06 N07 5.29e-01
C08 N07 Port2 1.46e-12
L08 N07 Port2 3.23e-10
R08 N07 Port2 3.47e+02
.ENDS GXM2162C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GXM2162C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2162C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GXM2162C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 3.60e-02
L04 N03 N04 3.08e-11
R04 N03 N04 5.35e-01
L05 N04 N05 2.97e-11
R05 N04 N05 2.78e-02
C06 N05 N06 2.77e-09
L06 N05 N06 1.17e-11
R06 N05 N06 2.63e-01
C07 N06 N07 3.93e-10
L07 N06 N07 2.60e-11
R07 N06 N07 5.46e-01
C08 N07 Port2 1.38e-12
L08 N07 Port2 3.17e-10
R08 N07 Port2 3.25e+02
.ENDS GXM2162C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GXM2162C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 4.50e-02
L04 N03 N04 6.53e-11
R04 N03 N04 1.49e+00
C05 N04 N05 2.07e-09
L05 N04 N05 2.24e-11
R05 N04 N05 4.17e-01
C06 N05 N06 5.37e-10
L06 N05 N06 2.75e-11
R06 N05 N06 6.67e-01
C07 N06 Port2 3.56e-12
L07 N06 Port2 7.25e-11
R07 N06 Port2 1.00e+05
.ENDS GXM2162C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GXM2162C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2162C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.73e-11
R03 N02 N03 3.39e-02
L04 N03 N04 4.55e-11
R04 N03 N04 5.50e-01
L05 N04 N05 1.26e-11
R05 N04 N05 2.01e-02
C06 N05 N06 3.69e-09
L06 N05 N06 1.61e-11
R06 N05 N06 4.31e-01
C07 N06 N07 6.49e-10
L07 N06 N07 3.03e-11
R07 N06 N07 6.62e-01
C08 N07 Port2 1.32e-12
L08 N07 Port2 3.27e-10
R08 N07 Port2 3.61e+02
.ENDS GXM2162C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM2163U1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2163U1H103JA02 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.31e-11
R03 N02 N03 9.69e-03
L04 N03 N04 1.29e-11
R04 N03 N04 3.14e-01
L05 N04 N05 9.42e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.07e-10
R06 N05 N06 6.62e-03
C07 N06 N07 4.56e-08
L07 N06 N07 1.58e-11
R07 N06 N07 8.43e-02
C08 N07 N08 1.13e-08
L08 N07 N08 2.21e-11
R08 N07 N08 1.30e-01
C09 N08 N09 9.87e-12
L09 N08 N09 3.55e-11
R09 N08 N09 9.87e+00
C10 N09 Port2 1.16e-12
L10 N09 Port2 2.58e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2163U1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GXM2163U1H123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2163U1H123JA02 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.18e-03
L04 N03 N04 1.80e-11
R04 N03 N04 5.01e-01
L05 N04 N05 9.37e-11
R05 N04 N05 2.17e-01
L06 N05 N06 1.74e-10
R06 N05 N06 6.02e-03
C07 N06 N07 4.57e-08
L07 N06 N07 2.20e-11
R07 N06 N07 1.01e-01
C08 N07 N08 1.24e-08
L08 N07 N08 2.73e-11
R08 N07 N08 1.60e-01
C09 N08 N09 4.63e-12
L09 N08 N09 7.58e-11
R09 N08 N09 3.34e+01
C10 N09 Port2 1.19e-12
L10 N09 Port2 2.72e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2163U1H123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GXM2163U1H153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2163U1H153JA02 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.24e-03
L04 N03 N04 1.81e-11
R04 N03 N04 6.80e-01
L05 N04 N05 1.25e-10
R05 N04 N05 1.79e-01
L06 N05 N06 9.53e-11
R06 N05 N06 4.86e-03
C07 N06 N07 5.23e-08
L07 N06 N07 2.56e-11
R07 N06 N07 1.01e-01
C08 N07 N08 2.17e-08
L08 N07 N08 2.23e-11
R08 N07 N08 1.50e-01
C09 N08 N09 2.43e-11
L09 N08 N09 1.45e-11
R09 N08 N09 6.36e+00
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2163U1H153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GXM2163U1H183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2163U1H183JA02 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-12
R03 N02 N03 8.28e-03
L04 N03 N04 2.32e-11
R04 N03 N04 5.84e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.99e-01
L06 N05 N06 6.34e-11
R06 N05 N06 4.50e-03
C07 N06 N07 7.53e-08
L07 N06 N07 2.28e-11
R07 N06 N07 8.68e-02
C08 N07 N08 2.35e-08
L08 N07 N08 2.91e-11
R08 N07 N08 1.30e-01
C09 N08 N09 2.49e-11
L09 N08 N09 1.17e-11
R09 N08 N09 3.83e+00
C10 N09 Port2 8.86e-13
L10 N09 Port2 2.68e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2163U1H183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GXM2165C1H122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H122JA02 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GXM2165C1H122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GXM2165C1H152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H152JA02 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2165C1H152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GXM2165C1H182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2165C1H182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GXM2165C1H222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H222JA02 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GXM2165C1H222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GXM2165C1H272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H272JA02 Port1 Port2
C01 Port1 N01 2.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-13
R03 N02 N03 8.94e-03
L04 N03 N04 1.46e-11
R04 N03 N04 6.66e-01
L05 N04 N05 8.75e-11
R05 N04 N05 4.83e-01
L06 N05 N06 7.88e-11
R06 N05 N06 1.84e-02
C07 N06 N07 1.00e-08
L07 N06 N07 2.90e-11
R07 N06 N07 2.84e-01
C08 N07 N08 2.55e-09
L08 N07 N08 4.52e-11
R08 N07 N08 5.75e-01
C09 N08 N09 2.85e-09
L09 N08 N09 1.27e-11
R09 N08 N09 1.31e-01
C10 N09 N10 3.65e-11
L10 N09 N10 9.60e-12
R10 N09 N10 4.23e+00
C11 N10 Port2 7.76e-13
L11 N10 Port2 3.59e-10
R11 N10 Port2 1.00e+05
.ENDS GXM2165C1H272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GXM2165C1H332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H332JA02 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2165C1H332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GXM2165C1H392JA02
* Property : C = 3.90e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H392JA02 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2165C1H392JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GXM2165C1H472JA02
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C1H472JA02 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2165C1H472JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GXM2165C2A102JA02
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A102JA02 Port1 Port2
C01 Port1 N01 9.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-11
R03 N02 N03 2.28e-02
C04 N03 N04 1.24e-08
L04 N03 N04 8.80e-11
R04 N03 N04 2.65e-02
C05 N04 N05 3.72e-09
L05 N04 N05 1.32e-11
R05 N04 N05 1.37e-01
C06 N05 N06 5.49e-10
L06 N05 N06 2.53e-11
R06 N05 N06 3.34e-01
C07 N06 N07 4.72e-12
L07 N06 N07 5.28e-11
R07 N06 N07 8.20e-01
C08 N07 Port2 5.35e-13
L08 N07 Port2 4.19e-10
R08 N07 Port2 9.12e+04
.ENDS GXM2165C2A102JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GXM2165C2A121JA02
* Property : C = 1.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A121JA02 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.76e-11
R03 N02 N03 9.81e-02
L04 N03 N04 1.09e-11
R04 N03 N04 7.43e-02
C05 N04 N05 4.44e-10
L05 N04 N05 1.55e-11
R05 N04 N05 1.04e+00
C06 N05 N06 9.74e-11
L06 N05 N06 2.16e-11
R06 N05 N06 1.95e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 2.93e-10
R07 N06 Port2 2.42e+02
.ENDS GXM2165C2A121JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GXM2165C2A122JA02
* Property : C = 1.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A122JA02 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GXM2165C2A122JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GXM2165C2A151JA02
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A151JA02 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 9.34e-02
C04 N03 N04 4.52e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.70e-01
C05 N04 N05 1.13e-10
L05 N04 N05 2.46e-11
R05 N04 N05 1.75e+00
C06 N05 N06 1.22e-11
L06 N05 N06 3.85e-11
R06 N05 N06 2.18e+00
C07 N06 Port2 1.09e-12
L07 N06 Port2 2.07e-10
R07 N06 Port2 1.00e+05
.ENDS GXM2165C2A151JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GXM2165C2A152JA02
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A152JA02 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2165C2A152JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GXM2165C2A181JA02
* Property : C = 1.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A181JA02 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.45e-11
R03 N02 N03 9.25e-02
L04 N03 N04 9.25e-11
R04 N03 N04 1.34e+01
C05 N04 N05 7.21e-10
L05 N04 N05 1.42e-11
R05 N04 N05 6.75e-01
C06 N05 N06 1.49e-10
L06 N05 N06 2.12e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.71e-12
L07 N06 Port2 2.75e-10
R07 N06 Port2 3.15e+02
.ENDS GXM2165C2A181JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GXM2165C2A182JA02
* Property : C = 1.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A182JA02 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2165C2A182JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GXM2165C2A221JA02
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A221JA02 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-11
R03 N02 N03 7.72e-02
C04 N03 N04 5.84e-10
L04 N03 N04 2.45e-11
R04 N03 N04 8.99e-01
C05 N04 N05 1.71e-10
L05 N04 N05 2.79e-11
R05 N04 N05 1.59e+00
C06 N05 N06 3.45e-10
L06 N05 N06 5.95e-12
R06 N05 N06 3.77e-01
C07 N06 N07 7.62e-11
L07 N06 N07 1.40e-11
R07 N06 N07 1.10e+00
C08 N07 N08 2.81e-11
L08 N07 N08 1.64e-11
R08 N07 N08 2.02e+00
C09 N08 Port2 5.26e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2165C2A221JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GXM2165C2A222JA02
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A222JA02 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GXM2165C2A222JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GXM2165C2A271JA02
* Property : C = 2.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A271JA02 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.08e-11
R03 N02 N03 6.90e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.90e+00
C05 N04 N05 1.04e-09
L05 N04 N05 1.98e-11
R05 N04 N05 9.94e-01
C06 N05 N06 3.04e-10
L06 N05 N06 2.35e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.29e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 3.39e+02
.ENDS GXM2165C2A271JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GXM2165C2A272JA02
* Property : C = 2.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A272JA02 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GXM2165C2A272JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GXM2165C2A331JA02
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A331JA02 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GXM2165C2A331JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GXM2165C2A332JA02
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A332JA02 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2165C2A332JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GXM2165C2A391JA02
* Property : C = 3.90e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A391JA02 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 5.29e-02
L04 N03 N04 3.19e-11
R04 N03 N04 7.68e-01
L05 N04 N05 2.05e-11
R05 N04 N05 3.64e-02
C06 N05 N06 1.61e-09
L06 N05 N06 1.07e-11
R06 N05 N06 2.17e-01
C07 N06 N07 3.53e-10
L07 N06 N07 1.38e-11
R07 N06 N07 5.29e-01
C08 N07 Port2 1.46e-12
L08 N07 Port2 3.23e-10
R08 N07 Port2 3.47e+02
.ENDS GXM2165C2A391JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GXM2165C2A471JA02
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A471JA02 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GXM2165C2A471JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GXM2165C2A561JA02
* Property : C = 5.60e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A561JA02 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 3.60e-02
L04 N03 N04 3.08e-11
R04 N03 N04 5.35e-01
L05 N04 N05 2.97e-11
R05 N04 N05 2.78e-02
C06 N05 N06 2.77e-09
L06 N05 N06 1.17e-11
R06 N05 N06 2.63e-01
C07 N06 N07 3.93e-10
L07 N06 N07 2.60e-11
R07 N06 N07 5.46e-01
C08 N07 Port2 1.38e-12
L08 N07 Port2 3.17e-10
R08 N07 Port2 3.25e+02
.ENDS GXM2165C2A561JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GXM2165C2A681JA02
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A681JA02 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 4.50e-02
L04 N03 N04 6.53e-11
R04 N03 N04 1.49e+00
C05 N04 N05 2.07e-09
L05 N04 N05 2.24e-11
R05 N04 N05 4.17e-01
C06 N05 N06 5.37e-10
L06 N05 N06 2.75e-11
R06 N05 N06 6.67e-01
C07 N06 Port2 3.56e-12
L07 N06 Port2 7.25e-11
R07 N06 Port2 1.00e+05
.ENDS GXM2165C2A681JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GXM2165C2A821JA02
* Property : C = 8.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2165C2A821JA02 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.73e-11
R03 N02 N03 3.39e-02
L04 N03 N04 4.55e-11
R04 N03 N04 5.50e-01
L05 N04 N05 1.26e-11
R05 N04 N05 2.01e-02
C06 N05 N06 3.69e-09
L06 N05 N06 1.61e-11
R06 N05 N06 4.31e-01
C07 N06 N07 6.49e-10
L07 N06 N07 3.03e-11
R07 N06 N07 6.62e-01
C08 N07 Port2 1.32e-12
L08 N07 Port2 3.27e-10
R08 N07 Port2 3.61e+02
.ENDS GXM2165C2A821JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GXM2167U1H123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2167U1H123JA02 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.18e-03
L04 N03 N04 1.80e-11
R04 N03 N04 5.01e-01
L05 N04 N05 9.37e-11
R05 N04 N05 2.17e-01
L06 N05 N06 1.74e-10
R06 N05 N06 6.02e-03
C07 N06 N07 4.57e-08
L07 N06 N07 2.20e-11
R07 N06 N07 1.01e-01
C08 N07 N08 1.24e-08
L08 N07 N08 2.73e-11
R08 N07 N08 1.60e-01
C09 N08 N09 4.63e-12
L09 N08 N09 7.58e-11
R09 N08 N09 3.34e+01
C10 N09 Port2 1.19e-12
L10 N09 Port2 2.72e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2167U1H123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GXM2167U1H153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2167U1H153JA02 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.24e-03
L04 N03 N04 1.81e-11
R04 N03 N04 6.80e-01
L05 N04 N05 1.25e-10
R05 N04 N05 1.79e-01
L06 N05 N06 9.53e-11
R06 N05 N06 4.86e-03
C07 N06 N07 5.23e-08
L07 N06 N07 2.56e-11
R07 N06 N07 1.01e-01
C08 N07 N08 2.17e-08
L08 N07 N08 2.23e-11
R08 N07 N08 1.50e-01
C09 N08 N09 2.43e-11
L09 N08 N09 1.45e-11
R09 N08 N09 6.36e+00
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.12e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2167U1H153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GXM2167U1H183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2167U1H183JA02 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-12
R03 N02 N03 8.28e-03
L04 N03 N04 2.32e-11
R04 N03 N04 5.84e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.99e-01
L06 N05 N06 6.34e-11
R06 N05 N06 4.50e-03
C07 N06 N07 7.53e-08
L07 N06 N07 2.28e-11
R07 N06 N07 8.68e-02
C08 N07 N08 2.35e-08
L08 N07 N08 2.91e-11
R08 N07 N08 1.30e-01
C09 N08 N09 2.49e-11
L09 N08 N09 1.17e-11
R09 N08 N09 3.83e+00
C10 N09 Port2 8.86e-13
L10 N09 Port2 2.68e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2167U1H183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM2192C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H103JA02 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GXM2192C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GXM2192C1H123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H123JA02 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2192C1H123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GXM2192C1H153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H153JA02 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GXM2192C1H153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM2192C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H562JA02 Port1 Port2
C01 Port1 N01 5.54e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 6.08e-03
L04 N03 N04 1.80e-11
R04 N03 N04 7.53e-01
L05 N04 N05 8.50e-11
R05 N04 N05 2.64e-01
L06 N05 N06 1.04e-10
R06 N05 N06 1.16e-02
C07 N06 N07 2.35e-08
L07 N06 N07 2.79e-11
R07 N06 N07 3.06e-01
C08 N07 N08 8.88e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.04e-01
C09 N08 N09 8.22e-12
L09 N08 N09 4.00e-11
R09 N08 N09 1.43e+01
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2192C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM2192C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H682JA02 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2192C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM2192C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2192C1H822JA02 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GXM2192C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/5.60e-02[uF]/10[V]
* Murata P/N :GXM2193U1A563JA02
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2193U1A563JA02 Port1 Port2
C01 Port1 N01 5.52e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.27e-10
R03 N02 N03 4.73e-03
L04 N03 N04 1.59e-11
R04 N03 N04 1.60e-01
L05 N04 N05 1.14e-10
R05 N04 N05 1.07e-01
L06 N05 N06 7.29e-11
R06 N05 N06 2.76e-03
C07 N06 N07 2.18e-07
L07 N06 N07 3.45e-11
R07 N06 N07 9.08e-02
C08 N07 N08 6.67e-08
L08 N07 N08 4.96e-11
R08 N07 N08 1.20e-01
C09 N08 Port2 4.31e-12
L09 N08 Port2 7.80e-11
R09 N08 Port2 4.11e+01
.ENDS GXM2193U1A563JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GXM2193U1H223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2193U1H223JA02 Port1 Port2
C01 Port1 N01 2.10e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-12
R03 N02 N03 5.50e-03
L04 N03 N04 2.04e-11
R04 N03 N04 4.41e-01
L05 N04 N05 1.68e-10
R05 N04 N05 1.54e-01
L06 N05 N06 2.05e-10
R06 N05 N06 2.56e-03
C07 N06 N07 1.43e-07
L07 N06 N07 1.77e-11
R07 N06 N07 1.04e-01
C08 N07 N08 4.31e-08
L08 N07 N08 2.29e-11
R08 N07 N08 1.36e-01
C09 N08 N09 9.75e-12
L09 N08 N09 3.60e-11
R09 N08 N09 1.58e+01
C10 N09 Port2 1.02e-12
L10 N09 Port2 3.16e-10
R10 N09 Port2 7.29e+02
.ENDS GXM2193U1H223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GXM2193U1H273JA02
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2193U1H273JA02 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 5.64e-03
L04 N03 N04 3.55e-11
R04 N03 N04 2.02e+00
L05 N04 N05 6.94e-11
R05 N04 N05 1.68e-01
L06 N05 N06 9.97e-11
R06 N05 N06 5.48e-03
C07 N06 N07 1.20e-07
L07 N06 N07 2.72e-11
R07 N06 N07 1.07e-01
C08 N07 N08 3.37e-08
L08 N07 N08 4.25e-11
R08 N07 N08 1.39e-01
C09 N08 N09 1.20e-08
L09 N08 N09 3.62e-11
R09 N08 N09 7.56e-02
C10 N09 N10 2.65e-11
L10 N09 N10 1.32e-11
R10 N09 N10 5.83e+00
C11 N10 Port2 1.05e-12
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GXM2193U1H273JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GXM2195C1H103JA02
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H103JA02 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GXM2195C1H103JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GXM2195C1H123JA02
* Property : C = 1.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H123JA02 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2195C1H123JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GXM2195C1H153JA02
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H153JA02 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GXM2195C1H153JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GXM2195C1H562JA02
* Property : C = 5.60e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H562JA02 Port1 Port2
C01 Port1 N01 5.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 4.66e-03
L04 N03 N04 1.04e-10
R04 N03 N04 3.42e-01
L05 N04 N05 8.94e-11
R05 N04 N05 7.30e-03
L06 N05 N06 6.66e-11
R06 N05 N06 1.34e-03
C07 N06 N07 1.63e-08
L07 N06 N07 4.04e-11
R07 N06 N07 2.97e-01
C08 N07 N08 8.56e-09
L08 N07 N08 3.20e-11
R08 N07 N08 4.24e-01
C09 N08 N09 1.30e-08
L09 N08 N09 9.56e-12
R09 N08 N09 7.44e-02
C10 N09 N10 9.40e-09
L10 N09 N10 8.19e-12
R10 N09 N10 9.49e-02
C11 N10 N11 3.90e-11
L11 N10 N11 9.00e-12
R11 N10 N11 1.33e+00
C12 N11 Port2 6.65e-13
L12 N11 Port2 3.41e-10
R12 N11 Port2 1.00e+05
.ENDS GXM2195C1H562JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GXM2195C1H682JA02
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H682JA02 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GXM2195C1H682JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GXM2195C1H822JA02
* Property : C = 8.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2195C1H822JA02 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GXM2195C1H822JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/5.60e-02[uF]/10[V]
* Murata P/N :GXM2197U1A563JA02
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2197U1A563JA02 Port1 Port2
C01 Port1 N01 5.52e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.27e-10
R03 N02 N03 4.73e-03
L04 N03 N04 1.59e-11
R04 N03 N04 1.60e-01
L05 N04 N05 1.14e-10
R05 N04 N05 1.07e-01
L06 N05 N06 7.29e-11
R06 N05 N06 2.76e-03
C07 N06 N07 2.18e-07
L07 N06 N07 3.45e-11
R07 N06 N07 9.08e-02
C08 N07 N08 6.67e-08
L08 N07 N08 4.96e-11
R08 N07 N08 1.20e-01
C09 N08 Port2 4.31e-12
L09 N08 Port2 7.80e-11
R09 N08 Port2 4.11e+01
.ENDS GXM2197U1A563JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GXM2197U1H223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2197U1H223JA02 Port1 Port2
C01 Port1 N01 2.10e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-12
R03 N02 N03 5.50e-03
L04 N03 N04 2.04e-11
R04 N03 N04 4.41e-01
L05 N04 N05 1.68e-10
R05 N04 N05 1.54e-01
L06 N05 N06 2.05e-10
R06 N05 N06 2.56e-03
C07 N06 N07 1.43e-07
L07 N06 N07 1.77e-11
R07 N06 N07 1.04e-01
C08 N07 N08 4.31e-08
L08 N07 N08 2.29e-11
R08 N07 N08 1.36e-01
C09 N08 N09 9.75e-12
L09 N08 N09 3.60e-11
R09 N08 N09 1.58e+01
C10 N09 Port2 1.02e-12
L10 N09 Port2 3.16e-10
R10 N09 Port2 7.29e+02
.ENDS GXM2197U1H223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GXM2197U1H273JA02
* Property : C = 2.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM2197U1H273JA02 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 5.64e-03
L04 N03 N04 3.55e-11
R04 N03 N04 2.02e+00
L05 N04 N05 6.94e-11
R05 N04 N05 1.68e-01
L06 N05 N06 9.97e-11
R06 N05 N06 5.48e-03
C07 N06 N07 1.20e-07
L07 N06 N07 2.72e-11
R07 N06 N07 1.07e-01
C08 N07 N08 3.37e-08
L08 N07 N08 4.25e-11
R08 N07 N08 1.39e-01
C09 N08 N09 1.20e-08
L09 N08 N09 3.62e-11
R09 N08 N09 7.56e-02
C10 N09 N10 2.65e-11
L10 N09 N10 1.32e-11
R10 N09 N10 5.83e+00
C11 N10 Port2 1.05e-12
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GXM2197U1H273JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GXM21A3U1H333JA39
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21A3U1H333JA39 Port1 Port2
C01 Port1 N01 3.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 3.42e-03
L04 N03 N04 1.81e-11
R04 N03 N04 4.91e-01
L05 N04 N05 1.60e-10
R05 N04 N05 1.75e-01
L06 N05 N06 1.32e-10
R06 N05 N06 2.86e-03
C07 N06 N07 1.14e-07
L07 N06 N07 3.95e-11
R07 N06 N07 1.69e-01
C08 N07 N08 7.52e-08
L08 N07 N08 2.79e-11
R08 N07 N08 1.45e-01
C09 N08 N09 1.71e-07
L09 N08 N09 5.36e-12
R09 N08 N09 2.49e-02
C10 N09 N10 1.63e-07
L10 N09 N10 3.74e-12
R10 N09 N10 3.70e-02
C11 N10 N11 1.06e-11
L11 N10 N11 3.32e-11
R11 N10 N11 8.90e+00
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.53e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21A3U1H333JA39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GXM21A7U1H333JA39
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21A7U1H333JA39 Port1 Port2
C01 Port1 N01 3.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 3.42e-03
L04 N03 N04 1.81e-11
R04 N03 N04 4.91e-01
L05 N04 N05 1.60e-10
R05 N04 N05 1.75e-01
L06 N05 N06 1.32e-10
R06 N05 N06 2.86e-03
C07 N06 N07 1.14e-07
L07 N06 N07 3.95e-11
R07 N06 N07 1.69e-01
C08 N07 N08 7.52e-08
L08 N07 N08 2.79e-11
R08 N07 N08 1.45e-01
C09 N08 N09 1.71e-07
L09 N08 N09 5.36e-12
R09 N08 N09 2.49e-02
C10 N09 N10 1.63e-07
L10 N09 N10 3.74e-12
R10 N09 N10 3.70e-02
C11 N10 N11 1.06e-11
L11 N10 N11 3.32e-11
R11 N10 N11 8.90e+00
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.53e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21A7U1H333JA39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GXM21B2C1H183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B2C1H183JA02 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GXM21B2C1H183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GXM21B2C1H223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B2C1H223JA02 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GXM21B2C1H223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GXM21B3U1A104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B3U1A104JA02 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 9.31e-11
R03 N02 N03 3.94e-03
L04 N03 N04 1.84e-11
R04 N03 N04 3.47e-01
L05 N04 N05 1.46e-10
R05 N04 N05 1.08e-01
L06 N05 N06 7.38e-11
R06 N05 N06 2.13e-03
C07 N06 N07 2.06e-07
L07 N06 N07 7.67e-11
R07 N06 N07 1.24e-01
C08 N07 N08 1.71e-07
L08 N07 N08 4.21e-11
R08 N07 N08 8.67e-02
C09 N08 N09 1.96e-07
L09 N08 N09 1.83e-11
R09 N08 N09 3.80e-02
C10 N09 N10 2.62e-07
L10 N09 N10 8.77e-12
R10 N09 N10 3.22e-02
C11 N10 N11 3.65e-11
L11 N10 N11 9.59e-12
R11 N10 N11 1.31e+00
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21B3U1A104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GXM21B3U1A683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B3U1A683JA02 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.57e-11
R03 N02 N03 4.60e-03
L04 N03 N04 1.95e-11
R04 N03 N04 4.22e-01
L05 N04 N05 8.75e-11
R05 N04 N05 1.16e-01
L06 N05 N06 9.66e-11
R06 N05 N06 6.89e-03
C07 N06 N07 2.34e-07
L07 N06 N07 4.00e-11
R07 N06 N07 8.18e-02
C08 N07 N08 8.67e-08
L08 N07 N08 4.56e-11
R08 N07 N08 8.56e-02
C09 N08 N09 5.26e-08
L09 N08 N09 2.40e-11
R09 N08 N09 3.99e-02
C10 N09 N10 1.13e-11
L10 N09 N10 3.11e-11
R10 N09 N10 1.37e+01
C11 N10 Port2 9.00e-13
L11 N10 Port2 3.50e-10
R11 N10 Port2 1.00e+05
.ENDS GXM21B3U1A683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/8.20e-02[uF]/10[V]
* Murata P/N :GXM21B3U1A823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B3U1A823JA02 Port1 Port2
C01 Port1 N01 8.39e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.99e-10
R03 N02 N03 3.66e-03
L04 N03 N04 1.54e-10
R04 N03 N04 1.04e-01
L05 N04 N05 9.71e-11
R05 N04 N05 3.25e-03
C06 N05 N06 2.78e-07
L06 N05 N06 4.73e-11
R06 N05 N06 9.82e-02
C07 N06 N07 1.48e-07
L07 N06 N07 4.14e-11
R07 N06 N07 9.16e-02
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.50e-10
R08 N07 Port2 4.52e+01
.ENDS GXM21B3U1A823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GXM21B3U1H393JA02
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B3U1H393JA02 Port1 Port2
C01 Port1 N01 3.88e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 4.37e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.71e-01
L05 N04 N05 1.17e-10
R05 N04 N05 5.64e-03
C06 N05 N06 1.12e-07
L06 N05 N06 5.35e-11
R06 N05 N06 1.46e-01
C07 N06 N07 5.11e-08
L07 N06 N07 5.25e-11
R07 N06 N07 1.32e-01
C08 N07 N08 1.78e-07
L08 N07 N08 7.56e-12
R08 N07 N08 3.39e-02
C09 N08 N09 3.84e-08
L09 N08 N09 2.17e-11
R09 N08 N09 6.59e-02
C10 N09 Port2 1.59e-12
L10 N09 Port2 2.00e-10
R10 N09 Port2 4.31e+01
.ENDS GXM21B3U1H393JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GXM21B3U1H473JA02
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B3U1H473JA02 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 3.71e-03
L04 N03 N04 2.22e-11
R04 N03 N04 4.19e-01
L05 N04 N05 1.64e-10
R05 N04 N05 1.46e-01
L06 N05 N06 4.84e-11
R06 N05 N06 1.78e-03
C07 N06 N07 1.22e-07
L07 N06 N07 6.18e-11
R07 N06 N07 1.57e-01
C08 N07 N08 8.96e-08
L08 N07 N08 3.82e-11
R08 N07 N08 1.42e-01
C09 N08 N09 2.85e-07
L09 N08 N09 6.74e-12
R09 N08 N09 3.99e-02
C10 N09 N10 1.20e-07
L10 N09 N10 1.01e-11
R10 N09 N10 4.16e-02
C11 N10 N11 4.34e-11
L11 N10 N11 8.09e-12
R11 N10 N11 7.95e-01
C12 N11 Port2 6.06e-13
L12 N11 Port2 2.78e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21B3U1H473JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GXM21B5C1H183JA02
* Property : C = 1.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B5C1H183JA02 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GXM21B5C1H183JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GXM21B5C1H223JA02
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B5C1H223JA02 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GXM21B5C1H223JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GXM21B7U1A104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B7U1A104JA02 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 9.31e-11
R03 N02 N03 3.94e-03
L04 N03 N04 1.84e-11
R04 N03 N04 3.47e-01
L05 N04 N05 1.46e-10
R05 N04 N05 1.08e-01
L06 N05 N06 7.38e-11
R06 N05 N06 2.13e-03
C07 N06 N07 2.06e-07
L07 N06 N07 7.67e-11
R07 N06 N07 1.24e-01
C08 N07 N08 1.71e-07
L08 N07 N08 4.21e-11
R08 N07 N08 8.67e-02
C09 N08 N09 1.96e-07
L09 N08 N09 1.83e-11
R09 N08 N09 3.80e-02
C10 N09 N10 2.62e-07
L10 N09 N10 8.77e-12
R10 N09 N10 3.22e-02
C11 N10 N11 3.65e-11
L11 N10 N11 9.59e-12
R11 N10 N11 1.31e+00
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21B7U1A104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GXM21B7U1A683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B7U1A683JA02 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.57e-11
R03 N02 N03 4.60e-03
L04 N03 N04 1.95e-11
R04 N03 N04 4.22e-01
L05 N04 N05 8.75e-11
R05 N04 N05 1.16e-01
L06 N05 N06 9.66e-11
R06 N05 N06 6.89e-03
C07 N06 N07 2.34e-07
L07 N06 N07 4.00e-11
R07 N06 N07 8.18e-02
C08 N07 N08 8.67e-08
L08 N07 N08 4.56e-11
R08 N07 N08 8.56e-02
C09 N08 N09 5.26e-08
L09 N08 N09 2.40e-11
R09 N08 N09 3.99e-02
C10 N09 N10 1.13e-11
L10 N09 N10 3.11e-11
R10 N09 N10 1.37e+01
C11 N10 Port2 9.00e-13
L11 N10 Port2 3.50e-10
R11 N10 Port2 1.00e+05
.ENDS GXM21B7U1A683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/8.20e-02[uF]/10[V]
* Murata P/N :GXM21B7U1A823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B7U1A823JA02 Port1 Port2
C01 Port1 N01 8.39e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.99e-10
R03 N02 N03 3.66e-03
L04 N03 N04 1.54e-10
R04 N03 N04 1.04e-01
L05 N04 N05 9.71e-11
R05 N04 N05 3.25e-03
C06 N05 N06 2.78e-07
L06 N05 N06 4.73e-11
R06 N05 N06 9.82e-02
C07 N06 N07 1.48e-07
L07 N06 N07 4.14e-11
R07 N06 N07 9.16e-02
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.50e-10
R08 N07 Port2 4.52e+01
.ENDS GXM21B7U1A823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GXM21B7U1H393JA02
* Property : C = 3.90e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B7U1H393JA02 Port1 Port2
C01 Port1 N01 3.88e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 4.37e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.71e-01
L05 N04 N05 1.17e-10
R05 N04 N05 5.64e-03
C06 N05 N06 1.12e-07
L06 N05 N06 5.35e-11
R06 N05 N06 1.46e-01
C07 N06 N07 5.11e-08
L07 N06 N07 5.25e-11
R07 N06 N07 1.32e-01
C08 N07 N08 1.78e-07
L08 N07 N08 7.56e-12
R08 N07 N08 3.39e-02
C09 N08 N09 3.84e-08
L09 N08 N09 2.17e-11
R09 N08 N09 6.59e-02
C10 N09 Port2 1.59e-12
L10 N09 Port2 2.00e-10
R10 N09 Port2 4.31e+01
.ENDS GXM21B7U1H393JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GXM21B7U1H473JA02
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM21B7U1H473JA02 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 3.71e-03
L04 N03 N04 2.22e-11
R04 N03 N04 4.19e-01
L05 N04 N05 1.64e-10
R05 N04 N05 1.46e-01
L06 N05 N06 4.84e-11
R06 N05 N06 1.78e-03
C07 N06 N07 1.22e-07
L07 N06 N07 6.18e-11
R07 N06 N07 1.57e-01
C08 N07 N08 8.96e-08
L08 N07 N08 3.82e-11
R08 N07 N08 1.42e-01
C09 N08 N09 2.85e-07
L09 N08 N09 6.74e-12
R09 N08 N09 3.99e-02
C10 N09 N10 1.20e-07
L10 N09 N10 1.01e-11
R10 N09 N10 4.16e-02
C11 N10 N11 4.34e-11
L11 N10 N11 8.09e-12
R11 N10 N11 7.95e-01
C12 N11 Port2 6.06e-13
L12 N11 Port2 2.78e-10
R12 N11 Port2 1.00e+05
.ENDS GXM21B7U1H473JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GXM31C2C1C124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C2C1C124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GXM31C2C1C124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GXM31C2C1E124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C2C1E124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GXM31C2C1E124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GXM31C2C1H104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C2C1H104JA02 Port1 Port2
C01 Port1 N01 9.75e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 2.30e-11
R03 N02 N03 3.57e-03
L04 N03 N04 1.82e-11
R04 N03 N04 2.43e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.28e-01
L06 N05 N06 4.95e-11
R06 N05 N06 1.20e-02
C07 N06 N07 2.06e-07
L07 N06 N07 1.26e-10
R07 N06 N07 1.90e-01
C08 N07 N08 1.87e-07
L08 N07 N08 6.53e-11
R08 N07 N08 1.78e-01
C09 N08 N09 5.49e-07
L09 N08 N09 1.18e-11
R09 N08 N09 5.07e-02
C10 N09 N10 1.38e-07
L10 N09 N10 2.98e-11
R10 N09 N10 5.85e-02
C11 N10 N11 1.35e-07
L11 N10 N11 1.70e-11
R11 N10 N11 3.93e-02
C12 N11 Port2 8.47e-13
L12 N11 Port2 4.01e-10
R12 N11 Port2 5.01e+02
.ENDS GXM31C2C1H104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GXM31C2C1H683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C2C1H683JA02 Port1 Port2
C01 Port1 N01 6.66e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 2.88e-12
R03 N02 N03 3.97e-03
L04 N03 N04 1.61e-11
R04 N03 N04 2.79e-01
L05 N04 N05 1.83e-10
R05 N04 N05 1.31e-01
L06 N05 N06 2.89e-11
R06 N05 N06 6.16e-03
C07 N06 N07 2.14e-07
L07 N06 N07 7.47e-11
R07 N06 N07 1.68e-01
C08 N07 N08 8.34e-08
L08 N07 N08 8.56e-11
R08 N07 N08 1.92e-01
C09 N08 N09 2.68e-07
L09 N08 N09 1.31e-11
R09 N08 N09 3.29e-02
C10 N09 N10 1.21e-07
L10 N09 N10 1.84e-11
R10 N09 N10 5.42e-02
C11 N10 N11 2.23e-07
L11 N10 N11 5.08e-12
R11 N10 N11 1.87e-02
C12 N11 Port2 7.41e-13
L12 N11 Port2 4.94e-10
R12 N11 Port2 7.24e+02
.ENDS GXM31C2C1H683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GXM31C2C1H823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C2C1H823JA02 Port1 Port2
C01 Port1 N01 8.17e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.60e-10
R03 N02 N03 3.14e-03
L04 N03 N04 1.92e-10
R04 N03 N04 1.47e-01
L05 N04 N05 1.69e-10
R05 N04 N05 2.87e-03
C06 N05 N06 2.23e-07
L06 N05 N06 9.69e-11
R06 N05 N06 2.18e-01
C07 N06 N07 1.26e-07
L07 N06 N07 8.03e-11
R07 N06 N07 1.95e-01
C08 N07 N08 2.26e-07
L08 N07 N08 2.31e-11
R08 N07 N08 6.90e-02
C09 N08 N09 1.30e-07
L09 N08 N09 2.61e-11
R09 N08 N09 8.41e-02
C10 N09 Port2 1.33e-12
L10 N09 Port2 2.96e-10
R10 N09 Port2 2.00e+02
.ENDS GXM31C2C1H823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GXM31C5C1C124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C5C1C124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GXM31C5C1C124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.20e-01[uF]/25[V]
* Murata P/N :GXM31C5C1E124JA02
* Property : C = 1.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C5C1E124JA02 Port1 Port2
C01 Port1 N01 1.21e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 1.42e-10
R03 N02 N03 2.28e-03
L04 N03 N04 2.23e-10
R04 N03 N04 1.01e-01
L05 N04 N05 7.52e-11
R05 N04 N05 1.64e-03
L06 N05 N06 5.12e-10
R06 N05 N06 1.31e-03
C07 N06 N07 4.00e-07
L07 N06 N07 7.83e-11
R07 N06 N07 1.35e-01
C08 N07 N08 2.02e-07
L08 N07 N08 7.30e-11
R08 N07 N08 1.33e-01
C09 N08 N09 8.00e-07
L09 N08 N09 9.31e-12
R09 N08 N09 3.22e-02
C10 N09 N10 3.30e-07
L10 N09 N10 1.48e-11
R10 N09 N10 5.04e-02
C11 N10 Port2 8.28e-13
L11 N10 Port2 4.20e-10
R11 N10 Port2 2.00e+02
.ENDS GXM31C5C1E124JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GXM31C5C1H104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C5C1H104JA02 Port1 Port2
C01 Port1 N01 9.75e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 2.30e-11
R03 N02 N03 3.57e-03
L04 N03 N04 1.82e-11
R04 N03 N04 2.43e-01
L05 N04 N05 1.73e-10
R05 N04 N05 1.28e-01
L06 N05 N06 4.95e-11
R06 N05 N06 1.20e-02
C07 N06 N07 2.06e-07
L07 N06 N07 1.26e-10
R07 N06 N07 1.90e-01
C08 N07 N08 1.87e-07
L08 N07 N08 6.53e-11
R08 N07 N08 1.78e-01
C09 N08 N09 5.49e-07
L09 N08 N09 1.18e-11
R09 N08 N09 5.07e-02
C10 N09 N10 1.38e-07
L10 N09 N10 2.98e-11
R10 N09 N10 5.85e-02
C11 N10 N11 1.35e-07
L11 N10 N11 1.70e-11
R11 N10 N11 3.93e-02
C12 N11 Port2 8.47e-13
L12 N11 Port2 4.01e-10
R12 N11 Port2 5.01e+02
.ENDS GXM31C5C1H104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GXM31C5C1H683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C5C1H683JA02 Port1 Port2
C01 Port1 N01 6.66e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 2.88e-12
R03 N02 N03 3.97e-03
L04 N03 N04 1.61e-11
R04 N03 N04 2.79e-01
L05 N04 N05 1.83e-10
R05 N04 N05 1.31e-01
L06 N05 N06 2.89e-11
R06 N05 N06 6.16e-03
C07 N06 N07 2.14e-07
L07 N06 N07 7.47e-11
R07 N06 N07 1.68e-01
C08 N07 N08 8.34e-08
L08 N07 N08 8.56e-11
R08 N07 N08 1.92e-01
C09 N08 N09 2.68e-07
L09 N08 N09 1.31e-11
R09 N08 N09 3.29e-02
C10 N09 N10 1.21e-07
L10 N09 N10 1.84e-11
R10 N09 N10 5.42e-02
C11 N10 N11 2.23e-07
L11 N10 N11 5.08e-12
R11 N10 N11 1.87e-02
C12 N11 Port2 7.41e-13
L12 N11 Port2 4.94e-10
R12 N11 Port2 7.24e+02
.ENDS GXM31C5C1H683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GXM31C5C1H823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31C5C1H823JA02 Port1 Port2
C01 Port1 N01 8.17e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.60e-10
R03 N02 N03 3.14e-03
L04 N03 N04 1.92e-10
R04 N03 N04 1.47e-01
L05 N04 N05 1.69e-10
R05 N04 N05 2.87e-03
C06 N05 N06 2.23e-07
L06 N05 N06 9.69e-11
R06 N05 N06 2.18e-01
C07 N06 N07 1.26e-07
L07 N06 N07 8.03e-11
R07 N06 N07 1.95e-01
C08 N07 N08 2.26e-07
L08 N07 N08 2.31e-11
R08 N07 N08 6.90e-02
C09 N08 N09 1.30e-07
L09 N08 N09 2.61e-11
R09 N08 N09 8.41e-02
C10 N09 Port2 1.33e-12
L10 N09 Port2 2.96e-10
R10 N09 Port2 2.00e+02
.ENDS GXM31C5C1H823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GXM31M2C1H473JA02
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M2C1H473JA02 Port1 Port2
C01 Port1 N01 4.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-12
R03 N02 N03 4.65e-03
L04 N03 N04 1.70e-10
R04 N03 N04 1.70e-01
L05 N04 N05 5.97e-11
R05 N04 N05 1.89e-03
C06 N05 N06 9.42e-08
L06 N05 N06 1.00e-10
R06 N05 N06 1.86e-01
C07 N06 N07 7.88e-08
L07 N06 N07 5.29e-11
R07 N06 N07 1.48e-01
C08 N07 N08 1.32e-07
L08 N07 N08 1.54e-11
R08 N07 N08 4.03e-02
C09 N08 N09 1.03e-07
L09 N08 N09 1.12e-11
R09 N08 N09 5.28e-02
C10 N09 N10 1.52e-11
L10 N09 N10 2.67e-11
R10 N09 N10 1.06e+00
C11 N10 Port2 6.48e-13
L11 N10 Port2 4.68e-10
R11 N10 Port2 1.00e+05
.ENDS GXM31M2C1H473JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GXM31M2C1H563JA02
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M2C1H563JA02 Port1 Port2
C01 Port1 N01 5.66e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.31e-11
R03 N02 N03 3.06e-03
L04 N03 N04 1.99e-11
R04 N03 N04 2.67e-01
L05 N04 N05 1.84e-10
R05 N04 N05 1.29e-01
L06 N05 N06 1.07e-10
R06 N05 N06 1.70e-03
L07 N06 N07 2.45e-10
R07 N06 N07 5.88e-04
C08 N07 N08 1.70e-07
L08 N07 N08 6.93e-11
R08 N07 N08 1.74e-01
C09 N08 N09 7.87e-08
L09 N08 N09 6.53e-11
R09 N08 N09 2.12e-01
C10 N09 Port2 8.35e-13
L10 N09 Port2 4.10e-10
R10 N09 Port2 8.41e+02
.ENDS GXM31M2C1H563JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/UJ(-25to85[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GXM31M3U1H104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M3U1H104JA02 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 5.02e-12
R03 N02 N03 4.44e-03
L04 N03 N04 2.69e-11
R04 N03 N04 6.56e-01
L05 N04 N05 9.73e-11
R05 N04 N05 1.50e-01
L06 N05 N06 5.03e-11
R06 N05 N06 1.89e-03
C07 N06 N07 3.90e-07
L07 N06 N07 5.62e-11
R07 N06 N07 9.96e-02
C08 N07 N08 1.48e-07
L08 N07 N08 6.86e-11
R08 N07 N08 1.02e-01
C09 N08 N09 1.50e-08
L09 N08 N09 1.52e-10
R09 N08 N09 7.99e-02
C10 N09 Port2 9.51e-13
L10 N09 Port2 4.38e-10
R10 N09 Port2 8.37e+02
.ENDS GXM31M3U1H104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/UJ(-25to85[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GXM31M3U1H683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M3U1H683JA02 Port1 Port2
C01 Port1 N01 6.86e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 7.94e-12
R03 N02 N03 5.88e-03
L04 N03 N04 2.74e-11
R04 N03 N04 3.28e-01
L05 N04 N05 2.20e-10
R05 N04 N05 1.32e-01
L06 N05 N06 3.44e-11
R06 N05 N06 1.21e-03
C07 N06 N07 3.91e-07
L07 N06 N07 3.35e-11
R07 N06 N07 7.69e-02
C08 N07 N08 1.04e-07
L08 N07 N08 5.37e-11
R08 N07 N08 9.13e-02
C09 N08 N09 1.01e-12
L09 N08 N09 5.77e-10
R09 N08 N09 7.51e+02
C10 N09 Port2 3.31e-14
L10 N09 Port2 2.07e-11
R10 N09 Port2 1.00e+05
.ENDS GXM31M3U1H683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/UJ(-25to85[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GXM31M3U1H823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M3U1H823JA02 Port1 Port2
C01 Port1 N01 8.12e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 8.70e-11
R03 N02 N03 5.49e-03
L04 N03 N04 3.19e-11
R04 N03 N04 7.11e-01
L05 N04 N05 2.03e-10
R05 N04 N05 1.17e-01
L06 N05 N06 9.73e-11
R06 N05 N06 1.86e-03
C07 N06 N07 3.16e-07
L07 N06 N07 5.14e-11
R07 N06 N07 9.32e-02
C08 N07 N08 1.12e-07
L08 N07 N08 6.37e-11
R08 N07 N08 1.22e-01
C09 N08 Port2 1.43e-12
L09 N08 Port2 4.20e-10
R09 N08 Port2 9.27e+02
.ENDS GXM31M3U1H823JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GXM31M5C1H473JA02
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M5C1H473JA02 Port1 Port2
C01 Port1 N01 4.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-12
R03 N02 N03 4.65e-03
L04 N03 N04 1.70e-10
R04 N03 N04 1.70e-01
L05 N04 N05 5.97e-11
R05 N04 N05 1.89e-03
C06 N05 N06 9.42e-08
L06 N05 N06 1.00e-10
R06 N05 N06 1.86e-01
C07 N06 N07 7.88e-08
L07 N06 N07 5.29e-11
R07 N06 N07 1.48e-01
C08 N07 N08 1.32e-07
L08 N07 N08 1.54e-11
R08 N07 N08 4.03e-02
C09 N08 N09 1.03e-07
L09 N08 N09 1.12e-11
R09 N08 N09 5.28e-02
C10 N09 N10 1.52e-11
L10 N09 N10 2.67e-11
R10 N09 N10 1.06e+00
C11 N10 Port2 6.48e-13
L11 N10 Port2 4.68e-10
R11 N10 Port2 1.00e+05
.ENDS GXM31M5C1H473JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GXM31M5C1H563JA02
* Property : C = 5.60e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M5C1H563JA02 Port1 Port2
C01 Port1 N01 5.66e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.31e-11
R03 N02 N03 3.06e-03
L04 N03 N04 1.99e-11
R04 N03 N04 2.67e-01
L05 N04 N05 1.84e-10
R05 N04 N05 1.29e-01
L06 N05 N06 1.07e-10
R06 N05 N06 1.70e-03
L07 N06 N07 2.45e-10
R07 N06 N07 5.88e-04
C08 N07 N08 1.70e-07
L08 N07 N08 6.93e-11
R08 N07 N08 1.74e-01
C09 N08 N09 7.87e-08
L09 N08 N09 6.53e-11
R09 N08 N09 2.12e-01
C10 N09 Port2 8.35e-13
L10 N09 Port2 4.10e-10
R10 N09 Port2 8.41e+02
.ENDS GXM31M5C1H563JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/U2J(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GXM31M7U1H104JA02
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M7U1H104JA02 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 5.02e-12
R03 N02 N03 4.44e-03
L04 N03 N04 2.69e-11
R04 N03 N04 6.56e-01
L05 N04 N05 9.73e-11
R05 N04 N05 1.50e-01
L06 N05 N06 5.03e-11
R06 N05 N06 1.89e-03
C07 N06 N07 3.90e-07
L07 N06 N07 5.62e-11
R07 N06 N07 9.96e-02
C08 N07 N08 1.48e-07
L08 N07 N08 6.86e-11
R08 N07 N08 1.02e-01
C09 N08 N09 1.50e-08
L09 N08 N09 1.52e-10
R09 N08 N09 7.99e-02
C10 N09 Port2 9.51e-13
L10 N09 Port2 4.38e-10
R10 N09 Port2 8.37e+02
.ENDS GXM31M7U1H104JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/U2J(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GXM31M7U1H683JA02
* Property : C = 6.80e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M7U1H683JA02 Port1 Port2
C01 Port1 N01 6.86e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 7.94e-12
R03 N02 N03 5.88e-03
L04 N03 N04 2.74e-11
R04 N03 N04 3.28e-01
L05 N04 N05 2.20e-10
R05 N04 N05 1.32e-01
L06 N05 N06 3.44e-11
R06 N05 N06 1.21e-03
C07 N06 N07 3.91e-07
L07 N06 N07 3.35e-11
R07 N06 N07 7.69e-02
C08 N07 N08 1.04e-07
L08 N07 N08 5.37e-11
R08 N07 N08 9.13e-02
C09 N08 N09 1.01e-12
L09 N08 N09 5.77e-10
R09 N08 N09 7.51e+02
C10 N09 Port2 3.31e-14
L10 N09 Port2 2.07e-11
R10 N09 Port2 1.00e+05
.ENDS GXM31M7U1H683JA02
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/U2J(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GXM31M7U1H823JA02
* Property : C = 8.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXM31M7U1H823JA02 Port1 Port2
C01 Port1 N01 8.12e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 8.70e-11
R03 N02 N03 5.49e-03
L04 N03 N04 3.19e-11
R04 N03 N04 7.11e-01
L05 N04 N05 2.03e-10
R05 N04 N05 1.17e-01
L06 N05 N06 9.73e-11
R06 N05 N06 1.86e-03
C07 N06 N07 3.16e-07
L07 N06 N07 5.14e-11
R07 N06 N07 9.32e-02
C08 N07 N08 1.12e-07
L08 N07 N08 6.37e-11
R08 N07 N08 1.22e-01
C09 N08 Port2 1.43e-12
L09 N08 Port2 4.20e-10
R09 N08 Port2 9.27e+02
.ENDS GXM31M7U1H823JA02
