*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N6B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 2.70e-10
R2 1 port2 8.00e-3
R3 port1 port2 1.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N6C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 2.70e-10
R2 1 port2 8.00e-3
R3 port1 port2 1.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N7B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N7C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N8B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N8C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N9B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N9C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN10NH02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.03e-8
R2 1 port2 4.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN10NJ02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.03e-8
R2 1 port2 4.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN11NH02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.15e-8
R2 1 port2 4.90e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.50e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.00e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN11NJ02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.15e-8
R2 1 port2 4.90e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.50e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.00e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN12NH02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.26e-8
R2 1 port2 4.10e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 8.70e-15
R7 6 port2 50.0
.ENDS LQP03TN12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN12NJ02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.26e-8
R2 1 port2 4.10e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 8.70e-15
R7 6 port2 50.0
.ENDS LQP03TN12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN13NH02 port1 port2
C1 port1 port2 9.75e-14
L2 port1 1 1.36e-8
R2 1 port2 5.35e-1
R3 port1 port2 9.00e+3
L4 port1 2 2.80e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.90e-7
R6 4 port2 220
L7 port1 5 8.20e-9
C7 5 6 9.00e-15
R7 6 port2 40.0
.ENDS LQP03TN13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN13NJ02 port1 port2
C1 port1 port2 9.75e-14
L2 port1 1 1.36e-8
R2 1 port2 5.35e-1
R3 port1 port2 9.00e+3
L4 port1 2 2.80e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.90e-7
R6 4 port2 220
L7 port1 5 8.20e-9
C7 5 6 9.00e-15
R7 6 port2 40.0
.ENDS LQP03TN13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN15NH02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.62e-8
R2 1 port2 4.70e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 79.0
L7 port1 5 8.10e-9
C7 5 6 1.21e-14
R7 6 port2 50.0
.ENDS LQP03TN15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN15NJ02 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.62e-8
R2 1 port2 4.70e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 79.0
L7 port1 5 8.10e-9
C7 5 6 1.21e-14
R7 6 port2 50.0
.ENDS LQP03TN15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN16NH02 port1 port2
C1 port1 port2 1.05e-13
L2 port1 1 1.73e-8
R2 1 port2 6.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 2.70e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.70e-7
R6 4 port2 60.0
L7 port1 5 8.00e-9
C7 5 6 1.15e-14
R7 6 port2 40.0
.ENDS LQP03TN16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN16NJ02 port1 port2
C1 port1 port2 1.05e-13
L2 port1 1 1.73e-8
R2 1 port2 6.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 2.70e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.70e-7
R6 4 port2 60.0
L7 port1 5 8.00e-9
C7 5 6 1.15e-14
R7 6 port2 40.0
.ENDS LQP03TN16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN18NH02 port1 port2
C1 port1 port2 1.22e-13
L2 port1 1 1.94e-8
R2 1 port2 5.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 3.70e-7
R4 2 port2 1.10e+3
L5 port1 3 6.50e-7
R5 3 port2 500
L6 port1 4 3.00e-7
R6 4 port2 90.0
L7 port1 5 1.71e-8
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN18NJ02 port1 port2
C1 port1 port2 1.22e-13
L2 port1 1 1.94e-8
R2 1 port2 5.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 3.70e-7
R4 2 port2 1.10e+3
L5 port1 3 6.50e-7
R5 3 port2 500
L6 port1 4 3.00e-7
R6 4 port2 90.0
L7 port1 5 1.71e-8
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N0B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N0C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N1B02 port1 port2
C1 port1 port2 2.70e-14
L2 port1 1 8.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.60e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N1C02 port1 port2
C1 port1 port2 2.70e-14
L2 port1 1 8.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.60e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N2B02 port1 port2
C1 port1 port2 3.70e-14
L2 port1 1 9.00e-10
R2 1 port2 3.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N2C02 port1 port2
C1 port1 port2 3.70e-14
L2 port1 1 9.00e-10
R2 1 port2 3.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N3B02 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.02e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 2.10e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N3C02 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.02e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 2.10e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N4B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.70e+3
L4 port1 2 2.25e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N4C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.70e+3
L4 port1 2 2.25e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N5B02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 1.23e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.40e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N5C02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 1.23e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.40e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N6B02 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.36e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.60e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N6C02 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.36e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.60e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N7B02 port1 port2
C1 port1 port2 3.45e-14
L2 port1 1 1.46e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 2.80e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N7C02 port1 port2
C1 port1 port2 3.45e-14
L2 port1 1 1.46e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 2.80e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N8B02 port1 port2
C1 port1 port2 4.15e-14
L2 port1 1 1.57e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N8C02 port1 port2
C1 port1 port2 4.15e-14
L2 port1 1 1.57e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N9B02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 1.67e-9
R2 1 port2 5.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.20e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N9C02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 1.67e-9
R2 1 port2 5.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.20e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN20NH02 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 2.16e-8
R2 1 port2 1.66
R3 port1 port2 1.30e+4
L4 port1 2 9.00e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 50.0
L7 port1 5 1.00e-8
C7 5 6 1.00e-14
R7 6 port2 30.0
.ENDS LQP03TN20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN20NJ02 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 2.16e-8
R2 1 port2 1.66
R3 port1 port2 1.30e+4
L4 port1 2 9.00e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 50.0
L7 port1 5 1.00e-8
C7 5 6 1.00e-14
R7 6 port2 30.0
.ENDS LQP03TN20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN22NH02 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 2.40e-8
R2 1 port2 1.30
R3 port1 port2 1.30e+4
L4 port1 2 8.50e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.37e-14
R7 6 port2 70.0
.ENDS LQP03TN22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN22NJ02 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 2.40e-8
R2 1 port2 1.30
R3 port1 port2 1.30e+4
L4 port1 2 8.50e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.37e-14
R7 6 port2 70.0
.ENDS LQP03TN22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN24NH02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN24NH02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 2.63e-8
R2 1 port2 1.89
R3 port1 port2 1.45e+4
L4 port1 2 1.10e-6
R4 2 port2 750
L5 port1 3 5.60e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.30e-14
R7 6 port2 55.0
.ENDS LQP03TN24NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN24NJ02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN24NJ02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 2.63e-8
R2 1 port2 1.89
R3 port1 port2 1.45e+4
L4 port1 2 1.10e-6
R4 2 port2 750
L5 port1 3 5.60e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.30e-14
R7 6 port2 55.0
.ENDS LQP03TN24NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN27NH02 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 3.03e-8
R2 1 port2 1.60
R3 port1 port2 1.50e+4
L4 port1 2 5.50e-7
R4 2 port2 1.60e+3
L5 port1 3 7.50e-7
R5 3 port2 380
L6 port1 4 3.00e-7
R6 4 port2 35.0
L7 port1 5 1.15e-8
C7 5 6 1.37e-14
R7 6 port2 75.0
.ENDS LQP03TN27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN27NJ02 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 3.03e-8
R2 1 port2 1.60
R3 port1 port2 1.50e+4
L4 port1 2 5.50e-7
R4 2 port2 1.60e+3
L5 port1 3 7.50e-7
R5 3 port2 380
L6 port1 4 3.00e-7
R6 4 port2 35.0
L7 port1 5 1.15e-8
C7 5 6 1.37e-14
R7 6 port2 75.0
.ENDS LQP03TN27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N0B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.80e-9
R2 1 port2 6.30e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.30e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N0C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.80e-9
R2 1 port2 6.30e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.30e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N1B02 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 1.91e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.50e-8
R4 2 port2 70.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N1C02 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 1.91e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.50e-8
R4 2 port2 70.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N2B02 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 2.01e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N2C02 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 2.01e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N3B02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.11e-9
R2 1 port2 7.50e-2
R3 port1 port2 3.60e+3
L4 port1 2 4.70e-8
R4 2 port2 110
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N3C02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.11e-9
R2 1 port2 7.50e-2
R3 port1 port2 3.60e+3
L4 port1 2 4.70e-8
R4 2 port2 110
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N4B02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.22e-9
R2 1 port2 8.30e-2
R3 port1 port2 3.80e+3
L4 port1 2 5.30e-8
R4 2 port2 150
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N4C02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.22e-9
R2 1 port2 8.30e-2
R3 port1 port2 3.80e+3
L4 port1 2 5.30e-8
R4 2 port2 150
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N5B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 2.32e-9
R2 1 port2 8.90e-2
R3 port1 port2 4.40e+3
L4 port1 2 6.20e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N5C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 2.32e-9
R2 1 port2 8.90e-2
R3 port1 port2 4.40e+3
L4 port1 2 6.20e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N6B02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 2.44e-9
R2 1 port2 8.40e-2
R3 port1 port2 4.50e+3
L4 port1 2 5.50e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 8.90e-15
R7 6 port2 40.0
.ENDS LQP03TN2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N6C02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 2.44e-9
R2 1 port2 8.40e-2
R3 port1 port2 4.50e+3
L4 port1 2 5.50e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 8.90e-15
R7 6 port2 40.0
.ENDS LQP03TN2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N7B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.55e-9
R2 1 port2 8.50e-2
R3 port1 port2 4.60e+3
L4 port1 2 5.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.60e-15
R7 6 port2 40.0
.ENDS LQP03TN2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N7C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.55e-9
R2 1 port2 8.50e-2
R3 port1 port2 4.60e+3
L4 port1 2 5.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.60e-15
R7 6 port2 40.0
.ENDS LQP03TN2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N8B02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.65e-9
R2 1 port2 9.95e-2
R3 port1 port2 4.60e+3
L4 port1 2 6.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N8C02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.65e-9
R2 1 port2 9.95e-2
R3 port1 port2 4.60e+3
L4 port1 2 6.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N9B02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.77e-9
R2 1 port2 1.05e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.10e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 40.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N9C02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.77e-9
R2 1 port2 1.05e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.10e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 40.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN30NH02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN30NH02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.21e-8
R2 1 port2 1.63
R3 port1 port2 1.55e+4
L4 port1 2 6.50e-7
R4 2 port2 2.10e+3
L5 port1 3 4.80e-7
R5 3 port2 190
L6 port1 4 1.20e-6
R6 4 port2 60.0
L7 port1 5 2.20e-8
C7 5 6 8.25e-15
R7 6 port2 60.0
.ENDS LQP03TN30NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN30NJ02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN30NJ02 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.21e-8
R2 1 port2 1.63
R3 port1 port2 1.55e+4
L4 port1 2 6.50e-7
R4 2 port2 2.10e+3
L5 port1 3 4.80e-7
R5 3 port2 190
L6 port1 4 1.20e-6
R6 4 port2 60.0
L7 port1 5 2.20e-8
C7 5 6 8.25e-15
R7 6 port2 60.0
.ENDS LQP03TN30NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN33NH02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 3.58e-8
R2 1 port2 2.48
R3 port1 port2 2.30e+4
L4 port1 2 6.50e-7
R4 2 port2 2.00e+3
L5 port1 3 6.00e-7
R5 3 port2 180
L6 port1 4 1.00e-6
R6 4 port2 41.0
L7 port1 5 2.20e-8
C7 5 6 8.80e-15
R7 6 port2 60.0
.ENDS LQP03TN33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN33NJ02 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 3.58e-8
R2 1 port2 2.48
R3 port1 port2 2.30e+4
L4 port1 2 6.50e-7
R4 2 port2 2.00e+3
L5 port1 3 6.00e-7
R5 3 port2 180
L6 port1 4 1.00e-6
R6 4 port2 41.0
L7 port1 5 2.20e-8
C7 5 6 8.80e-15
R7 6 port2 60.0
.ENDS LQP03TN33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN36NH02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN36NH02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 3.98e-8
R2 1 port2 2.46
R3 port1 port2 1.20e+4
L4 port1 2 4.80e-7
R4 2 port2 800
L5 port1 3 8.20e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 1.86e-14
R7 6 port2 80.0
.ENDS LQP03TN36NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN36NJ02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN36NJ02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 3.98e-8
R2 1 port2 2.46
R3 port1 port2 1.20e+4
L4 port1 2 4.80e-7
R4 2 port2 800
L5 port1 3 8.20e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 1.86e-14
R7 6 port2 80.0
.ENDS LQP03TN36NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN39NH02 port1 port2
C1 port1 port2 1.17e-13
L2 port1 1 4.35e-8
R2 1 port2 2.35
R3 port1 port2 1.45e+4
L4 port1 2 4.50e-7
R4 2 port2 800
L5 port1 3 7.95e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 2.36e-14
R7 6 port2 70.0
.ENDS LQP03TN39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN39NJ02 port1 port2
C1 port1 port2 1.17e-13
L2 port1 1 4.35e-8
R2 1 port2 2.35
R3 port1 port2 1.45e+4
L4 port1 2 4.50e-7
R4 2 port2 800
L5 port1 3 7.95e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 2.36e-14
R7 6 port2 70.0
.ENDS LQP03TN39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N0B02 port1 port2
C1 port1 port2 5.93e-14
L2 port1 1 2.87e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N0C02 port1 port2
C1 port1 port2 5.93e-14
L2 port1 1 2.87e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N1B02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 2.99e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.30e-15
R7 6 port2 40.0
.ENDS LQP03TN3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N1C02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 2.99e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.30e-15
R7 6 port2 40.0
.ENDS LQP03TN3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N2B02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.11e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.30e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N2C02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.11e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.30e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N3B02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.22e-9
R2 1 port2 1.27e-1
R3 port1 port2 5.50e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N3C02 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.22e-9
R2 1 port2 1.27e-1
R3 port1 port2 5.50e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N4B02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 3.34e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.40e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N4C02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 3.34e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.40e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N5B02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.46e-9
R2 1 port2 1.35e-1
R3 port1 port2 6.00e+3
L4 port1 2 7.70e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N5C02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.46e-9
R2 1 port2 1.35e-1
R3 port1 port2 6.00e+3
L4 port1 2 7.70e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N6B02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 1.25e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 25.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N6C02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 1.25e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 25.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N7B02 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.69e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.30e+3
L4 port1 2 9.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 35.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N7C02 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.69e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.30e+3
L4 port1 2 9.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 35.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N8B02 port1 port2
C1 port1 port2 1.08e-13
L2 port1 1 3.73e-9
R2 1 port2 1.40e-1
R3 port1 port2 6.50e+3
L4 port1 2 1.00e-7
R4 2 port2 250
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N8C02 port1 port2
C1 port1 port2 1.08e-13
L2 port1 1 3.73e-9
R2 1 port2 1.40e-1
R3 port1 port2 6.50e+3
L4 port1 2 1.00e-7
R4 2 port2 250
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N9B02 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.83e-9
R2 1 port2 1.30e-1
R3 port1 port2 4.80e+3
L4 port1 2 1.30e-7
R4 2 port2 300
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 40.0
.ENDS LQP03TN3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N9C02 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.83e-9
R2 1 port2 1.30e-1
R3 port1 port2 4.80e+3
L4 port1 2 1.30e-7
R4 2 port2 300
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 40.0
.ENDS LQP03TN3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN43NH02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN43NH02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 4.86e-8
R2 1 port2 2.33
R3 port1 port2 1.20e+4
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 8.00e-7
R5 3 port2 120
L6 port1 4 1.30e-6
R6 4 port2 30.0
L7 port1 5 1.14e-8
C7 5 6 2.70e-14
R7 6 port2 100
.ENDS LQP03TN43NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN43NJ02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN43NJ02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 4.86e-8
R2 1 port2 2.33
R3 port1 port2 1.20e+4
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 8.00e-7
R5 3 port2 120
L6 port1 4 1.30e-6
R6 4 port2 30.0
L7 port1 5 1.14e-8
C7 5 6 2.70e-14
R7 6 port2 100
.ENDS LQP03TN43NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN47NH02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN47NH02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 5.20e-8
R2 1 port2 2.95
R3 port1 port2 2.60e+4
L4 port1 2 7.00e-7
R4 2 port2 1.90e+3
L5 port1 3 7.95e-7
R5 3 port2 200
L6 port1 4 1.05e-6
R6 4 port2 60.0
L7 port1 5 2.48e-8
C7 5 6 1.23e-14
R7 6 port2 85.0
L8 port1 7 6.70e-9
C8 7 8 1.32e-14
R8 8 port2 80.0
.ENDS LQP03TN47NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN47NJ02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 5.20e-8
R2 1 port2 2.95
R3 port1 port2 2.60e+4
L4 port1 2 7.00e-7
R4 2 port2 1.90e+3
L5 port1 3 7.95e-7
R5 3 port2 200
L6 port1 4 1.05e-6
R6 4 port2 60.0
L7 port1 5 2.48e-8
C7 5 6 1.23e-14
R7 6 port2 85.0
L8 port1 7 6.70e-9
C8 7 8 1.32e-14
R8 8 port2 80.0
.ENDS LQP03TN47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N0B02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 3.93e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
.ENDS LQP03TN4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N0C02 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 3.93e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
.ENDS LQP03TN4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N1B02 port1 port2
C1 port1 port2 9.55e-14
L2 port1 1 4.03e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N1C02 port1 port2
C1 port1 port2 9.55e-14
L2 port1 1 4.03e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N2B02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 4.16e-9
R2 1 port2 1.90e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.60e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N2C02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 4.16e-9
R2 1 port2 1.90e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.60e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N3H02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 4.30e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.30e+3
L4 port1 2 1.30e-7
R4 2 port2 400
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N3J02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 4.30e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.30e+3
L4 port1 2 1.30e-7
R4 2 port2 400
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N7H02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.75e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N7J02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.75e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN51NH02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN51NH02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 5.80e-8
R2 1 port2 2.58
R3 port1 port2 1.30e+4
L4 port1 2 6.60e-7
R4 2 port2 1.00e+3
L5 port1 3 1.10e-6
R5 3 port2 220
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.05e-8
C7 5 6 1.85e-14
R7 6 port2 150
L8 port1 7 1.10e-8
C8 7 8 7.78e-15
R8 8 port2 180
.ENDS LQP03TN51NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN51NJ02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN51NJ02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 5.80e-8
R2 1 port2 2.58
R3 port1 port2 1.30e+4
L4 port1 2 6.60e-7
R4 2 port2 1.00e+3
L5 port1 3 1.10e-6
R5 3 port2 220
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.05e-8
C7 5 6 1.85e-14
R7 6 port2 150
L8 port1 7 1.10e-8
C8 7 8 7.78e-15
R8 8 port2 180
.ENDS LQP03TN51NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN56NH02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN56NH02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 6.37e-8
R2 1 port2 3.42
R3 port1 port2 1.70e+4
L4 port1 2 7.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 35.0
L7 port1 5 2.12e-8
C7 5 6 1.85e-14
R7 6 port2 100
L8 port1 7 1.49e-8
C8 7 8 7.58e-15
R8 8 port2 80.0
.ENDS LQP03TN56NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN56NJ02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 6.37e-8
R2 1 port2 3.42
R3 port1 port2 1.70e+4
L4 port1 2 7.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 35.0
L7 port1 5 2.12e-8
C7 5 6 1.85e-14
R7 6 port2 100
L8 port1 7 1.49e-8
C8 7 8 7.58e-15
R8 8 port2 80.0
.ENDS LQP03TN56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N1H02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 5.24e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.80e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N1J02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 5.24e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.80e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N6H02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 5.80e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.70e-7
R4 2 port2 980
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 37.0
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N6J02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 5.80e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.70e-7
R4 2 port2 980
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 37.0
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN62NH02
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN62NH02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 7.17e-8
R2 1 port2 3.32
R3 port1 port2 1.50e+4
L4 port1 2 8.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.45e-8
C7 5 6 1.85e-14
R7 6 port2 140
L8 port1 7 1.70e-8
C8 7 8 7.58e-15
R8 8 port2 100
.ENDS LQP03TN62NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN62NJ02
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN62NJ02 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 7.17e-8
R2 1 port2 3.32
R3 port1 port2 1.50e+4
L4 port1 2 8.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.45e-8
C7 5 6 1.85e-14
R7 6 port2 140
L8 port1 7 1.70e-8
C8 7 8 7.58e-15
R8 8 port2 100
.ENDS LQP03TN62NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN68NH02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN68NH02 port1 port2
C1 port1 port2 1.53e-13
L2 port1 1 7.88e-8
R2 1 port2 5.90
R3 port1 port2 1.10e+4
L4 port1 2 8.50e-7
R4 2 port2 1.20e+3
L5 port1 3 8.50e-7
R5 3 port2 180
L6 port1 4 1.22e-6
R6 4 port2 47.0
L7 port1 5 3.80e-8
C7 5 6 1.33e-14
R7 6 port2 120
L8 port1 7 2.62e-8
C8 7 8 5.31e-15
R8 8 port2 130
.ENDS LQP03TN68NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN68NJ02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN68NJ02 port1 port2
C1 port1 port2 1.53e-13
L2 port1 1 7.88e-8
R2 1 port2 5.90
R3 port1 port2 1.10e+4
L4 port1 2 8.50e-7
R4 2 port2 1.20e+3
L5 port1 3 8.50e-7
R5 3 port2 180
L6 port1 4 1.22e-6
R6 4 port2 47.0
L7 port1 5 3.80e-8
C7 5 6 1.33e-14
R7 6 port2 120
L8 port1 7 2.62e-8
C8 7 8 5.31e-15
R8 8 port2 130
.ENDS LQP03TN68NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N2H02 port1 port2
C1 port1 port2 6.10e-14
L2 port1 1 6.20e-9
R2 1 port2 3.40e-1
R3 port1 port2 6.00e+3
L4 port1 2 1.40e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 350
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N2J02 port1 port2
C1 port1 port2 6.10e-14
L2 port1 1 6.20e-9
R2 1 port2 3.40e-1
R3 port1 port2 6.00e+3
L4 port1 2 1.40e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 350
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N8H02 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 6.90e-9
R2 1 port2 2.85e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N8J02 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 6.90e-9
R2 1 port2 2.85e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN75NH02
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN75NH02 port1 port2
C1 port1 port2 1.55e-13
L2 port1 1 9.00e-8
R2 1 port2 5.70
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-7
R4 2 port2 1.35e+3
L5 port1 3 9.70e-7
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 95.0
L7 port1 5 5.50e-8
C7 5 6 1.04e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.20e-15
R8 8 port2 200
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN75NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN75NJ02
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN75NJ02 port1 port2
C1 port1 port2 1.55e-13
L2 port1 1 9.00e-8
R2 1 port2 5.70
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-7
R4 2 port2 1.35e+3
L5 port1 3 9.70e-7
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 95.0
L7 port1 5 5.50e-8
C7 5 6 1.04e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.20e-15
R8 8 port2 200
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN75NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN7N5H02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 7.74e-9
R2 1 port2 2.95e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 210
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 60.0
.ENDS LQP03TN7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN7N5J02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 7.74e-9
R2 1 port2 2.95e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 210
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 60.0
.ENDS LQP03TN7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN82NH02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN82NH02 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.00e-7
R2 1 port2 6.20
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 100
L7 port1 5 5.50e-8
C7 5 6 1.10e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.40e-15
R8 8 port2 250
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN82NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN82NJ02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN82NJ02 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.00e-7
R2 1 port2 6.20
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 100
L7 port1 5 5.50e-8
C7 5 6 1.10e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.40e-15
R8 8 port2 250
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN82NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN8N2H02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 8.40e-9
R2 1 port2 4.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.50e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 80.0
.ENDS LQP03TN8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN8N2J02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 8.40e-9
R2 1 port2 4.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.50e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 80.0
.ENDS LQP03TN8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN91NH02
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN91NH02 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.13e-7
R2 1 port2 6.35
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 140
L6 port1 4 8.50e-7
R6 4 port2 60.0
L7 port1 5 5.50e-8
C7 5 6 1.35e-14
R7 6 port2 160
L8 port1 7 4.00e-8
C8 7 8 5.40e-15
R8 8 port2 250
.ENDS LQP03TN91NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN91NJ02
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN91NJ02 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.13e-7
R2 1 port2 6.35
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 140
L6 port1 4 8.50e-7
R6 4 port2 60.0
L7 port1 5 5.50e-8
C7 5 6 1.35e-14
R7 6 port2 160
L8 port1 7 4.00e-8
C8 7 8 5.40e-15
R8 8 port2 250
.ENDS LQP03TN91NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN9N1H02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 9.50e-9
R2 1 port2 3.25e-1
R3 port1 port2 7.50e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.30e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 50.0
.ENDS LQP03TN9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN9N1J02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 9.50e-9
R2 1 port2 3.25e-1
R3 port1 port2 7.50e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.30e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 50.0
.ENDS LQP03TN9N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR10H02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR10H02 port1 port2
C1 port1 port2 1.42e-13
L2 port1 1 1.15e-7
R2 1 port2 7.05
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 8.80e-7
R5 3 port2 180
L6 port1 4 3.90e-6
R6 4 port2 250
L7 port1 5 8.66e-8
C7 5 6 9.00e-15
R7 6 port2 180
L8 port1 7 5.06e-8
C8 7 8 4.54e-15
R8 8 port2 191
L9 port1 9 1.39e-8
C9 9 10 8.65e-15
R9 10 port2 120
L10 port1 11 5.68e-9
C10 11 12 1.24e-14
R10 12 port2 80.0
.ENDS LQP03TNR10H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR10J02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR10J02 port1 port2
C1 port1 port2 1.42e-13
L2 port1 1 1.15e-7
R2 1 port2 7.05
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 8.80e-7
R5 3 port2 180
L6 port1 4 3.90e-6
R6 4 port2 250
L7 port1 5 8.66e-8
C7 5 6 9.00e-15
R7 6 port2 180
L8 port1 7 5.06e-8
C8 7 8 4.54e-15
R8 8 port2 191
L9 port1 9 1.39e-8
C9 9 10 8.65e-15
R9 10 port2 120
L10 port1 11 5.68e-9
C10 11 12 1.24e-14
R10 12 port2 80.0
.ENDS LQP03TNR10J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR11H02
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR11H02 port1 port2
C1 port1 port2 1.60e-13
L2 port1 1 1.21e-7
R2 1 port2 7.70
R3 port1 port2 1.40e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 9.00e-7
R5 3 port2 180
L6 port1 4 8.00e-6
R6 4 port2 400
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 5.80e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.30e-15
R9 10 port2 200
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 250
.ENDS LQP03TNR11H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR11J02
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR11J02 port1 port2
C1 port1 port2 1.60e-13
L2 port1 1 1.21e-7
R2 1 port2 7.70
R3 port1 port2 1.40e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 9.00e-7
R5 3 port2 180
L6 port1 4 8.00e-6
R6 4 port2 400
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 5.80e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.30e-15
R9 10 port2 200
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 250
.ENDS LQP03TNR11J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR12H02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR12H02 port1 port2
C1 port1 port2 1.64e-13
L2 port1 1 1.34e-7
R2 1 port2 7.90
R3 port1 port2 1.50e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 8.90e-7
R5 3 port2 205
L6 port1 4 6.80e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 6.08e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.23e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 150
.ENDS LQP03TNR12H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR12J02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR12J02 port1 port2
C1 port1 port2 1.64e-13
L2 port1 1 1.34e-7
R2 1 port2 7.90
R3 port1 port2 1.50e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 8.90e-7
R5 3 port2 205
L6 port1 4 6.80e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 6.08e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.23e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 150
.ENDS LQP03TNR12J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR13H02
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR13H02 port1 port2
C1 port1 port2 1.80e-13
L2 port1 1 1.50e-7
R2 1 port2 5.67
R3 port1 port2 1.00e+4
L4 port1 2 1.00e-6
R4 2 port2 1.20e+3
L5 port1 3 1.50e-6
R5 3 port2 250
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.80e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 9.08e-15
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.50e-15
R9 10 port2 150
L10 port1 11 1.19e-8
C10 11 12 5.57e-15
R10 12 port2 100
.ENDS LQP03TNR13H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR13J02
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR13J02 port1 port2
C1 port1 port2 1.80e-13
L2 port1 1 1.50e-7
R2 1 port2 5.67
R3 port1 port2 1.00e+4
L4 port1 2 1.00e-6
R4 2 port2 1.20e+3
L5 port1 3 1.50e-6
R5 3 port2 250
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.80e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 9.08e-15
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.50e-15
R9 10 port2 150
L10 port1 11 1.19e-8
C10 11 12 5.57e-15
R10 12 port2 100
.ENDS LQP03TNR13J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR15H02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR15H02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 1.79e-7
R2 1 port2 6.20
R3 port1 port2 6.50e+3
L4 port1 2 1.25e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-6
R5 3 port2 165
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.20e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 9.08e-15
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.50e-15
R9 10 port2 150
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 100
.ENDS LQP03TNR15H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR15J02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR15J02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 1.79e-7
R2 1 port2 6.20
R3 port1 port2 6.50e+3
L4 port1 2 1.25e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-6
R5 3 port2 165
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.20e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 9.08e-15
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.50e-15
R9 10 port2 150
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 100
.ENDS LQP03TNR15J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR16H02
* Property : L = 160[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR16H02 port1 port2
C1 port1 port2 2.00e-13
L2 port1 1 1.90e-7
R2 1 port2 6.50
R3 port1 port2 1.00e+4
L4 port1 2 1.10e-6
R4 2 port2 1.20e+3
L5 port1 3 1.60e-6
R5 3 port2 220
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.20e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 1.00e-14
R8 8 port2 400
.ENDS LQP03TNR16H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR16J02
* Property : L = 160[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR16J02 port1 port2
C1 port1 port2 2.00e-13
L2 port1 1 1.90e-7
R2 1 port2 6.50
R3 port1 port2 1.00e+4
L4 port1 2 1.10e-6
R4 2 port2 1.20e+3
L5 port1 3 1.60e-6
R5 3 port2 220
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.20e-14
R7 6 port2 250
L8 port1 7 4.92e-8
C8 7 8 1.00e-14
R8 8 port2 400
.ENDS LQP03TNR16J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR18H02
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR18H02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 2.12e-7
R2 1 port2 7.50
R3 port1 port2 7.50e+3
L4 port1 2 1.40e-6
R4 2 port2 1.20e+3
L5 port1 3 2.15e-6
R5 3 port2 200
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.90e-14
R7 6 port2 300
L8 port1 7 4.92e-8
C8 7 8 1.10e-14
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.20e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 100
.ENDS LQP03TNR18H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR18J02
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR18J02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 2.12e-7
R2 1 port2 7.50
R3 port1 port2 7.50e+3
L4 port1 2 1.40e-6
R4 2 port2 1.20e+3
L5 port1 3 2.15e-6
R5 3 port2 200
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 2.90e-14
R7 6 port2 300
L8 port1 7 4.92e-8
C8 7 8 1.10e-14
R8 8 port2 500
L9 port1 9 2.23e-8
C9 9 10 7.20e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 100
.ENDS LQP03TNR18J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR20H02
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR20H02 port1 port2
C1 port1 port2 2.20e-13
L2 port1 1 2.49e-7
R2 1 port2 7.90
R3 port1 port2 1.10e+4
L4 port1 2 1.35e-6
R4 2 port2 1.20e+3
L5 port1 3 1.60e-6
R5 3 port2 135
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 3.10e-14
R7 6 port2 300
L8 port1 7 4.00e-8
C8 7 8 1.80e-14
R8 8 port2 400
.ENDS LQP03TNR20H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR20J02
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR20J02 port1 port2
C1 port1 port2 2.20e-13
L2 port1 1 2.49e-7
R2 1 port2 7.90
R3 port1 port2 1.10e+4
L4 port1 2 1.35e-6
R4 2 port2 1.20e+3
L5 port1 3 1.60e-6
R5 3 port2 135
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 3.10e-14
R7 6 port2 300
L8 port1 7 4.00e-8
C8 7 8 1.80e-14
R8 8 port2 400
.ENDS LQP03TNR20J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR22H02
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR22H02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 2.65e-7
R2 1 port2 8.50
R3 port1 port2 8.50e+3
L4 port1 2 1.70e-6
R4 2 port2 1.50e+3
L5 port1 3 2.15e-6
R5 3 port2 200
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 3.90e-14
R7 6 port2 300
L8 port1 7 4.92e-8
C8 7 8 1.50e-14
R8 8 port2 500
.ENDS LQP03TNR22H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR22J02
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR22J02 port1 port2
C1 port1 port2 1.94e-13
L2 port1 1 2.65e-7
R2 1 port2 8.50
R3 port1 port2 8.50e+3
L4 port1 2 1.70e-6
R4 2 port2 1.50e+3
L5 port1 3 2.15e-6
R5 3 port2 200
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 3.90e-14
R7 6 port2 300
L8 port1 7 4.92e-8
C8 7 8 1.50e-14
R8 8 port2 500
.ENDS LQP03TNR22J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR24H02
* Property : L = 240[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR24H02 port1 port2
C1 port1 port2 1.95e-13
L2 port1 1 2.95e-7
R2 1 port2 8.75
R3 port1 port2 8.50e+3
L4 port1 2 2.00e-6
R4 2 port2 1.50e+3
L5 port1 3 2.15e-6
R5 3 port2 180
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 4.00e-14
R7 6 port2 500
L8 port1 7 4.92e-8
C8 7 8 1.80e-14
R8 8 port2 600
.ENDS LQP03TNR24H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR24J02
* Property : L = 240[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR24J02 port1 port2
C1 port1 port2 1.95e-13
L2 port1 1 2.95e-7
R2 1 port2 8.75
R3 port1 port2 8.50e+3
L4 port1 2 2.00e-6
R4 2 port2 1.50e+3
L5 port1 3 2.15e-6
R5 3 port2 180
L6 port1 4 7.50e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 4.00e-14
R7 6 port2 500
L8 port1 7 4.92e-8
C8 7 8 1.80e-14
R8 8 port2 600
.ENDS LQP03TNR24J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR27H02
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR27H02 port1 port2
C1 port1 port2 2.10e-13
L2 port1 1 3.25e-7
R2 1 port2 9.50
R3 port1 port2 6.00e+3
L4 port1 2 2.65e-6
R4 2 port2 1.60e+3
L5 port1 3 2.80e-6
R5 3 port2 210
L6 port1 4 7.50e-6
R6 4 port2 250
L7 port1 5 7.07e-8
C7 5 6 4.90e-14
R7 6 port2 300
L8 port1 7 1.00e-7
C8 7 8 9.60e-15
R8 8 port2 400
.ENDS LQP03TNR27H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR27J02
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR27J02 port1 port2
C1 port1 port2 2.10e-13
L2 port1 1 3.25e-7
R2 1 port2 9.50
R3 port1 port2 6.00e+3
L4 port1 2 2.65e-6
R4 2 port2 1.60e+3
L5 port1 3 2.80e-6
R5 3 port2 210
L6 port1 4 7.50e-6
R6 4 port2 250
L7 port1 5 7.07e-8
C7 5 6 4.90e-14
R7 6 port2 300
L8 port1 7 1.00e-7
C8 7 8 9.60e-15
R8 8 port2 400
.ENDS LQP03TNR27J02
*----------------------------------------------------------------------
