*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN10NG80
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN10NG80 port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.96e-7
R4 2 port2 97.8
L5 port1 3 6.01e-7
R5 3 port2 1.35e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN10NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN10NJ80
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN10NJ80 port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.96e-7
R4 2 port2 97.8
L5 port1 3 6.01e-7
R5 3 port2 1.35e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN10NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN11NG80
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN11NG80 port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 1.12e-8
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.48e-7
R4 2 port2 65.5
L5 port1 3 6.13e-7
R5 3 port2 1.30e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN11NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN11NJ80
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN11NJ80 port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 1.12e-8
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.48e-7
R4 2 port2 65.5
L5 port1 3 6.13e-7
R5 3 port2 1.30e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN11NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN12NG80
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN12NG80 port1 port2
C1 port1 port2 4.39e-14
L2 port1 1 1.20e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.98e-7
R4 2 port2 119
L5 port1 3 8.48e-7
R5 3 port2 3.46e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN12NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN12NJ80
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN12NJ80 port1 port2
C1 port1 port2 4.39e-14
L2 port1 1 1.20e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.98e-7
R4 2 port2 119
L5 port1 3 8.48e-7
R5 3 port2 3.46e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN12NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN13NG80
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN13NG80 port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 1.32e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.33e-7
R4 2 port2 45.2
L5 port1 3 5.84e-7
R5 3 port2 1.19e+3
L6 port1 4 2.47e-6
C6 4 5 6.62e-17
R6 5 port2 281
.ENDS LQW18AN13NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN13NJ80
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN13NJ80 port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 1.32e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.33e-7
R4 2 port2 45.2
L5 port1 3 5.84e-7
R5 3 port2 1.19e+3
L6 port1 4 2.47e-6
C6 4 5 6.62e-17
R6 5 port2 281
.ENDS LQW18AN13NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN15NG80
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN15NG80 port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 1.51e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.87e-7
R4 2 port2 98.7
L5 port1 3 7.74e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN15NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN15NJ80
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN15NJ80 port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 1.51e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.87e-7
R4 2 port2 98.7
L5 port1 3 7.74e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN15NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN16NG80
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN16NG80 port1 port2
C1 port1 port2 3.74e-14
L2 port1 1 1.62e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.34e-7
R4 2 port2 98.7
L5 port1 3 7.56e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 1.15e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.59e-15
R7 7 port2 365
.ENDS LQW18AN16NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN16NJ80
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN16NJ80 port1 port2
C1 port1 port2 3.74e-14
L2 port1 1 1.62e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.34e-7
R4 2 port2 98.7
L5 port1 3 7.56e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 1.15e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.59e-15
R7 7 port2 365
.ENDS LQW18AN16NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN17NG80
* Property : L = 17[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN17NG80 port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.74e-8
R2 1 port2 6.64e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.14e-7
R4 2 port2 98.7
L5 port1 3 7.39e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 8.53e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.18e-15
R7 7 port2 365
.ENDS LQW18AN17NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN17NJ80
* Property : L = 17[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN17NJ80 port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.74e-8
R2 1 port2 6.64e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.14e-7
R4 2 port2 98.7
L5 port1 3 7.39e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 8.53e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.18e-15
R7 7 port2 365
.ENDS LQW18AN17NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN18NG80
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN18NG80 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 1.82e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.49e-7
R4 2 port2 128
L5 port1 3 1.09e-6
R5 3 port2 2.10e+3
L6 port1 4 2.47e-6
C6 4 5 1.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.29e-15
R7 7 port2 365
.ENDS LQW18AN18NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN18NJ80
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN18NJ80 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 1.82e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.49e-7
R4 2 port2 128
L5 port1 3 1.09e-6
R5 3 port2 2.10e+3
L6 port1 4 2.47e-6
C6 4 5 1.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.29e-15
R7 7 port2 365
.ENDS LQW18AN18NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN19NG80
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN19NG80 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.95e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.51e-7
R4 2 port2 49.5
L5 port1 3 7.84e-7
R5 3 port2 897
L6 port1 4 2.47e-6
C6 4 5 1.05e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 365
.ENDS LQW18AN19NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN19NJ80
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN19NJ80 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.95e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.51e-7
R4 2 port2 49.5
L5 port1 3 7.84e-7
R5 3 port2 897
L6 port1 4 2.47e-6
C6 4 5 1.05e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 365
.ENDS LQW18AN19NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN22NG80
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN22NG80 port1 port2
C1 port1 port2 4.82e-14
L2 port1 1 2.29e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.43e-7
R4 2 port2 71.1
L5 port1 3 1.04e-6
R5 3 port2 1.52e+3
L6 port1 4 2.47e-6
C6 4 5 1.55e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN22NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN22NJ80
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN22NJ80 port1 port2
C1 port1 port2 4.82e-14
L2 port1 1 2.29e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.43e-7
R4 2 port2 71.1
L5 port1 3 1.04e-6
R5 3 port2 1.52e+3
L6 port1 4 2.47e-6
C6 4 5 1.55e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN22NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN23NG80
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN23NG80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.40e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.41e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN23NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN23NJ80
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN23NJ80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.40e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.41e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN23NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN24NG80
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN24NG80 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.51e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.10e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.44e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.55e-15
R7 7 port2 365
.ENDS LQW18AN24NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN24NJ80
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN24NJ80 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.51e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.10e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.44e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.55e-15
R7 7 port2 365
.ENDS LQW18AN24NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN25NG80
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN25NG80 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 2.63e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.23e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.04e-15
R7 7 port2 365
.ENDS LQW18AN25NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN25NJ80
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN25NJ80 port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 2.63e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.23e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.04e-15
R7 7 port2 365
.ENDS LQW18AN25NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN27NG80
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN27NG80 port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 2.75e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.35e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN27NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN27NJ80
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN27NJ80 port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 2.75e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.35e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN27NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN28NG80
* Property : L = 28[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN28NG80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.95e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.80e-7
R4 2 port2 79.6
L5 port1 3 1.26e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN28NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN28NJ80
* Property : L = 28[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN28NJ80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.95e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.80e-7
R4 2 port2 79.6
L5 port1 3 1.26e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN28NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN2N2C80
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN2N2C80 port1 port2
C1 port1 port2 6.09e-14
L2 port1 1 1.94e-9
R2 1 port2 1.50e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.10e-8
R4 2 port2 9.71
L5 port1 3 4.91e-8
R5 3 port2 180
.ENDS LQW18AN2N2C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN2N4C80
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN2N4C80 port1 port2
C1 port1 port2 5.95e-14
L2 port1 1 2.03e-9
R2 1 port2 2.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 6.19e-8
R4 2 port2 54.9
L5 port1 3 7.07e-8
R5 3 port2 323
.ENDS LQW18AN2N4C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN30NG80
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN30NG80 port1 port2
C1 port1 port2 6.64e-14
L2 port1 1 3.16e-8
R2 1 port2 1.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.45e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN30NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN30NJ80
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN30NJ80 port1 port2
C1 port1 port2 6.64e-14
L2 port1 1 3.16e-8
R2 1 port2 1.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.45e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN30NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN31NG80
* Property : L = 31[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN31NG80 port1 port2
C1 port1 port2 4.09e-14
L2 port1 1 3.23e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.78e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.57e-15
R7 7 port2 365
.ENDS LQW18AN31NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN31NJ80
* Property : L = 31[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN31NJ80 port1 port2
C1 port1 port2 4.09e-14
L2 port1 1 3.23e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.78e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.57e-15
R7 7 port2 365
.ENDS LQW18AN31NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN33NG80
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN33NG80 port1 port2
C1 port1 port2 4.49e-14
L2 port1 1 3.46e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.68e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.51e-15
R7 7 port2 365
.ENDS LQW18AN33NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN33NJ80
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN33NJ80 port1 port2
C1 port1 port2 4.49e-14
L2 port1 1 3.46e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.68e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.51e-15
R7 7 port2 365
.ENDS LQW18AN33NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN34NG80
* Property : L = 34[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN34NG80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 3.54e-8
R2 1 port2 1.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.03e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.09e-15
R7 7 port2 365
.ENDS LQW18AN34NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN34NJ80
* Property : L = 34[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN34NJ80 port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 3.54e-8
R2 1 port2 1.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.03e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.09e-15
R7 7 port2 365
.ENDS LQW18AN34NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN36NG80
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN36NG80 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 3.79e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN36NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN36NJ80
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN36NJ80 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 3.79e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN36NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN37NG80
* Property : L = 37[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN37NG80 port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 3.88e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.89e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.18e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN37NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN37NJ80
* Property : L = 37[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN37NJ80 port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 3.88e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.89e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.18e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN37NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN39NG80
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN39NG80 port1 port2
C1 port1 port2 3.10e-14
L2 port1 1 4.16e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 5.23e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 183
.ENDS LQW18AN39NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN39NJ80
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN39NJ80 port1 port2
C1 port1 port2 3.10e-14
L2 port1 1 4.16e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 5.23e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 183
.ENDS LQW18AN39NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N0C80
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N0C80 port1 port2
C1 port1 port2 4.51e-14
L2 port1 1 2.62e-9
R2 1 port2 1.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.43e-8
R4 2 port2 234
L5 port1 3 1.26e-7
R5 3 port2 125
.ENDS LQW18AN3N0C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9B80
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9B80 port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9C80
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9C80 port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9G80
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9G80 port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN41NG80
* Property : L = 41[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN41NG80 port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 4.36e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.17e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.08e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.95e-15
R7 7 port2 183
.ENDS LQW18AN41NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN41NJ80
* Property : L = 41[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN41NJ80 port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 4.36e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.17e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.08e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.95e-15
R7 7 port2 183
.ENDS LQW18AN41NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN43NG80
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN43NG80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 4.56e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.92e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.62e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.75e-15
R7 7 port2 183
.ENDS LQW18AN43NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN43NJ80
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN43NJ80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 4.56e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.92e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.62e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.75e-15
R7 7 port2 183
.ENDS LQW18AN43NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN44NG80
* Property : L = 44[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN44NG80 port1 port2
C1 port1 port2 5.03e-14
L2 port1 1 4.67e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.61e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.88e-15
R7 7 port2 183
.ENDS LQW18AN44NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN44NJ80
* Property : L = 44[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN44NJ80 port1 port2
C1 port1 port2 5.03e-14
L2 port1 1 4.67e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.61e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.88e-15
R7 7 port2 183
.ENDS LQW18AN44NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN47NG80
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN47NG80 port1 port2
C1 port1 port2 4.48e-14
L2 port1 1 5.00e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.08e-7
R4 2 port2 79.6
L5 port1 3 2.06e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.74e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.71e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN47NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN47NJ80
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN47NJ80 port1 port2
C1 port1 port2 4.48e-14
L2 port1 1 5.00e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.08e-7
R4 2 port2 79.6
L5 port1 3 2.06e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.74e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.71e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN47NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN48NG80
* Property : L = 48[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN48NG80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 5.12e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.01e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.56e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN48NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN48NJ80
* Property : L = 48[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN48NJ80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 5.12e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.01e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.56e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN48NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1B80
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1B80 port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1C80
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1C80 port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1G80
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1G80 port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2B80
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2B80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2C80
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2C80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2G80
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2G80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3B80
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3B80 port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3C80
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3C80 port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3G80
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3G80 port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7B80
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7B80 port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7C80
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7C80 port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7G80
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7G80 port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9B80
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9B80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9B80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9C80
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9C80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9G80
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9G80 port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN51NG80
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN51NG80 port1 port2
C1 port1 port2 4.69e-14
L2 port1 1 5.36e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.00e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.67e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.28e-16
R8 9 port2 578
.ENDS LQW18AN51NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN51NJ80
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN51NJ80 port1 port2
C1 port1 port2 4.69e-14
L2 port1 1 5.36e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.00e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.67e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.28e-16
R8 9 port2 578
.ENDS LQW18AN51NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN52NG80
* Property : L = 52[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN52NG80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 5.61e-8
R2 1 port2 2.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 1.97e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.52e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.80e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.33e-16
R8 9 port2 578
.ENDS LQW18AN52NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN52NJ80
* Property : L = 52[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN52NJ80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 5.61e-8
R2 1 port2 2.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 1.97e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.52e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.80e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.33e-16
R8 9 port2 578
.ENDS LQW18AN52NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN56NG80
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN56NG80 port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 6.01e-8
R2 1 port2 2.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 2.54e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.78e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.89e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.44e-16
R8 9 port2 578
.ENDS LQW18AN56NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN56NJ80
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN56NJ80 port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 6.01e-8
R2 1 port2 2.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 2.54e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.78e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.89e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.44e-16
R8 9 port2 578
.ENDS LQW18AN56NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN58NG80
* Property : L = 58[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN58NG80 port1 port2
C1 port1 port2 4.38e-14
L2 port1 1 6.29e-8
R2 1 port2 2.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.90e-7
R4 2 port2 79.6
L5 port1 3 2.11e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.96e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.46e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.74e-16
R8 9 port2 578
.ENDS LQW18AN58NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN58NJ80
* Property : L = 58[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN58NJ80 port1 port2
C1 port1 port2 4.38e-14
L2 port1 1 6.29e-8
R2 1 port2 2.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.90e-7
R4 2 port2 79.6
L5 port1 3 2.11e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.96e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.46e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.74e-16
R8 9 port2 578
.ENDS LQW18AN58NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN5N6C80
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN5N6C80 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 5.47e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.01e-7
R4 2 port2 142
L5 port1 3 3.67e-7
R5 3 port2 1.41e+3
.ENDS LQW18AN5N6C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN5N6G80
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN5N6G80 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 5.47e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.01e-7
R4 2 port2 142
L5 port1 3 3.67e-7
R5 3 port2 1.41e+3
.ENDS LQW18AN5N6G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN68NG80
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN68NG80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 7.39e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.02e-6
R4 2 port2 79.6
L5 port1 3 2.79e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.54e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.00e-16
R8 9 port2 578
.ENDS LQW18AN68NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN68NJ80
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN68NJ80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 7.39e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.02e-6
R4 2 port2 79.6
L5 port1 3 2.79e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.54e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.00e-16
R8 9 port2 578
.ENDS LQW18AN68NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN69NG80
* Property : L = 69[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN69NG80 port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 7.56e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 9.74e-7
R4 2 port2 79.6
L5 port1 3 2.43e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.73e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.99e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 1.47e-16
R8 9 port2 578
.ENDS LQW18AN69NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN69NJ80
* Property : L = 69[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN69NJ80 port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 7.56e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 9.74e-7
R4 2 port2 79.6
L5 port1 3 2.43e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.73e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.99e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 1.47e-16
R8 9 port2 578
.ENDS LQW18AN69NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N0C80
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N0C80 port1 port2
C1 port1 port2 1.64e-14
L2 port1 1 5.60e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 215
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N0C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N0G80
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N0G80 port1 port2
C1 port1 port2 1.64e-14
L2 port1 1 5.60e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 215
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N0G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N5C80
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N5C80 port1 port2
C1 port1 port2 2.98e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.76e-7
R4 2 port2 152
L5 port1 3 3.16e-7
R5 3 port2 1.25e+3
L6 port1 4 2.62e-7
C6 4 5 5.14e-16
R6 5 port2 600
L7 port1 6 1.95e-7
C7 6 7 3.90e-16
R7 7 port2 222
.ENDS LQW18AN6N5C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N5G80
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N5G80 port1 port2
C1 port1 port2 2.98e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.76e-7
R4 2 port2 152
L5 port1 3 3.16e-7
R5 3 port2 1.25e+3
L6 port1 4 2.62e-7
C6 4 5 5.14e-16
R6 5 port2 600
L7 port1 6 1.95e-7
C7 6 7 3.90e-16
R7 7 port2 222
.ENDS LQW18AN6N5G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N8C80
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N8C80 port1 port2
C1 port1 port2 3.93e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 156
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N8C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N8G80
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N8G80 port1 port2
C1 port1 port2 3.93e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 156
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N8G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN72NG80
* Property : L = 72[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN72NG80 port1 port2
C1 port1 port2 3.90e-14
L2 port1 1 7.92e-8
R2 1 port2 3.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.17e-6
R4 2 port2 79.6
L5 port1 3 2.99e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.65e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.75e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.07e-16
R8 9 port2 578
.ENDS LQW18AN72NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN72NJ80
* Property : L = 72[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN72NJ80 port1 port2
C1 port1 port2 3.90e-14
L2 port1 1 7.92e-8
R2 1 port2 3.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.17e-6
R4 2 port2 79.6
L5 port1 3 2.99e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.65e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.75e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.07e-16
R8 9 port2 578
.ENDS LQW18AN72NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN73NG80
* Property : L = 73[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN73NG80 port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.20e-6
R4 2 port2 79.6
L5 port1 3 2.49e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.40e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.61e-16
R8 9 port2 578
.ENDS LQW18AN73NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN73NJ80
* Property : L = 73[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN73NJ80 port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.20e-6
R4 2 port2 79.6
L5 port1 3 2.49e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.40e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.61e-16
R8 9 port2 578
.ENDS LQW18AN73NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN75NG80
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN75NG80 port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.84e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.95e-16
R8 9 port2 578
.ENDS LQW18AN75NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN75NJ80
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN75NJ80 port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.84e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.95e-16
R8 9 port2 578
.ENDS LQW18AN75NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN78NG80
* Property : L = 78[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN78NG80 port1 port2
C1 port1 port2 3.39e-14
L2 port1 1 8.10e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.03e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.72e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.91e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.86e-16
R8 9 port2 578
.ENDS LQW18AN78NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN78NJ80
* Property : L = 78[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN78NJ80 port1 port2
C1 port1 port2 3.39e-14
L2 port1 1 8.10e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.03e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.72e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.91e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.86e-16
R8 9 port2 578
.ENDS LQW18AN78NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N2C80
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N2C80 port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 7.05e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.89e-7
R4 2 port2 168
L5 port1 3 4.66e-7
R5 3 port2 1.40e+3
.ENDS LQW18AN7N2C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N2G80
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N2G80 port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 7.05e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.89e-7
R4 2 port2 168
L5 port1 3 4.66e-7
R5 3 port2 1.40e+3
.ENDS LQW18AN7N2G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N5C80
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N5C80 port1 port2
C1 port1 port2 3.84e-14
L2 port1 1 7.38e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.83e-7
R4 2 port2 50.6
L5 port1 3 3.25e-7
R5 3 port2 802
.ENDS LQW18AN7N5C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N5G80
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N5G80 port1 port2
C1 port1 port2 3.84e-14
L2 port1 1 7.38e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.83e-7
R4 2 port2 50.6
L5 port1 3 3.25e-7
R5 3 port2 802
.ENDS LQW18AN7N5G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN82NG80
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN82NG80 port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.49e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.71e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.05e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN82NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN82NJ80
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN82NJ80 port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.49e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.71e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.05e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN82NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN83NG80
* Property : L = 83[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN83NG80 port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.69e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.87e-6
R4 2 port2 255
L5 port1 3 3.39e-6
R5 3 port2 2.38e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.67e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN83NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN83NJ80
* Property : L = 83[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN83NJ80 port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.69e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.87e-6
R4 2 port2 255
L5 port1 3 3.39e-6
R5 3 port2 2.38e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.67e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN83NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N2C80
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N2C80 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 8.09e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.38e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N2C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N2G80
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N2G80 port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 8.09e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.38e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N2G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N4C80
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N4C80 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 8.40e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.27e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N4C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N4G80
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N4G80 port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 8.40e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.27e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N4G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N7C80
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N7C80 port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 8.50e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.77e-7
R4 2 port2 118
L5 port1 3 4.72e-7
R5 3 port2 1.06e+3
.ENDS LQW18AN8N7C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N7G80
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N7G80 port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 8.50e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.77e-7
R4 2 port2 118
L5 port1 3 4.72e-7
R5 3 port2 1.06e+3
.ENDS LQW18AN8N7G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN91NG80
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN91NG80 port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 9.53e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.11e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.85e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.15e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN91NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN91NJ80
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN91NJ80 port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 9.53e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.11e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.85e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.15e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN91NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN94NG80
* Property : L = 94[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN94NG80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 9.75e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.25e-6
R4 2 port2 255
L5 port1 3 4.02e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.75e-15
R7 7 port2 183
L8 port1 8 1.53e-7
C8 8 9 1.23e-15
R8 9 port2 793
L9 port1 10 7.12e-7
C9 10 11 1.25e-16
R9 11 port2 3.80e+3
.ENDS LQW18AN94NG80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN94NJ80
* Property : L = 94[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN94NJ80 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 9.75e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.25e-6
R4 2 port2 255
L5 port1 3 4.02e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.75e-15
R7 7 port2 183
L8 port1 8 1.53e-7
C8 8 9 1.23e-15
R8 9 port2 793
L9 port1 10 7.12e-7
C9 10 11 1.25e-16
R9 11 port2 3.80e+3
.ENDS LQW18AN94NJ80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N1C80
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N1C80 port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.90e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.79e-7
R4 2 port2 123
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.71e-6
C6 4 5 4.91e-17
R6 5 port2 2.68e+3
.ENDS LQW18AN9N1C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N1G80
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N1G80 port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.90e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.79e-7
R4 2 port2 123
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.71e-6
C6 4 5 4.91e-17
R6 5 port2 2.68e+3
.ENDS LQW18AN9N1G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N5C80
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N5C80 port1 port2
C1 port1 port2 3.49e-14
L2 port1 1 9.32e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.41e-7
R4 2 port2 115
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN9N5C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N5G80
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N5G80 port1 port2
C1 port1 port2 3.49e-14
L2 port1 1 9.32e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.41e-7
R4 2 port2 115
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN9N5G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N9C80
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N9C80 port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.07e-7
R4 2 port2 63.4
L5 port1 3 5.48e-7
R5 3 port2 1.97e+3
L6 port1 4 2.47e-6
C6 4 5 3.72e-17
R6 5 port2 281
.ENDS LQW18AN9N9C80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N9G80
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N9G80 port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.07e-7
R4 2 port2 63.4
L5 port1 3 5.48e-7
R5 3 port2 1.97e+3
L6 port1 4 2.47e-6
C6 4 5 3.72e-17
R6 5 port2 281
.ENDS LQW18AN9N9G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR10G80
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR10G80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 1.02e-7
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.09e-6
R4 2 port2 373
L5 port1 3 9.54e-6
R5 3 port2 9.45e+3
L6 port1 4 2.47e-6
C6 4 5 7.89e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 8.70e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.65e-15
R10 13 port2 405
.ENDS LQW18ANR10G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR10J80
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR10J80 port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 1.02e-7
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.09e-6
R4 2 port2 373
L5 port1 3 9.54e-6
R5 3 port2 9.45e+3
L6 port1 4 2.47e-6
C6 4 5 7.89e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 8.70e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.65e-15
R10 13 port2 405
.ENDS LQW18ANR10J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR11G80
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR11G80 port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 1.14e-7
R2 1 port2 5.80e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.83e-6
R4 2 port2 818
L5 port1 3 1.90e-5
R5 3 port2 8.08e+3
L6 port1 4 2.47e-6
C6 4 5 8.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.76e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 7.36e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.92e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.89e-15
R10 13 port2 405
.ENDS LQW18ANR11G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR11J80
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR11J80 port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 1.14e-7
R2 1 port2 5.80e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.83e-6
R4 2 port2 818
L5 port1 3 1.90e-5
R5 3 port2 8.08e+3
L6 port1 4 2.47e-6
C6 4 5 8.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.76e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 7.36e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.92e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.89e-15
R10 13 port2 405
.ENDS LQW18ANR11J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR12G80
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR12G80 port1 port2
C1 port1 port2 3.48e-14
L2 port1 1 1.25e-7
R2 1 port2 6.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.10e-6
R4 2 port2 818
L5 port1 3 1.73e-5
R5 3 port2 7.20e+3
L6 port1 4 2.47e-6
C6 4 5 9.48e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.17e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 4.75e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.61e-15
R10 13 port2 405
.ENDS LQW18ANR12G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR12J80
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR12J80 port1 port2
C1 port1 port2 3.48e-14
L2 port1 1 1.25e-7
R2 1 port2 6.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.10e-6
R4 2 port2 818
L5 port1 3 1.73e-5
R5 3 port2 7.20e+3
L6 port1 4 2.47e-6
C6 4 5 9.48e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.17e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 4.75e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.61e-15
R10 13 port2 405
.ENDS LQW18ANR12J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR15G80
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR15G80 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-7
R2 1 port2 7.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.91e-6
R4 2 port2 1.19e+3
L5 port1 3 9.25e-5
R5 3 port2 1.67e+4
L6 port1 4 2.47e-6
C6 4 5 1.17e-15
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.08e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.25e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.83e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR15G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR15J80
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR15J80 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-7
R2 1 port2 7.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.91e-6
R4 2 port2 1.19e+3
L5 port1 3 9.25e-5
R5 3 port2 1.67e+4
L6 port1 4 2.47e-6
C6 4 5 1.17e-15
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.08e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.25e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.83e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR15J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR18G80
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR18G80 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 1.85e-7
R2 1 port2 1.37
R3 port1 port2 2.28e+4
L4 port1 2 5.01e-6
R4 2 port2 962
L5 port1 3 4.81e-4
R5 3 port2 6.84e+3
L6 port1 4 2.47e-6
C6 4 5 1.20e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.32e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 9.69e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.96e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR18G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR18J80
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR18J80 port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 1.85e-7
R2 1 port2 1.37
R3 port1 port2 2.28e+4
L4 port1 2 5.01e-6
R4 2 port2 962
L5 port1 3 4.81e-4
R5 3 port2 6.84e+3
L6 port1 4 2.47e-6
C6 4 5 1.20e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.32e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 9.69e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.96e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR18J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR20G80
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR20G80 port1 port2
C1 port1 port2 3.80e-14
L2 port1 1 2.03e-7
R2 1 port2 1.45
R3 port1 port2 2.28e+4
L4 port1 2 5.78e-6
R4 2 port2 1.19e+3
L5 port1 3 2.77e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.09e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.20e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR20G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR20J80
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR20J80 port1 port2
C1 port1 port2 3.80e-14
L2 port1 1 2.03e-7
R2 1 port2 1.45
R3 port1 port2 2.28e+4
L4 port1 2 5.78e-6
R4 2 port2 1.19e+3
L5 port1 3 2.77e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.09e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.20e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR20J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR21G80
* Property : L = 210[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR21G80 port1 port2
C1 port1 port2 4.07e-14
L2 port1 1 2.13e-7
R2 1 port2 1.65
R3 port1 port2 2.28e+4
L4 port1 2 6.64e-6
R4 2 port2 1.19e+3
L5 port1 3 2.15e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.36e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.17e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.30e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR21G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR21J80
* Property : L = 210[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR21J80 port1 port2
C1 port1 port2 4.07e-14
L2 port1 1 2.13e-7
R2 1 port2 1.65
R3 port1 port2 2.28e+4
L4 port1 2 6.64e-6
R4 2 port2 1.19e+3
L5 port1 3 2.15e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.36e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.17e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.30e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR21J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR22G80
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR22G80 port1 port2
C1 port1 port2 3.98e-14
L2 port1 1 2.28e-7
R2 1 port2 1.73
R3 port1 port2 2.28e+4
L4 port1 2 6.75e-6
R4 2 port2 1.36e+3
L5 port1 3 2.88e-4
R5 3 port2 1.45e+4
L6 port1 4 2.47e-6
C6 4 5 1.69e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.30e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.14e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.41e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.76e-15
R10 13 port2 405
.ENDS LQW18ANR22G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR22J80
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR22J80 port1 port2
C1 port1 port2 3.98e-14
L2 port1 1 2.28e-7
R2 1 port2 1.73
R3 port1 port2 2.28e+4
L4 port1 2 6.75e-6
R4 2 port2 1.36e+3
L5 port1 3 2.88e-4
R5 3 port2 1.45e+4
L6 port1 4 2.47e-6
C6 4 5 1.69e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.30e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.14e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.41e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.76e-15
R10 13 port2 405
.ENDS LQW18ANR22J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR25G80
* Property : L = 250[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR25G80 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 2.56e-7
R2 1 port2 1.90
R3 port1 port2 2.28e+4
L4 port1 2 7.28e-6
R4 2 port2 1.19e+3
L5 port1 3 7.21e-5
R5 3 port2 1.33e+3
L6 port1 4 2.47e-6
C6 4 5 8.47e-16
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.40e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 3.25e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 2.17e-15
R10 13 port2 405
.ENDS LQW18ANR25G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR25J80
* Property : L = 250[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR25J80 port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 2.56e-7
R2 1 port2 1.90
R3 port1 port2 2.28e+4
L4 port1 2 7.28e-6
R4 2 port2 1.19e+3
L5 port1 3 7.21e-5
R5 3 port2 1.33e+3
L6 port1 4 2.47e-6
C6 4 5 8.47e-16
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.40e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 3.25e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 2.17e-15
R10 13 port2 405
.ENDS LQW18ANR25J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR27G80
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR27G80 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.74e-7
R2 1 port2 1.92
R3 port1 port2 2.28e+4
L4 port1 2 9.69e-6
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.80e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.32e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 6.64e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.75e-15
R10 13 port2 405
.ENDS LQW18ANR27G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR27J80
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR27J80 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.74e-7
R2 1 port2 1.92
R3 port1 port2 2.28e+4
L4 port1 2 9.69e-6
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.80e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.32e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 6.64e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.75e-15
R10 13 port2 405
.ENDS LQW18ANR27J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR30G80
* Property : L = 300[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR30G80 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 3.07e-7
R2 1 port2 2.60
R3 port1 port2 2.28e+4
L4 port1 2 1.31e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.02e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR30G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR30J80
* Property : L = 300[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR30J80 port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 3.07e-7
R2 1 port2 2.60
R3 port1 port2 2.28e+4
L4 port1 2 1.31e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.02e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR30J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR33G80
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR33G80 port1 port2
C1 port1 port2 2.51e-14
L2 port1 1 3.37e-7
R2 1 port2 3.20
R3 port1 port2 2.28e+4
L4 port1 2 1.94e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 3.15e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR33G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR33J80
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR33J80 port1 port2
C1 port1 port2 2.51e-14
L2 port1 1 3.37e-7
R2 1 port2 3.20
R3 port1 port2 2.28e+4
L4 port1 2 1.94e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 3.15e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR33J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR36G80
* Property : L = 360[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR36G80 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 3.61e-7
R2 1 port2 3.31
R3 port1 port2 2.28e+4
L4 port1 2 1.99e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 3.38e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.53e-15
R10 13 port2 405
.ENDS LQW18ANR36G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR36J80
* Property : L = 360[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR36J80 port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 3.61e-7
R2 1 port2 3.31
R3 port1 port2 2.28e+4
L4 port1 2 1.99e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 3.38e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.53e-15
R10 13 port2 405
.ENDS LQW18ANR36J80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR39G80
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR39G80 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 3.96e-7
R2 1 port2 3.52
R3 port1 port2 2.28e+4
L4 port1 2 2.04e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 1.48e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.02e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.67e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 5.66e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.24e-15
R10 13 port2 405
.ENDS LQW18ANR39G80
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR39J80
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR39J80 port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 3.96e-7
R2 1 port2 3.52
R3 port1 port2 2.28e+4
L4 port1 2 2.04e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 1.48e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.02e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.67e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 5.66e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.24e-15
R10 13 port2 405
.ENDS LQW18ANR39J80
*----------------------------------------------------------------------
