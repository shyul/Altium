*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H100FB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H100FB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 8.00e-02
L04 N03 N04 6.08e-12
R04 N03 N04 1.07e-01
C05 N04 N05 4.67e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.40e+01
C06 N05 N06 4.08e-11
L06 N05 N06 8.15e-12
R06 N05 N06 2.10e+00
C07 N06 Port2 1.89e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H100FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H100GB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 8.00e-02
L04 N03 N04 6.08e-12
R04 N03 N04 1.07e-01
C05 N04 N05 4.67e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.40e+01
C06 N05 N06 4.08e-11
L06 N05 N06 8.15e-12
R06 N05 N06 2.10e+00
C07 N06 Port2 1.89e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H100GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H100JB01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 8.00e-02
L04 N03 N04 6.08e-12
R04 N03 N04 1.07e-01
C05 N04 N05 4.67e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.40e+01
C06 N05 N06 4.08e-11
L06 N05 N06 8.15e-12
R06 N05 N06 2.10e+00
C07 N06 Port2 1.89e-12
L07 N06 Port2 1.31e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H100JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H110GB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.91e-02
L04 N03 N04 5.59e-12
R04 N03 N04 9.79e-02
C05 N04 N05 4.47e-11
L05 N04 N05 1.39e-11
R05 N04 N05 1.37e+01
C06 N05 N06 4.59e-12
L06 N05 N06 5.35e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 4.22e-12
L07 N06 Port2 4.95e-11
R07 N06 Port2 7.37e+01
.ENDS GCQ1555C1H110GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H110JB01
* Property : C = 1.10e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.81e-10
R03 N02 N03 7.91e-02
L04 N03 N04 5.59e-12
R04 N03 N04 9.79e-02
C05 N04 N05 4.47e-11
L05 N04 N05 1.39e-11
R05 N04 N05 1.37e+01
C06 N05 N06 4.59e-12
L06 N05 N06 5.35e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 4.22e-12
L07 N06 Port2 4.95e-11
R07 N06 Port2 7.37e+01
.ENDS GCQ1555C1H110JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H120FB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H120FB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.70e-11
R03 N02 N03 8.00e-02
L04 N03 N04 5.86e-12
R04 N03 N04 7.37e-02
C05 N04 N05 1.34e-12
L05 N04 N05 1.71e-10
C06 N05 N06 2.34e-11
L06 N05 N06 1.35e-11
R06 N05 N06 7.91e+00
C07 N06 Port2 6.03e-11
L07 N06 Port2 1.17e-11
R07 N06 Port2 1.17e+01
.ENDS GCQ1555C1H120FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H120GB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.70e-11
R03 N02 N03 8.00e-02
L04 N03 N04 5.86e-12
R04 N03 N04 7.37e-02
C05 N04 N05 1.34e-12
L05 N04 N05 1.71e-10
C06 N05 N06 2.34e-11
L06 N05 N06 1.35e-11
R06 N05 N06 7.91e+00
C07 N06 Port2 6.03e-11
L07 N06 Port2 1.17e-11
R07 N06 Port2 1.17e+01
.ENDS GCQ1555C1H120GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H120JB01
* Property : C = 1.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H120JB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.70e-11
R03 N02 N03 8.00e-02
L04 N03 N04 5.86e-12
R04 N03 N04 7.37e-02
C05 N04 N05 1.34e-12
L05 N04 N05 1.71e-10
C06 N05 N06 2.34e-11
L06 N05 N06 1.35e-11
R06 N05 N06 7.91e+00
C07 N06 Port2 6.03e-11
L07 N06 Port2 1.17e-11
R07 N06 Port2 1.17e+01
.ENDS GCQ1555C1H120JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H130GB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.24e-11
R03 N02 N03 7.89e-02
L04 N03 N04 7.37e-12
R04 N03 N04 4.70e-01
L05 N04 N05 9.88e-12
R05 N04 N05 2.73e-02
C06 N05 N06 5.73e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.19e+01
C07 N06 N07 5.31e-12
L07 N06 N07 5.07e-11
R07 N06 N07 7.90e+01
C08 N07 Port2 1.53e-12
L08 N07 Port2 1.59e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H130GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H130JB01
* Property : C = 1.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.24e-11
R03 N02 N03 7.89e-02
L04 N03 N04 7.37e-12
R04 N03 N04 4.70e-01
L05 N04 N05 9.88e-12
R05 N04 N05 2.73e-02
C06 N05 N06 5.73e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.19e+01
C07 N06 N07 5.31e-12
L07 N06 N07 5.07e-11
R07 N06 N07 7.90e+01
C08 N07 Port2 1.53e-12
L08 N07 Port2 1.59e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H130JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H150FB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H150FB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-11
R03 N02 N03 7.92e-02
L04 N03 N04 3.95e-12
R04 N03 N04 8.90e-02
C05 N04 N05 7.22e-11
L05 N04 N05 1.17e-11
R05 N04 N05 1.08e+01
C06 N05 N06 7.71e-12
L06 N05 N06 4.36e-11
R06 N05 N06 5.51e+01
C07 N06 Port2 6.98e-13
L07 N06 Port2 2.14e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H150FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H150GB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-11
R03 N02 N03 7.92e-02
L04 N03 N04 3.95e-12
R04 N03 N04 8.90e-02
C05 N04 N05 7.22e-11
L05 N04 N05 1.17e-11
R05 N04 N05 1.08e+01
C06 N05 N06 7.71e-12
L06 N05 N06 4.36e-11
R06 N05 N06 5.51e+01
C07 N06 Port2 6.98e-13
L07 N06 Port2 2.14e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H150GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H150JB01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-11
R03 N02 N03 7.92e-02
L04 N03 N04 3.95e-12
R04 N03 N04 8.90e-02
C05 N04 N05 7.22e-11
L05 N04 N05 1.17e-11
R05 N04 N05 1.08e+01
C06 N05 N06 7.71e-12
L06 N05 N06 4.36e-11
R06 N05 N06 5.51e+01
C07 N06 Port2 6.98e-13
L07 N06 Port2 2.14e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H150JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H160GB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 7.35e-02
L04 N03 N04 7.87e-12
R04 N03 N04 2.84e-02
C05 N04 N05 7.02e-11
L05 N04 N05 1.28e-11
R05 N04 N05 1.04e+01
C06 N05 Port2 7.18e-12
L06 N05 Port2 5.20e-11
R06 N05 Port2 6.84e+01
.ENDS GCQ1555C1H160GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H160JB01
* Property : C = 1.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 7.35e-02
L04 N03 N04 7.87e-12
R04 N03 N04 2.84e-02
C05 N04 N05 7.02e-11
L05 N04 N05 1.28e-11
R05 N04 N05 1.04e+01
C06 N05 Port2 7.18e-12
L06 N05 Port2 5.20e-11
R06 N05 Port2 6.84e+01
.ENDS GCQ1555C1H160JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H180FB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H180FB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 3.12e-12
R04 N03 N04 3.92e-02
C05 N04 N05 9.44e-13
L05 N04 N05 1.99e-10
C06 N05 N06 6.96e-12
L06 N05 N06 3.01e-11
R06 N05 N06 2.23e+01
C07 N06 N07 1.17e-11
L07 N06 N07 3.80e-11
R07 N06 N07 4.21e+01
C08 N07 Port2 8.73e-11
L08 N07 Port2 1.21e-11
R08 N07 Port2 1.06e+01
.ENDS GCQ1555C1H180FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H180GB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 3.12e-12
R04 N03 N04 3.92e-02
C05 N04 N05 9.44e-13
L05 N04 N05 1.99e-10
C06 N05 N06 6.96e-12
L06 N05 N06 3.01e-11
R06 N05 N06 2.23e+01
C07 N06 N07 1.17e-11
L07 N06 N07 3.80e-11
R07 N06 N07 4.21e+01
C08 N07 Port2 8.73e-11
L08 N07 Port2 1.21e-11
R08 N07 Port2 1.06e+01
.ENDS GCQ1555C1H180GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H180JB01
* Property : C = 1.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 3.12e-12
R04 N03 N04 3.92e-02
C05 N04 N05 9.44e-13
L05 N04 N05 1.99e-10
C06 N05 N06 6.96e-12
L06 N05 N06 3.01e-11
R06 N05 N06 2.23e+01
C07 N06 N07 1.17e-11
L07 N06 N07 3.80e-11
R07 N06 N07 4.21e+01
C08 N07 Port2 8.73e-11
L08 N07 Port2 1.21e-11
R08 N07 Port2 1.06e+01
.ENDS GCQ1555C1H180JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R0BB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.46e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 8.69e-13
L04 N03 Port2 7.01e-11
R04 N03 Port2 4.11e+02
.ENDS GCQ1555C1H1R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R0CB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.46e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 8.69e-13
L04 N03 Port2 7.01e-11
R04 N03 Port2 4.11e+02
.ENDS GCQ1555C1H1R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R0WB01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R0WB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.46e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 8.69e-13
L04 N03 Port2 7.01e-11
R04 N03 Port2 4.11e+02
.ENDS GCQ1555C1H1R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R1BB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R1CB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R1WB01
* Property : C = 1.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R1WB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R2BB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R2CB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R2WB01
* Property : C = 1.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R2WB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R3BB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R3CB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R3CB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R3WB01
* Property : C = 1.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R3WB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 2.30e-01
C04 N03 Port2 2.22e-10
L04 N03 Port2 1.32e-12
R04 N03 Port2 2.28e-01
.ENDS GCQ1555C1H1R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R4BB01
* Property : C = 1.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R4BB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R4CB01
* Property : C = 1.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R4CB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R4WB01
* Property : C = 1.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R4WB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R5BB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R5CB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R5WB01
* Property : C = 1.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R5WB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R6BB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R6BB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R6CB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R6CB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R6WB01
* Property : C = 1.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R6WB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.39e-10
R03 N02 N03 2.10e-01
C04 N03 Port2 1.29e-10
L04 N03 Port2 2.21e-12
R04 N03 Port2 4.02e-01
.ENDS GCQ1555C1H1R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R7BB01
* Property : C = 1.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R7BB01 Port1 Port2
C01 Port1 N01 1.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R7CB01
* Property : C = 1.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R7CB01 Port1 Port2
C01 Port1 N01 1.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R7WB01
* Property : C = 1.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R7WB01 Port1 Port2
C01 Port1 N01 1.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R8BB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R8CB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R8WB01
* Property : C = 1.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R8WB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R9BB01
* Property : C = 1.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R9BB01 Port1 Port2
C01 Port1 N01 1.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R9CB01
* Property : C = 1.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R9CB01 Port1 Port2
C01 Port1 N01 1.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R9WB01
* Property : C = 1.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R9WB01 Port1 Port2
C01 Port1 N01 1.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H200GB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.10e-11
R03 N02 N03 7.29e-02
L04 N03 N04 4.01e-12
R04 N03 N04 1.09e-01
C05 N04 N05 8.66e-11
L05 N04 N05 1.42e-11
R05 N04 N05 1.29e+01
C06 N05 N06 1.61e-11
L06 N05 N06 3.23e-11
R06 N05 N06 4.06e+01
C07 N06 N07 2.40e-11
L07 N06 N07 1.15e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 9.84e-13
L08 N07 Port2 2.08e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H200GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H200JB01
* Property : C = 2.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.10e-11
R03 N02 N03 7.29e-02
L04 N03 N04 4.01e-12
R04 N03 N04 1.09e-01
C05 N04 N05 8.66e-11
L05 N04 N05 1.42e-11
R05 N04 N05 1.29e+01
C06 N05 N06 1.61e-11
L06 N05 N06 3.23e-11
R06 N05 N06 4.06e+01
C07 N06 N07 2.40e-11
L07 N06 N07 1.15e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 9.84e-13
L08 N07 Port2 2.08e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H200JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H220FB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H220FB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 7.50e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.61e-11
R04 N03 N04 1.11e+01
C05 N04 N05 2.33e-11
L05 N04 N05 2.54e-11
R05 N04 N05 2.60e+01
C06 N05 Port2 4.91e-12
L06 N05 Port2 5.74e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H220FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H220GB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 7.50e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.61e-11
R04 N03 N04 1.11e+01
C05 N04 N05 2.33e-11
L05 N04 N05 2.54e-11
R05 N04 N05 2.60e+01
C06 N05 Port2 4.91e-12
L06 N05 Port2 5.74e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H220GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H220JB01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 7.50e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.61e-11
R04 N03 N04 1.11e+01
C05 N04 N05 2.33e-11
L05 N04 N05 2.54e-11
R05 N04 N05 2.60e+01
C06 N05 Port2 4.91e-12
L06 N05 Port2 5.74e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H220JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H240FB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H240FB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.35e-10
R03 N02 N03 7.50e-02
C04 N03 N04 1.08e-10
L04 N03 N04 1.15e-11
R04 N03 N04 5.34e+00
C05 N04 N05 1.45e-11
L05 N04 N05 3.32e-11
R05 N04 N05 2.56e+01
C06 N05 Port2 1.67e-12
L06 N05 Port2 1.37e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H240FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H240GB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.35e-10
R03 N02 N03 7.50e-02
C04 N03 N04 1.08e-10
L04 N03 N04 1.15e-11
R04 N03 N04 5.34e+00
C05 N04 N05 1.45e-11
L05 N04 N05 3.32e-11
R05 N04 N05 2.56e+01
C06 N05 Port2 1.67e-12
L06 N05 Port2 1.37e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H240GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H240JB01
* Property : C = 2.40e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H240JB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.35e-10
R03 N02 N03 7.50e-02
C04 N03 N04 1.08e-10
L04 N03 N04 1.15e-11
R04 N03 N04 5.34e+00
C05 N04 N05 1.45e-11
L05 N04 N05 3.32e-11
R05 N04 N05 2.56e+01
C06 N05 Port2 1.67e-12
L06 N05 Port2 1.37e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H240JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H270FB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H270FB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.42e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.92e-10
L04 N03 N04 7.61e-12
R04 N03 N04 5.78e+00
C05 N04 N05 2.21e-11
L05 N04 N05 2.57e-11
R05 N04 N05 1.96e+01
C06 N05 N06 2.15e-11
L06 N05 N06 1.53e-11
R06 N05 N06 6.75e+00
C07 N06 Port2 2.14e-12
L07 N06 Port2 1.15e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H270FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H270GB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.42e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.92e-10
L04 N03 N04 7.61e-12
R04 N03 N04 5.78e+00
C05 N04 N05 2.21e-11
L05 N04 N05 2.57e-11
R05 N04 N05 1.96e+01
C06 N05 N06 2.15e-11
L06 N05 N06 1.53e-11
R06 N05 N06 6.75e+00
C07 N06 Port2 2.14e-12
L07 N06 Port2 1.15e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H270GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H270JB01
* Property : C = 2.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.42e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.92e-10
L04 N03 N04 7.61e-12
R04 N03 N04 5.78e+00
C05 N04 N05 2.21e-11
L05 N04 N05 2.57e-11
R05 N04 N05 1.96e+01
C06 N05 N06 2.15e-11
L06 N05 N06 1.53e-11
R06 N05 N06 6.75e+00
C07 N06 Port2 2.14e-12
L07 N06 Port2 1.15e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H270JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R0BB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R0CB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R0WB01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R0WB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R1BB01
* Property : C = 2.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R1BB01 Port1 Port2
C01 Port1 N01 2.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R1CB01
* Property : C = 2.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R1CB01 Port1 Port2
C01 Port1 N01 2.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R1WB01
* Property : C = 2.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R1WB01 Port1 Port2
C01 Port1 N01 2.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R2BB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R2CB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R2WB01
* Property : C = 2.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R2WB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H2R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R3BB01
* Property : C = 2.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R3BB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R3CB01
* Property : C = 2.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R3CB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R3WB01
* Property : C = 2.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R3WB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R4BB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R4BB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R4CB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R4CB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R4WB01
* Property : C = 2.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R4WB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R5BB01
* Property : C = 2.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R5BB01 Port1 Port2
C01 Port1 N01 2.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R5CB01
* Property : C = 2.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R5CB01 Port1 Port2
C01 Port1 N01 2.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R5WB01
* Property : C = 2.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R5WB01 Port1 Port2
C01 Port1 N01 2.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.47e-10
R03 N02 N03 1.50e-01
C04 N03 N04 2.22e-12
L04 N03 N04 1.18e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.13e-11
L05 N04 Port2 1.10e-11
R05 N04 Port2 2.12e+00
.ENDS GCQ1555C1H2R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R6BB01
* Property : C = 2.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R6BB01 Port1 Port2
C01 Port1 N01 2.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R6CB01
* Property : C = 2.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R6CB01 Port1 Port2
C01 Port1 N01 2.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R6WB01
* Property : C = 2.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R6WB01 Port1 Port2
C01 Port1 N01 2.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R7BB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R7CB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R7WB01
* Property : C = 2.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R7WB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R8BB01
* Property : C = 2.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R8BB01 Port1 Port2
C01 Port1 N01 2.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R8CB01
* Property : C = 2.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R8CB01 Port1 Port2
C01 Port1 N01 2.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R8WB01
* Property : C = 2.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R8WB01 Port1 Port2
C01 Port1 N01 2.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.89e-10
R03 N02 N03 1.40e-01
C04 N03 N04 3.35e-12
L04 N03 N04 8.85e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 1.10e-11
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.28e+01
.ENDS GCQ1555C1H2R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R9BB01
* Property : C = 2.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R9BB01 Port1 Port2
C01 Port1 N01 2.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H2R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R9CB01
* Property : C = 2.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R9CB01 Port1 Port2
C01 Port1 N01 2.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H2R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H2R9WB01
* Property : C = 2.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H2R9WB01 Port1 Port2
C01 Port1 N01 2.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H2R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H300FB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H300FB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.65e-10
L04 N03 N04 1.04e-11
R04 N03 N04 6.07e+00
C05 N04 N05 3.18e-11
L05 N04 N05 2.15e-11
R05 N04 N05 1.89e+01
C06 N05 N06 2.39e-11
L06 N05 N06 1.30e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.94e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H300FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H300GB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.65e-10
L04 N03 N04 1.04e-11
R04 N03 N04 6.07e+00
C05 N04 N05 3.18e-11
L05 N04 N05 2.15e-11
R05 N04 N05 1.89e+01
C06 N05 N06 2.39e-11
L06 N05 N06 1.30e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.94e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H300GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H300JB01
* Property : C = 3.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.65e-10
L04 N03 N04 1.04e-11
R04 N03 N04 6.07e+00
C05 N04 N05 3.18e-11
L05 N04 N05 2.15e-11
R05 N04 N05 1.89e+01
C06 N05 N06 2.39e-11
L06 N05 N06 1.30e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.94e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H300JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H330FB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H330FB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.38e-10
R03 N02 N03 7.10e-02
C04 N03 N04 1.29e-10
L04 N03 N04 1.55e-11
R04 N03 N04 5.64e+00
C05 N04 N05 4.28e-11
L05 N04 N05 1.89e-11
R05 N04 N05 1.46e+01
C06 N05 N06 1.11e-10
L06 N05 N06 3.58e-12
R06 N05 N06 3.06e+00
C07 N06 Port2 8.90e-12
L07 N06 Port2 3.12e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H330FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H330GB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H330GB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.38e-10
R03 N02 N03 7.10e-02
C04 N03 N04 1.29e-10
L04 N03 N04 1.55e-11
R04 N03 N04 5.64e+00
C05 N04 N05 4.28e-11
L05 N04 N05 1.89e-11
R05 N04 N05 1.46e+01
C06 N05 N06 1.11e-10
L06 N05 N06 3.58e-12
R06 N05 N06 3.06e+00
C07 N06 Port2 8.90e-12
L07 N06 Port2 3.12e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H330GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H330JB01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.38e-10
R03 N02 N03 7.10e-02
C04 N03 N04 1.29e-10
L04 N03 N04 1.55e-11
R04 N03 N04 5.64e+00
C05 N04 N05 4.28e-11
L05 N04 N05 1.89e-11
R05 N04 N05 1.46e+01
C06 N05 N06 1.11e-10
L06 N05 N06 3.58e-12
R06 N05 N06 3.06e+00
C07 N06 Port2 8.90e-12
L07 N06 Port2 3.12e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H330JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H360FB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H360FB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.10e-02
C04 N03 N04 2.05e-10
L04 N03 N04 1.05e-11
R04 N03 N04 6.06e+00
C05 N04 N05 4.44e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.27e+01
C06 N05 N06 1.35e-10
L06 N05 N06 3.26e-12
R06 N05 N06 2.80e+00
C07 N06 Port2 1.07e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H360FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H360GB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H360GB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.10e-02
C04 N03 N04 2.05e-10
L04 N03 N04 1.05e-11
R04 N03 N04 6.06e+00
C05 N04 N05 4.44e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.27e+01
C06 N05 N06 1.35e-10
L06 N05 N06 3.26e-12
R06 N05 N06 2.80e+00
C07 N06 Port2 1.07e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H360GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H360JB01
* Property : C = 3.60e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.10e-02
C04 N03 N04 2.05e-10
L04 N03 N04 1.05e-11
R04 N03 N04 6.06e+00
C05 N04 N05 4.44e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.27e+01
C06 N05 N06 1.35e-10
L06 N05 N06 3.26e-12
R06 N05 N06 2.80e+00
C07 N06 Port2 1.07e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H360JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H390FB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H390FB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.86e-10
L04 N03 N04 1.33e-11
R04 N03 N04 6.39e+00
C05 N04 N05 5.35e-11
L05 N04 N05 1.94e-11
R05 N04 N05 1.35e+01
C06 N05 N06 1.09e-10
L06 N05 N06 4.73e-12
R06 N05 N06 2.81e+00
C07 N06 N07 1.05e-10
L07 N06 N07 3.24e-12
R07 N06 N07 2.69e+00
C08 N07 Port2 4.72e-12
L08 N07 Port2 5.63e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H390FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H390GB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.86e-10
L04 N03 N04 1.33e-11
R04 N03 N04 6.39e+00
C05 N04 N05 5.35e-11
L05 N04 N05 1.94e-11
R05 N04 N05 1.35e+01
C06 N05 N06 1.09e-10
L06 N05 N06 4.73e-12
R06 N05 N06 2.81e+00
C07 N06 N07 1.05e-10
L07 N06 N07 3.24e-12
R07 N06 N07 2.69e+00
C08 N07 Port2 4.72e-12
L08 N07 Port2 5.63e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H390GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H390JB01
* Property : C = 3.90e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H390JB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.86e-10
L04 N03 N04 1.33e-11
R04 N03 N04 6.39e+00
C05 N04 N05 5.35e-11
L05 N04 N05 1.94e-11
R05 N04 N05 1.35e+01
C06 N05 N06 1.09e-10
L06 N05 N06 4.73e-12
R06 N05 N06 2.81e+00
C07 N06 N07 1.05e-10
L07 N06 N07 3.24e-12
R07 N06 N07 2.69e+00
C08 N07 Port2 4.72e-12
L08 N07 Port2 5.63e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H390JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R0BB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R0CB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R0CB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R0WB01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R0WB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R1BB01
* Property : C = 3.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R1BB01 Port1 Port2
C01 Port1 N01 3.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R1CB01
* Property : C = 3.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R1CB01 Port1 Port2
C01 Port1 N01 3.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R1WB01
* Property : C = 3.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R1WB01 Port1 Port2
C01 Port1 N01 3.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.88e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.39e-11
L04 N03 N04 6.93e-12
R04 N03 N04 6.32e-01
C05 N04 Port2 6.06e-12
L05 N04 Port2 4.24e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R2BB01
* Property : C = 3.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R2BB01 Port1 Port2
C01 Port1 N01 3.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R2CB01
* Property : C = 3.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R2CB01 Port1 Port2
C01 Port1 N01 3.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R2WB01
* Property : C = 3.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R2WB01 Port1 Port2
C01 Port1 N01 3.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R3BB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R3BB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R3CB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R3CB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R3WB01
* Property : C = 3.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R3WB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R4BB01
* Property : C = 3.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R4BB01 Port1 Port2
C01 Port1 N01 3.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R4CB01
* Property : C = 3.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R4CB01 Port1 Port2
C01 Port1 N01 3.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R4WB01
* Property : C = 3.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R4WB01 Port1 Port2
C01 Port1 N01 3.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GCQ1555C1H3R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R5BB01
* Property : C = 3.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R5BB01 Port1 Port2
C01 Port1 N01 3.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R5CB01
* Property : C = 3.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R5CB01 Port1 Port2
C01 Port1 N01 3.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R5WB01
* Property : C = 3.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R5WB01 Port1 Port2
C01 Port1 N01 3.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R6BB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R6CB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R6CB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R6WB01
* Property : C = 3.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R6WB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R7BB01
* Property : C = 3.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R7BB01 Port1 Port2
C01 Port1 N01 3.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R7CB01
* Property : C = 3.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R7CB01 Port1 Port2
C01 Port1 N01 3.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R7WB01
* Property : C = 3.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R7WB01 Port1 Port2
C01 Port1 N01 3.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 1.30e-01
C04 N03 N04 2.41e-12
L04 N03 N04 1.04e-10
R04 N03 N04 1.00e+05
C05 N04 Port2 2.15e-11
L05 N04 Port2 1.01e-11
R05 N04 Port2 1.14e+00
.ENDS GCQ1555C1H3R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R8BB01
* Property : C = 3.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R8BB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R8CB01
* Property : C = 3.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R8CB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R8WB01
* Property : C = 3.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R8WB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R9BB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R9BB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R9CB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R9CB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R9WB01
* Property : C = 3.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R9WB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H430FB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H430FB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.47e-11
R03 N02 N03 7.00e-02
C04 N03 N04 2.01e-10
L04 N03 N04 1.32e-11
R04 N03 N04 5.74e+00
C05 N04 N05 5.95e-11
L05 N04 N05 1.87e-11
R05 N04 N05 1.38e+01
C06 N05 N06 1.52e-10
L06 N05 N06 3.67e-12
R06 N05 N06 2.95e+00
C07 N06 N07 2.90e-11
L07 N06 N07 1.18e-11
R07 N06 N07 1.15e+01
C08 N07 Port2 1.22e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H430FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H430GB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H430GB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.47e-11
R03 N02 N03 7.00e-02
C04 N03 N04 2.01e-10
L04 N03 N04 1.32e-11
R04 N03 N04 5.74e+00
C05 N04 N05 5.95e-11
L05 N04 N05 1.87e-11
R05 N04 N05 1.38e+01
C06 N05 N06 1.52e-10
L06 N05 N06 3.67e-12
R06 N05 N06 2.95e+00
C07 N06 N07 2.90e-11
L07 N06 N07 1.18e-11
R07 N06 N07 1.15e+01
C08 N07 Port2 1.22e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H430GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H430JB01
* Property : C = 4.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.47e-11
R03 N02 N03 7.00e-02
C04 N03 N04 2.01e-10
L04 N03 N04 1.32e-11
R04 N03 N04 5.74e+00
C05 N04 N05 5.95e-11
L05 N04 N05 1.87e-11
R05 N04 N05 1.38e+01
C06 N05 N06 1.52e-10
L06 N05 N06 3.67e-12
R06 N05 N06 2.95e+00
C07 N06 N07 2.90e-11
L07 N06 N07 1.18e-11
R07 N06 N07 1.15e+01
C08 N07 Port2 1.22e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H430JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H470FB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H470FB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 7.00e-02
C04 N03 N04 2.11e-10
L04 N03 N04 1.40e-11
R04 N03 N04 6.28e+00
C05 N04 N05 6.55e-11
L05 N04 N05 1.92e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.62e-10
L06 N05 N06 3.88e-12
R06 N05 N06 2.58e+00
C07 N06 N07 4.76e-11
L07 N06 N07 8.30e-12
R07 N06 N07 7.40e+00
C08 N07 Port2 1.15e-11
L08 N07 Port2 2.42e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H470FB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H470GB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H470GB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 7.00e-02
C04 N03 N04 2.11e-10
L04 N03 N04 1.40e-11
R04 N03 N04 6.28e+00
C05 N04 N05 6.55e-11
L05 N04 N05 1.92e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.62e-10
L06 N05 N06 3.88e-12
R06 N05 N06 2.58e+00
C07 N06 N07 4.76e-11
L07 N06 N07 8.30e-12
R07 N06 N07 7.40e+00
C08 N07 Port2 1.15e-11
L08 N07 Port2 2.42e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H470GB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H470JB01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.12e-10
R03 N02 N03 7.00e-02
C04 N03 N04 2.11e-10
L04 N03 N04 1.40e-11
R04 N03 N04 6.28e+00
C05 N04 N05 6.55e-11
L05 N04 N05 1.92e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.62e-10
L06 N05 N06 3.88e-12
R06 N05 N06 2.58e+00
C07 N06 N07 4.76e-11
L07 N06 N07 8.30e-12
R07 N06 N07 7.40e+00
C08 N07 Port2 1.15e-11
L08 N07 Port2 2.42e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H470JB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R0BB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R0BB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R0CB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R0CB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R0WB01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R0WB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R1BB01
* Property : C = 4.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R1BB01 Port1 Port2
C01 Port1 N01 4.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R1CB01
* Property : C = 4.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R1CB01 Port1 Port2
C01 Port1 N01 4.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R1WB01
* Property : C = 4.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R1WB01 Port1 Port2
C01 Port1 N01 4.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R2BB01
* Property : C = 4.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R2BB01 Port1 Port2
C01 Port1 N01 4.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R2CB01
* Property : C = 4.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R2CB01 Port1 Port2
C01 Port1 N01 4.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R2WB01
* Property : C = 4.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R2WB01 Port1 Port2
C01 Port1 N01 4.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R3BB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R3CB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R3WB01
* Property : C = 4.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R3WB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.34e-10
R03 N02 N03 1.20e-01
L04 N03 N04 6.99e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 1.01e-10
L05 N04 Port2 2.74e-12
R05 N04 Port2 4.02e-01
.ENDS GCQ1555C1H4R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R4BB01
* Property : C = 4.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R4BB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R4CB01
* Property : C = 4.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R4CB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R4WB01
* Property : C = 4.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R4WB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R5BB01
* Property : C = 4.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R5BB01 Port1 Port2
C01 Port1 N01 4.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R5CB01
* Property : C = 4.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R5CB01 Port1 Port2
C01 Port1 N01 4.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R5WB01
* Property : C = 4.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R5WB01 Port1 Port2
C01 Port1 N01 4.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R6BB01
* Property : C = 4.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R6BB01 Port1 Port2
C01 Port1 N01 4.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R6CB01
* Property : C = 4.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R6CB01 Port1 Port2
C01 Port1 N01 4.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R6WB01
* Property : C = 4.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R6WB01 Port1 Port2
C01 Port1 N01 4.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R7BB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R7CB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R7WB01
* Property : C = 4.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R7WB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R8BB01
* Property : C = 4.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R8BB01 Port1 Port2
C01 Port1 N01 4.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R8CB01
* Property : C = 4.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R8CB01 Port1 Port2
C01 Port1 N01 4.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R8WB01
* Property : C = 4.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R8WB01 Port1 Port2
C01 Port1 N01 4.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R9BB01
* Property : C = 4.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R9BB01 Port1 Port2
C01 Port1 N01 4.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R9CB01
* Property : C = 4.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R9CB01 Port1 Port2
C01 Port1 N01 4.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R9WB01
* Property : C = 4.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R9WB01 Port1 Port2
C01 Port1 N01 4.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.06e-01
C04 N03 N04 5.82e-11
L04 N03 N04 6.93e-12
R04 N03 N04 4.39e-01
C05 N04 Port2 3.25e-12
L05 N04 Port2 7.09e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H4R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R0BB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R0BB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R0CB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R0CB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R0WB01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R0WB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R1BB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R1BB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R1CB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R1CB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R1DB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R1WB01
* Property : C = 5.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R1WB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R2BB01
* Property : C = 5.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R2BB01 Port1 Port2
C01 Port1 N01 5.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R2CB01
* Property : C = 5.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R2CB01 Port1 Port2
C01 Port1 N01 5.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R2DB01
* Property : C = 5.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R2DB01 Port1 Port2
C01 Port1 N01 5.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R2WB01
* Property : C = 5.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R2WB01 Port1 Port2
C01 Port1 N01 5.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.45e-10
R03 N02 N03 1.00e-01
C04 N03 N04 3.07e-11
L04 N03 N04 1.13e-11
R04 N03 N04 1.03e+00
C05 N04 Port2 1.56e-12
L05 N04 Port2 1.59e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R3BB01
* Property : C = 5.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R3BB01 Port1 Port2
C01 Port1 N01 5.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R3CB01
* Property : C = 5.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R3CB01 Port1 Port2
C01 Port1 N01 5.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R3DB01
* Property : C = 5.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R3DB01 Port1 Port2
C01 Port1 N01 5.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R3DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R3WB01
* Property : C = 5.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R3WB01 Port1 Port2
C01 Port1 N01 5.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R4BB01
* Property : C = 5.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R4BB01 Port1 Port2
C01 Port1 N01 5.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R4CB01
* Property : C = 5.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R4CB01 Port1 Port2
C01 Port1 N01 5.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R4DB01
* Property : C = 5.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R4DB01 Port1 Port2
C01 Port1 N01 5.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R4DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R4WB01
* Property : C = 5.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R4WB01 Port1 Port2
C01 Port1 N01 5.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R5BB01
* Property : C = 5.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R5BB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R5CB01
* Property : C = 5.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R5CB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R5DB01
* Property : C = 5.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R5DB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R5WB01
* Property : C = 5.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R5WB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H5R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R6BB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R6BB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R6CB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R6CB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R6DB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R6WB01
* Property : C = 5.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R6WB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R7BB01
* Property : C = 5.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R7BB01 Port1 Port2
C01 Port1 N01 5.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R7CB01
* Property : C = 5.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R7CB01 Port1 Port2
C01 Port1 N01 5.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R7DB01
* Property : C = 5.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R7DB01 Port1 Port2
C01 Port1 N01 5.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R7DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R7WB01
* Property : C = 5.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R7WB01 Port1 Port2
C01 Port1 N01 5.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R8BB01
* Property : C = 5.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R8BB01 Port1 Port2
C01 Port1 N01 5.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R8CB01
* Property : C = 5.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R8CB01 Port1 Port2
C01 Port1 N01 5.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R8DB01
* Property : C = 5.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R8DB01 Port1 Port2
C01 Port1 N01 5.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R8WB01
* Property : C = 5.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R8WB01 Port1 Port2
C01 Port1 N01 5.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 1.00e-01
L04 N03 Port2 7.85e-11
R04 N03 Port2 3.41e+01
.ENDS GCQ1555C1H5R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R9BB01
* Property : C = 5.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R9BB01 Port1 Port2
C01 Port1 N01 5.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R9CB01
* Property : C = 5.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R9CB01 Port1 Port2
C01 Port1 N01 5.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R9DB01
* Property : C = 5.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R9DB01 Port1 Port2
C01 Port1 N01 5.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R9DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H5R9WB01
* Property : C = 5.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H5R9WB01 Port1 Port2
C01 Port1 N01 5.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H5R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R0BB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R0BB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R0CB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R0CB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R0DB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R0DB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R0WB01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R0WB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R1BB01
* Property : C = 6.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R1BB01 Port1 Port2
C01 Port1 N01 6.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R1CB01
* Property : C = 6.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R1CB01 Port1 Port2
C01 Port1 N01 6.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R1DB01
* Property : C = 6.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R1DB01 Port1 Port2
C01 Port1 N01 6.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R1WB01
* Property : C = 6.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R1WB01 Port1 Port2
C01 Port1 N01 6.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.55e-11
R03 N02 N03 1.00e-01
C04 N03 N04 2.16e-11
L04 N03 N04 1.51e-11
R04 N03 N04 1.59e+00
C05 N04 Port2 8.59e-13
L05 N04 Port2 2.46e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H6R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R2BB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R2BB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R2CB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R2DB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R2WB01
* Property : C = 6.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R2WB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R3BB01
* Property : C = 6.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R3BB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R3CB01
* Property : C = 6.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R3CB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R3DB01
* Property : C = 6.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R3DB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R3DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R3WB01
* Property : C = 6.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R3WB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R4BB01
* Property : C = 6.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R4BB01 Port1 Port2
C01 Port1 N01 6.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R4CB01
* Property : C = 6.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R4CB01 Port1 Port2
C01 Port1 N01 6.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R4DB01
* Property : C = 6.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R4DB01 Port1 Port2
C01 Port1 N01 6.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R4DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R4WB01
* Property : C = 6.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R4WB01 Port1 Port2
C01 Port1 N01 6.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GCQ1555C1H6R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R5BB01
* Property : C = 6.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R5BB01 Port1 Port2
C01 Port1 N01 6.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R5CB01
* Property : C = 6.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R5CB01 Port1 Port2
C01 Port1 N01 6.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R5DB01
* Property : C = 6.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R5DB01 Port1 Port2
C01 Port1 N01 6.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R5WB01
* Property : C = 6.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R5WB01 Port1 Port2
C01 Port1 N01 6.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R6BB01
* Property : C = 6.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R6BB01 Port1 Port2
C01 Port1 N01 6.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R6CB01
* Property : C = 6.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R6CB01 Port1 Port2
C01 Port1 N01 6.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R6DB01
* Property : C = 6.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R6DB01 Port1 Port2
C01 Port1 N01 6.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R6WB01
* Property : C = 6.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R6WB01 Port1 Port2
C01 Port1 N01 6.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R7BB01
* Property : C = 6.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R7BB01 Port1 Port2
C01 Port1 N01 6.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R7CB01
* Property : C = 6.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R7CB01 Port1 Port2
C01 Port1 N01 6.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R7DB01
* Property : C = 6.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R7DB01 Port1 Port2
C01 Port1 N01 6.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R7DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R7WB01
* Property : C = 6.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R7WB01 Port1 Port2
C01 Port1 N01 6.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R8BB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R8BB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R8CB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R8DB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R8WB01
* Property : C = 6.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R8WB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R9BB01
* Property : C = 6.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R9BB01 Port1 Port2
C01 Port1 N01 6.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R9CB01
* Property : C = 6.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R9CB01 Port1 Port2
C01 Port1 N01 6.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R9DB01
* Property : C = 6.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R9DB01 Port1 Port2
C01 Port1 N01 6.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R9DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R9WB01
* Property : C = 6.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R9WB01 Port1 Port2
C01 Port1 N01 6.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R0BB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R0BB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H7R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R0CB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H7R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R0DB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R0DB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H7R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R0WB01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R0WB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H7R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R1BB01
* Property : C = 7.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R1BB01 Port1 Port2
C01 Port1 N01 7.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R1CB01
* Property : C = 7.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R1CB01 Port1 Port2
C01 Port1 N01 7.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R1DB01
* Property : C = 7.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R1DB01 Port1 Port2
C01 Port1 N01 7.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R1WB01
* Property : C = 7.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R1WB01 Port1 Port2
C01 Port1 N01 7.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R2BB01
* Property : C = 7.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R2BB01 Port1 Port2
C01 Port1 N01 7.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R2CB01
* Property : C = 7.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R2CB01 Port1 Port2
C01 Port1 N01 7.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R2DB01
* Property : C = 7.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R2DB01 Port1 Port2
C01 Port1 N01 7.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R2WB01
* Property : C = 7.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R2WB01 Port1 Port2
C01 Port1 N01 7.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R3BB01
* Property : C = 7.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R3BB01 Port1 Port2
C01 Port1 N01 7.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R3CB01
* Property : C = 7.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R3CB01 Port1 Port2
C01 Port1 N01 7.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R3DB01
* Property : C = 7.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R3DB01 Port1 Port2
C01 Port1 N01 7.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R3DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R3WB01
* Property : C = 7.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R3WB01 Port1 Port2
C01 Port1 N01 7.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R4BB01
* Property : C = 7.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R4BB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R4CB01
* Property : C = 7.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R4CB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R4DB01
* Property : C = 7.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R4DB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R4DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R4WB01
* Property : C = 7.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R4WB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R5BB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R5BB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R5CB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R5CB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R5DB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R5DB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R5WB01
* Property : C = 7.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R5WB01 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R6BB01
* Property : C = 7.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R6BB01 Port1 Port2
C01 Port1 N01 7.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R6CB01
* Property : C = 7.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R6CB01 Port1 Port2
C01 Port1 N01 7.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R6DB01
* Property : C = 7.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R6DB01 Port1 Port2
C01 Port1 N01 7.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R6WB01
* Property : C = 7.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R6WB01 Port1 Port2
C01 Port1 N01 7.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R7BB01
* Property : C = 7.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R7BB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R7CB01
* Property : C = 7.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R7CB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R7DB01
* Property : C = 7.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R7DB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R7DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R7WB01
* Property : C = 7.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R7WB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R8BB01
* Property : C = 7.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R8BB01 Port1 Port2
C01 Port1 N01 7.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R8CB01
* Property : C = 7.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R8CB01 Port1 Port2
C01 Port1 N01 7.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R8DB01
* Property : C = 7.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R8DB01 Port1 Port2
C01 Port1 N01 7.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R8WB01
* Property : C = 7.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R8WB01 Port1 Port2
C01 Port1 N01 7.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R9BB01
* Property : C = 7.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R9BB01 Port1 Port2
C01 Port1 N01 7.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R9CB01
* Property : C = 7.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R9CB01 Port1 Port2
C01 Port1 N01 7.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R9DB01
* Property : C = 7.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R9DB01 Port1 Port2
C01 Port1 N01 7.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R9DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R9WB01
* Property : C = 7.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R9WB01 Port1 Port2
C01 Port1 N01 7.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R0BB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R0BB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R0CB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R0DB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R0WB01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R0WB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R1BB01
* Property : C = 8.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R1BB01 Port1 Port2
C01 Port1 N01 8.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R1CB01
* Property : C = 8.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R1CB01 Port1 Port2
C01 Port1 N01 8.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R1DB01
* Property : C = 8.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R1DB01 Port1 Port2
C01 Port1 N01 8.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R1WB01
* Property : C = 8.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R1WB01 Port1 Port2
C01 Port1 N01 8.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R2BB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R2BB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R2CB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R2DB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R2DB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R2WB01
* Property : C = 8.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R2WB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.66e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.90e-12
R04 N03 N04 1.49e-01
C05 N04 N05 3.42e-11
L05 N04 N05 1.24e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 6.20e-12
L06 N05 Port2 4.71e-11
R06 N05 Port2 7.08e+02
.ENDS GCQ1555C1H8R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R3BB01
* Property : C = 8.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R3BB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R3CB01
* Property : C = 8.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R3CB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R3DB01
* Property : C = 8.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R3DB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R3DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R3WB01
* Property : C = 8.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R3WB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R4BB01
* Property : C = 8.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R4BB01 Port1 Port2
C01 Port1 N01 8.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R4CB01
* Property : C = 8.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R4CB01 Port1 Port2
C01 Port1 N01 8.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R4DB01
* Property : C = 8.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R4DB01 Port1 Port2
C01 Port1 N01 8.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R4DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R4WB01
* Property : C = 8.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R4WB01 Port1 Port2
C01 Port1 N01 8.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R5BB01
* Property : C = 8.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R5BB01 Port1 Port2
C01 Port1 N01 8.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R5CB01
* Property : C = 8.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R5CB01 Port1 Port2
C01 Port1 N01 8.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R5DB01
* Property : C = 8.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R5DB01 Port1 Port2
C01 Port1 N01 8.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R5WB01
* Property : C = 8.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R5WB01 Port1 Port2
C01 Port1 N01 8.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GCQ1555C1H8R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R6BB01
* Property : C = 8.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R6BB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R6CB01
* Property : C = 8.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R6CB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R6DB01
* Property : C = 8.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R6DB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R6WB01
* Property : C = 8.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R6WB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R7BB01
* Property : C = 8.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R7BB01 Port1 Port2
C01 Port1 N01 8.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R7CB01
* Property : C = 8.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R7CB01 Port1 Port2
C01 Port1 N01 8.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R7DB01
* Property : C = 8.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R7DB01 Port1 Port2
C01 Port1 N01 8.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R7DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R7WB01
* Property : C = 8.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R7WB01 Port1 Port2
C01 Port1 N01 8.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R8BB01
* Property : C = 8.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R8BB01 Port1 Port2
C01 Port1 N01 8.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R8CB01
* Property : C = 8.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R8CB01 Port1 Port2
C01 Port1 N01 8.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R8DB01
* Property : C = 8.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R8DB01 Port1 Port2
C01 Port1 N01 8.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R8WB01
* Property : C = 8.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R8WB01 Port1 Port2
C01 Port1 N01 8.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H8R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R9BB01
* Property : C = 8.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R9BB01 Port1 Port2
C01 Port1 N01 8.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H8R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R9CB01
* Property : C = 8.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R9CB01 Port1 Port2
C01 Port1 N01 8.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H8R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R9DB01
* Property : C = 8.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R9DB01 Port1 Port2
C01 Port1 N01 8.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H8R9DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H8R9WB01
* Property : C = 8.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H8R9WB01 Port1 Port2
C01 Port1 N01 8.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H8R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R0BB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R0BB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R0BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R0CB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R0CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R0DB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R0DB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R0DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R0WB01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R0WB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R0WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R1BB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R1BB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R1BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R1CB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R1CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R1DB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R1DB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R1DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R1WB01
* Property : C = 9.10e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R1WB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H9R1WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R2BB01
* Property : C = 9.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R2BB01 Port1 Port2
C01 Port1 N01 9.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R2BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R2CB01
* Property : C = 9.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R2CB01 Port1 Port2
C01 Port1 N01 9.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R2CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R2DB01
* Property : C = 9.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R2DB01 Port1 Port2
C01 Port1 N01 9.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R2DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.20e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R2WB01
* Property : C = 9.20e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R2WB01 Port1 Port2
C01 Port1 N01 9.20e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R2WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R3BB01
* Property : C = 9.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R3BB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R3BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R3CB01
* Property : C = 9.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R3CB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R3CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R3DB01
* Property : C = 9.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R3DB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R3DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.30e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R3WB01
* Property : C = 9.30e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R3WB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R3WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R4BB01
* Property : C = 9.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R4BB01 Port1 Port2
C01 Port1 N01 9.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R4BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R4CB01
* Property : C = 9.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R4CB01 Port1 Port2
C01 Port1 N01 9.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R4CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R4DB01
* Property : C = 9.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R4DB01 Port1 Port2
C01 Port1 N01 9.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R4DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R4WB01
* Property : C = 9.40e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R4WB01 Port1 Port2
C01 Port1 N01 9.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 7.87e-02
L04 N03 N04 7.90e-12
R04 N03 N04 2.57e-01
C05 N04 N05 4.75e-11
L05 N04 N05 1.02e-11
R05 N04 N05 1.13e+01
C06 N05 Port2 4.04e-12
L06 N05 Port2 6.55e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R4WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R5BB01
* Property : C = 9.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R5BB01 Port1 Port2
C01 Port1 N01 9.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R5BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R5CB01
* Property : C = 9.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R5CB01 Port1 Port2
C01 Port1 N01 9.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R5CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R5DB01
* Property : C = 9.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R5DB01 Port1 Port2
C01 Port1 N01 9.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R5DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.50e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R5WB01
* Property : C = 9.50e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R5WB01 Port1 Port2
C01 Port1 N01 9.50e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R5WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R6BB01
* Property : C = 9.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R6BB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R6BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R6CB01
* Property : C = 9.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R6CB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R6CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R6DB01
* Property : C = 9.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R6DB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R6DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R6WB01
* Property : C = 9.60e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R6WB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R6WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R7BB01
* Property : C = 9.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R7BB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R7BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R7CB01
* Property : C = 9.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R7CB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R7CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R7DB01
* Property : C = 9.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R7DB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R7DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R7WB01
* Property : C = 9.70e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R7WB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R7WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R8BB01
* Property : C = 9.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R8BB01 Port1 Port2
C01 Port1 N01 9.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R8BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R8CB01
* Property : C = 9.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R8CB01 Port1 Port2
C01 Port1 N01 9.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R8CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R8DB01
* Property : C = 9.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R8DB01 Port1 Port2
C01 Port1 N01 9.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R8DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R8WB01
* Property : C = 9.80e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R8WB01 Port1 Port2
C01 Port1 N01 9.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R8WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R9BB01
* Property : C = 9.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R9BB01 Port1 Port2
C01 Port1 N01 9.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R9BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R9CB01
* Property : C = 9.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R9CB01 Port1 Port2
C01 Port1 N01 9.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R9CB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R9DB01
* Property : C = 9.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R9DB01 Port1 Port2
C01 Port1 N01 9.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R9DB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R9WB01
* Property : C = 9.90e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R9WB01 Port1 Port2
C01 Port1 N01 9.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.79e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.83e-12
R04 N03 N04 7.23e-02
C05 N04 N05 4.53e-11
L05 N04 N05 1.23e-11
R05 N04 N05 1.35e+01
C06 N05 Port2 1.77e-12
L06 N05 Port2 1.15e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R9WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR10BB01
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR10BB01 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.51e-10
R03 N02 N03 5.96e-01
C04 N03 Port2 8.62e-11
L04 N03 Port2 5.09e-13
R04 N03 Port2 4.98e-01
.ENDS GCQ1555C1HR10BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR10WB01
* Property : C = 1.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR10WB01 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.51e-10
R03 N02 N03 5.96e-01
C04 N03 Port2 8.62e-11
L04 N03 Port2 5.09e-13
R04 N03 Port2 4.98e-01
.ENDS GCQ1555C1HR10WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR20BB01
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR20BB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.37e-10
R03 N02 N03 4.75e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.30e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 8.88e-12
L05 N04 Port2 5.18e-12
R05 N04 Port2 1.24e+01
.ENDS GCQ1555C1HR20BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR20WB01
* Property : C = 2.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR20WB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.37e-10
R03 N02 N03 4.75e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.30e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 8.88e-12
L05 N04 Port2 5.18e-12
R05 N04 Port2 1.24e+01
.ENDS GCQ1555C1HR20WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR30BB01
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR30BB01 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 4.17e-01
C04 N03 N04 1.85e-11
L04 N03 N04 3.04e-12
R04 N03 N04 2.80e+00
C05 N04 Port2 3.10e-13
L05 N04 Port2 9.92e-11
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR30BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR30WB01
* Property : C = 3.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR30WB01 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.31e-10
R03 N02 N03 4.17e-01
C04 N03 N04 1.85e-11
L04 N03 N04 3.04e-12
R04 N03 N04 2.80e+00
C05 N04 Port2 3.10e-13
L05 N04 Port2 9.92e-11
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR30WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR40BB01
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR40BB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.47e-10
R03 N02 N03 3.46e-01
C04 N03 Port2 2.61e-12
L04 N03 Port2 1.96e-11
R04 N03 Port2 3.43e+01
.ENDS GCQ1555C1HR40BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR40WB01
* Property : C = 4.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR40WB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.47e-10
R03 N02 N03 3.46e-01
C04 N03 Port2 2.61e-12
L04 N03 Port2 1.96e-11
R04 N03 Port2 3.43e+01
.ENDS GCQ1555C1HR40WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR50BB01
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR50BB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 1.57e-10
R03 N02 N03 3.28e-01
C04 N03 N04 1.22e-11
L04 N03 N04 4.38e-12
R04 N03 N04 4.42e+00
C05 N04 Port2 1.60e-13
L05 N04 Port2 1.67e-10
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR50BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR50WB01
* Property : C = 5.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR50WB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 1.57e-10
R03 N02 N03 3.28e-01
C04 N03 N04 1.22e-11
L04 N03 N04 4.38e-12
R04 N03 N04 4.42e+00
C05 N04 Port2 1.60e-13
L05 N04 Port2 1.67e-10
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR50WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR60BB01
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR60BB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.62e-10
R03 N02 N03 3.13e-01
C04 N03 N04 9.58e-12
L04 N03 N04 6.41e-12
R04 N03 N04 3.56e+00
C05 N04 Port2 6.74e-13
L05 N04 Port2 6.66e-11
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR60BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR60WB01
* Property : C = 6.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR60WB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.62e-10
R03 N02 N03 3.13e-01
C04 N03 N04 9.58e-12
L04 N03 N04 6.41e-12
R04 N03 N04 3.56e+00
C05 N04 Port2 6.74e-13
L05 N04 Port2 6.66e-11
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR60WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR70BB01
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR70BB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.13e-10
R03 N02 N03 2.90e-01
C04 N03 Port2 6.12e-13
L04 N03 Port2 7.28e-11
R04 N03 Port2 2.38e+02
.ENDS GCQ1555C1HR70BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR70WB01
* Property : C = 7.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR70WB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.13e-10
R03 N02 N03 2.90e-01
C04 N03 Port2 6.12e-13
L04 N03 Port2 7.28e-11
R04 N03 Port2 2.38e+02
.ENDS GCQ1555C1HR70WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR80BB01
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR80BB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 2.69e-01
C04 N03 Port2 7.47e-13
L04 N03 Port2 6.84e-11
R04 N03 Port2 1.99e+02
.ENDS GCQ1555C1HR80BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR80WB01
* Property : C = 8.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR80WB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.17e-10
R03 N02 N03 2.69e-01
C04 N03 Port2 7.47e-13
L04 N03 Port2 6.84e-11
R04 N03 Port2 1.99e+02
.ENDS GCQ1555C1HR80WB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR90BB01
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.87e-10
R03 N02 N03 2.52e-01
C04 N03 Port2 5.82e-13
L04 N03 Port2 9.54e-11
R04 N03 Port2 3.53e+02
.ENDS GCQ1555C1HR90BB01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR90WB01
* Property : C = 9.00e-07[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR90WB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 2.87e-10
R03 N02 N03 2.52e-01
C04 N03 Port2 5.82e-13
L04 N03 Port2 9.54e-11
R04 N03 Port2 3.53e+02
.ENDS GCQ1555C1HR90WB01
