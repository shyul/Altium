*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N6BZ2
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N6BZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 2.70e-10
R2 1 port2 8.00e-3
R3 port1 port2 1.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N6BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N6CZ2
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N6CZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 2.70e-10
R2 1 port2 8.00e-3
R3 port1 port2 1.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N6CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N7BZ2
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N7BZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N7BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N7CZ2
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N7CZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N7CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N8BZ2
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N8BZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N8BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N8CZ2
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N8CZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N8CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N9BZ2
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N9BZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N9BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN0N9CZ2
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN0N9CZ2 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN0N9CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN10NHZ2
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN10NHZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.03e-8
R2 1 port2 4.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN10NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN10NJZ2
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN10NJZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.03e-8
R2 1 port2 4.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN10NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN11NHZ2
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN11NHZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.15e-8
R2 1 port2 4.90e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.50e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.00e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN11NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN11NJZ2
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN11NJZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.15e-8
R2 1 port2 4.90e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.50e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 190
L7 port1 5 8.00e-9
C7 5 6 8.00e-15
R7 6 port2 50.0
.ENDS LQP03TN11NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN12NHZ2
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN12NHZ2 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.26e-8
R2 1 port2 4.10e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 8.70e-15
R7 6 port2 50.0
.ENDS LQP03TN12NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN12NJZ2
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN12NJZ2 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.26e-8
R2 1 port2 4.10e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 8.70e-15
R7 6 port2 50.0
.ENDS LQP03TN12NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN13NHZ2
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN13NHZ2 port1 port2
C1 port1 port2 9.75e-14
L2 port1 1 1.36e-8
R2 1 port2 5.35e-1
R3 port1 port2 9.00e+3
L4 port1 2 2.80e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.90e-7
R6 4 port2 220
L7 port1 5 8.20e-9
C7 5 6 9.00e-15
R7 6 port2 40.0
.ENDS LQP03TN13NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN13NJZ2
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN13NJZ2 port1 port2
C1 port1 port2 9.75e-14
L2 port1 1 1.36e-8
R2 1 port2 5.35e-1
R3 port1 port2 9.00e+3
L4 port1 2 2.80e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.90e-7
R6 4 port2 220
L7 port1 5 8.20e-9
C7 5 6 9.00e-15
R7 6 port2 40.0
.ENDS LQP03TN13NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN15NHZ2
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN15NHZ2 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.62e-8
R2 1 port2 4.70e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 79.0
L7 port1 5 8.10e-9
C7 5 6 1.21e-14
R7 6 port2 50.0
.ENDS LQP03TN15NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN15NJZ2
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN15NJZ2 port1 port2
C1 port1 port2 1.12e-13
L2 port1 1 1.62e-8
R2 1 port2 4.70e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.60e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.35e-7
R6 4 port2 79.0
L7 port1 5 8.10e-9
C7 5 6 1.21e-14
R7 6 port2 50.0
.ENDS LQP03TN15NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN16NHZ2
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN16NHZ2 port1 port2
C1 port1 port2 1.05e-13
L2 port1 1 1.73e-8
R2 1 port2 6.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 2.70e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.70e-7
R6 4 port2 60.0
L7 port1 5 8.00e-9
C7 5 6 1.15e-14
R7 6 port2 40.0
.ENDS LQP03TN16NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN16NJZ2
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN16NJZ2 port1 port2
C1 port1 port2 1.05e-13
L2 port1 1 1.73e-8
R2 1 port2 6.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 2.70e-7
R4 2 port2 750
L5 port1 3 8.00e-7
R5 3 port2 500
L6 port1 4 2.70e-7
R6 4 port2 60.0
L7 port1 5 8.00e-9
C7 5 6 1.15e-14
R7 6 port2 40.0
.ENDS LQP03TN16NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN18NHZ2
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN18NHZ2 port1 port2
C1 port1 port2 1.22e-13
L2 port1 1 1.94e-8
R2 1 port2 5.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 3.70e-7
R4 2 port2 1.10e+3
L5 port1 3 6.50e-7
R5 3 port2 500
L6 port1 4 3.00e-7
R6 4 port2 90.0
L7 port1 5 1.71e-8
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN18NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN18NJZ2
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN18NJZ2 port1 port2
C1 port1 port2 1.22e-13
L2 port1 1 1.94e-8
R2 1 port2 5.00e-1
R3 port1 port2 1.20e+4
L4 port1 2 3.70e-7
R4 2 port2 1.10e+3
L5 port1 3 6.50e-7
R5 3 port2 500
L6 port1 4 3.00e-7
R6 4 port2 90.0
L7 port1 5 1.71e-8
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN18NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N0BZ2
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N0BZ2 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N0BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N0CZ2
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N0CZ2 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N0CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N1BZ2
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N1BZ2 port1 port2
C1 port1 port2 2.70e-14
L2 port1 1 8.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.60e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N1BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N1CZ2
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N1CZ2 port1 port2
C1 port1 port2 2.70e-14
L2 port1 1 8.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.60e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N1CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N2BZ2
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N2BZ2 port1 port2
C1 port1 port2 3.70e-14
L2 port1 1 9.00e-10
R2 1 port2 3.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N2BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N2CZ2
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N2CZ2 port1 port2
C1 port1 port2 3.70e-14
L2 port1 1 9.00e-10
R2 1 port2 3.80e-2
R3 port1 port2 2.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N2CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N3BZ2
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N3BZ2 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.02e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 2.10e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N3BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N3CZ2
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N3CZ2 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.02e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.00e+3
L4 port1 2 2.10e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N3CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N4BZ2
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N4BZ2 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.70e+3
L4 port1 2 2.25e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N4BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N4CZ2
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N4CZ2 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.70e+3
L4 port1 2 2.25e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N4CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N5BZ2
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N5BZ2 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 1.23e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.40e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N5BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N5CZ2
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N5CZ2 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 1.23e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.40e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N5CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N6BZ2
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N6BZ2 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.36e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.60e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N6BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N6CZ2
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N6CZ2 port1 port2
C1 port1 port2 2.30e-14
L2 port1 1 1.36e-9
R2 1 port2 5.50e-2
R3 port1 port2 2.80e+3
L4 port1 2 2.60e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N6CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N7BZ2
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N7BZ2 port1 port2
C1 port1 port2 3.45e-14
L2 port1 1 1.46e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 2.80e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N7BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N7CZ2
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N7CZ2 port1 port2
C1 port1 port2 3.45e-14
L2 port1 1 1.46e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 2.80e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N7CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N8BZ2
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N8BZ2 port1 port2
C1 port1 port2 4.15e-14
L2 port1 1 1.57e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N8BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N8CZ2
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N8CZ2 port1 port2
C1 port1 port2 4.15e-14
L2 port1 1 1.57e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N8CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N9BZ2
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N9BZ2 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 1.67e-9
R2 1 port2 5.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.20e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N9BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN1N9CZ2
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN1N9CZ2 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 1.67e-9
R2 1 port2 5.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 3.20e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TN1N9CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN20NHZ2
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN20NHZ2 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 2.16e-8
R2 1 port2 1.66
R3 port1 port2 1.30e+4
L4 port1 2 9.00e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 50.0
L7 port1 5 1.00e-8
C7 5 6 1.00e-14
R7 6 port2 30.0
.ENDS LQP03TN20NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN20NJZ2
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN20NJZ2 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 2.16e-8
R2 1 port2 1.66
R3 port1 port2 1.30e+4
L4 port1 2 9.00e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 50.0
L7 port1 5 1.00e-8
C7 5 6 1.00e-14
R7 6 port2 30.0
.ENDS LQP03TN20NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN22NHZ2
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN22NHZ2 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 2.40e-8
R2 1 port2 1.30
R3 port1 port2 1.30e+4
L4 port1 2 8.50e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.37e-14
R7 6 port2 70.0
.ENDS LQP03TN22NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN22NJZ2
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN22NJZ2 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 2.40e-8
R2 1 port2 1.30
R3 port1 port2 1.30e+4
L4 port1 2 8.50e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.37e-14
R7 6 port2 70.0
.ENDS LQP03TN22NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN24NHZ2
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN24NHZ2 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 2.63e-8
R2 1 port2 1.89
R3 port1 port2 1.45e+4
L4 port1 2 1.10e-6
R4 2 port2 750
L5 port1 3 5.60e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.30e-14
R7 6 port2 55.0
.ENDS LQP03TN24NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN24NJZ2
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN24NJZ2 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 2.63e-8
R2 1 port2 1.89
R3 port1 port2 1.45e+4
L4 port1 2 1.10e-6
R4 2 port2 750
L5 port1 3 5.60e-7
R5 3 port2 1.60e+3
L6 port1 4 2.90e-7
R6 4 port2 45.0
L7 port1 5 9.64e-9
C7 5 6 1.30e-14
R7 6 port2 55.0
.ENDS LQP03TN24NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN27NHZ2
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN27NHZ2 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 3.03e-8
R2 1 port2 1.60
R3 port1 port2 1.50e+4
L4 port1 2 5.50e-7
R4 2 port2 1.60e+3
L5 port1 3 7.50e-7
R5 3 port2 380
L6 port1 4 3.00e-7
R6 4 port2 35.0
L7 port1 5 1.15e-8
C7 5 6 1.37e-14
R7 6 port2 75.0
.ENDS LQP03TN27NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN27NJZ2
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN27NJZ2 port1 port2
C1 port1 port2 1.02e-13
L2 port1 1 3.03e-8
R2 1 port2 1.60
R3 port1 port2 1.50e+4
L4 port1 2 5.50e-7
R4 2 port2 1.60e+3
L5 port1 3 7.50e-7
R5 3 port2 380
L6 port1 4 3.00e-7
R6 4 port2 35.0
L7 port1 5 1.15e-8
C7 5 6 1.37e-14
R7 6 port2 75.0
.ENDS LQP03TN27NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N0BZ2
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N0BZ2 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.80e-9
R2 1 port2 6.30e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.30e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N0BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N0CZ2
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N0CZ2 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 1.80e-9
R2 1 port2 6.30e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.30e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N0CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N1BZ2
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N1BZ2 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 1.91e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.50e-8
R4 2 port2 70.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N1BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N1CZ2
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N1CZ2 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 1.91e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.30e+3
L4 port1 2 3.50e-8
R4 2 port2 70.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N1CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N2BZ2
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N2BZ2 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 2.01e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N2BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N2CZ2
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N2CZ2 port1 port2
C1 port1 port2 6.05e-14
L2 port1 1 2.01e-9
R2 1 port2 6.50e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.00e-8
R4 2 port2 80.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N2CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N3BZ2
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N3BZ2 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.11e-9
R2 1 port2 7.50e-2
R3 port1 port2 3.60e+3
L4 port1 2 4.70e-8
R4 2 port2 110
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N3BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N3CZ2
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N3CZ2 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.11e-9
R2 1 port2 7.50e-2
R3 port1 port2 3.60e+3
L4 port1 2 4.70e-8
R4 2 port2 110
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N3CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N4BZ2
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N4BZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.22e-9
R2 1 port2 8.30e-2
R3 port1 port2 3.80e+3
L4 port1 2 5.30e-8
R4 2 port2 150
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N4BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N4CZ2
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N4CZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.22e-9
R2 1 port2 8.30e-2
R3 port1 port2 3.80e+3
L4 port1 2 5.30e-8
R4 2 port2 150
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N4CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N5BZ2
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N5BZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 2.32e-9
R2 1 port2 8.90e-2
R3 port1 port2 4.40e+3
L4 port1 2 6.20e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N5BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N5CZ2
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N5CZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 2.32e-9
R2 1 port2 8.90e-2
R3 port1 port2 4.40e+3
L4 port1 2 6.20e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 9.50e-15
R7 6 port2 40.0
.ENDS LQP03TN2N5CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N6BZ2
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N6BZ2 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 2.44e-9
R2 1 port2 8.40e-2
R3 port1 port2 4.50e+3
L4 port1 2 5.50e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 8.90e-15
R7 6 port2 40.0
.ENDS LQP03TN2N6BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N6CZ2
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N6CZ2 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 2.44e-9
R2 1 port2 8.40e-2
R3 port1 port2 4.50e+3
L4 port1 2 5.50e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 37.0
L7 port1 5 5.00e-9
C7 5 6 8.90e-15
R7 6 port2 40.0
.ENDS LQP03TN2N6CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N7BZ2
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N7BZ2 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.55e-9
R2 1 port2 8.50e-2
R3 port1 port2 4.60e+3
L4 port1 2 5.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.60e-15
R7 6 port2 40.0
.ENDS LQP03TN2N7BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N7CZ2
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N7CZ2 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.55e-9
R2 1 port2 8.50e-2
R3 port1 port2 4.60e+3
L4 port1 2 5.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.60e-15
R7 6 port2 40.0
.ENDS LQP03TN2N7CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N8BZ2
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N8BZ2 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.65e-9
R2 1 port2 9.95e-2
R3 port1 port2 4.60e+3
L4 port1 2 6.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N8BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N8CZ2
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N8CZ2 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.65e-9
R2 1 port2 9.95e-2
R3 port1 port2 4.60e+3
L4 port1 2 6.60e-8
R4 2 port2 180
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N8CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N9BZ2
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N9BZ2 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.77e-9
R2 1 port2 1.05e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.10e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 40.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N9BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN2N9CZ2
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN2N9CZ2 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.77e-9
R2 1 port2 1.05e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.10e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 40.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN2N9CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN30NHZ2
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN30NHZ2 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.21e-8
R2 1 port2 1.63
R3 port1 port2 1.55e+4
L4 port1 2 6.50e-7
R4 2 port2 2.10e+3
L5 port1 3 4.80e-7
R5 3 port2 190
L6 port1 4 1.20e-6
R6 4 port2 60.0
L7 port1 5 2.20e-8
C7 5 6 8.25e-15
R7 6 port2 60.0
.ENDS LQP03TN30NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN30NJZ2
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN30NJZ2 port1 port2
C1 port1 port2 1.18e-13
L2 port1 1 3.21e-8
R2 1 port2 1.63
R3 port1 port2 1.55e+4
L4 port1 2 6.50e-7
R4 2 port2 2.10e+3
L5 port1 3 4.80e-7
R5 3 port2 190
L6 port1 4 1.20e-6
R6 4 port2 60.0
L7 port1 5 2.20e-8
C7 5 6 8.25e-15
R7 6 port2 60.0
.ENDS LQP03TN30NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN33NHZ2
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN33NHZ2 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 3.58e-8
R2 1 port2 2.48
R3 port1 port2 2.30e+4
L4 port1 2 6.50e-7
R4 2 port2 2.00e+3
L5 port1 3 6.00e-7
R5 3 port2 180
L6 port1 4 1.00e-6
R6 4 port2 41.0
L7 port1 5 2.20e-8
C7 5 6 8.80e-15
R7 6 port2 60.0
.ENDS LQP03TN33NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN33NJZ2
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN33NJZ2 port1 port2
C1 port1 port2 1.10e-13
L2 port1 1 3.58e-8
R2 1 port2 2.48
R3 port1 port2 2.30e+4
L4 port1 2 6.50e-7
R4 2 port2 2.00e+3
L5 port1 3 6.00e-7
R5 3 port2 180
L6 port1 4 1.00e-6
R6 4 port2 41.0
L7 port1 5 2.20e-8
C7 5 6 8.80e-15
R7 6 port2 60.0
.ENDS LQP03TN33NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN36NHZ2
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN36NHZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 3.98e-8
R2 1 port2 2.46
R3 port1 port2 1.20e+4
L4 port1 2 4.80e-7
R4 2 port2 800
L5 port1 3 8.20e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 1.86e-14
R7 6 port2 80.0
.ENDS LQP03TN36NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN36NJZ2
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN36NJZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 3.98e-8
R2 1 port2 2.46
R3 port1 port2 1.20e+4
L4 port1 2 4.80e-7
R4 2 port2 800
L5 port1 3 8.20e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 1.86e-14
R7 6 port2 80.0
.ENDS LQP03TN36NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN39NHZ2
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN39NHZ2 port1 port2
C1 port1 port2 1.17e-13
L2 port1 1 4.35e-8
R2 1 port2 2.35
R3 port1 port2 1.45e+4
L4 port1 2 4.50e-7
R4 2 port2 800
L5 port1 3 7.95e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 2.36e-14
R7 6 port2 70.0
.ENDS LQP03TN39NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN39NJZ2
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN39NJZ2 port1 port2
C1 port1 port2 1.17e-13
L2 port1 1 4.35e-8
R2 1 port2 2.35
R3 port1 port2 1.45e+4
L4 port1 2 4.50e-7
R4 2 port2 800
L5 port1 3 7.95e-7
R5 3 port2 100
L6 port1 4 1.18e-6
R6 4 port2 32.0
L7 port1 5 1.14e-8
C7 5 6 2.36e-14
R7 6 port2 70.0
.ENDS LQP03TN39NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N0BZ2
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N0BZ2 port1 port2
C1 port1 port2 5.93e-14
L2 port1 1 2.87e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN3N0BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N0CZ2
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N0CZ2 port1 port2
C1 port1 port2 5.93e-14
L2 port1 1 2.87e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.10e-15
R7 6 port2 40.0
.ENDS LQP03TN3N0CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N1BZ2
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N1BZ2 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 2.99e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.30e-15
R7 6 port2 40.0
.ENDS LQP03TN3N1BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N1CZ2
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N1CZ2 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 2.99e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.30e-15
R7 6 port2 40.0
.ENDS LQP03TN3N1CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N2BZ2
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N2BZ2 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.11e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.30e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N2BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N2CZ2
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N2CZ2 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.11e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.30e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N2CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N3BZ2
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N3BZ2 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.22e-9
R2 1 port2 1.27e-1
R3 port1 port2 5.50e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N3BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N3CZ2
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N3CZ2 port1 port2
C1 port1 port2 6.25e-14
L2 port1 1 3.22e-9
R2 1 port2 1.27e-1
R3 port1 port2 5.50e+3
L4 port1 2 7.30e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N3CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N4BZ2
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N4BZ2 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 3.34e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.40e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N4BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N4CZ2
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N4CZ2 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 3.34e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.40e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 9.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N4CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N5BZ2
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N5BZ2 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.46e-9
R2 1 port2 1.35e-1
R3 port1 port2 6.00e+3
L4 port1 2 7.70e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N5BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N5CZ2
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N5CZ2 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.46e-9
R2 1 port2 1.35e-1
R3 port1 port2 6.00e+3
L4 port1 2 7.70e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 38.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N5CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N6BZ2
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N6BZ2 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 1.25e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 25.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N6BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N6CZ2
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N6CZ2 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 1.25e-1
R3 port1 port2 6.00e+3
L4 port1 2 8.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 25.0
L7 port1 5 5.00e-9
C7 5 6 6.80e-15
R7 6 port2 40.0
.ENDS LQP03TN3N6CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N7BZ2
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N7BZ2 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.69e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.30e+3
L4 port1 2 9.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 35.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N7BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N7CZ2
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N7CZ2 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.69e-9
R2 1 port2 1.00e-1
R3 port1 port2 6.30e+3
L4 port1 2 9.00e-8
R4 2 port2 200
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 5.00e-8
R6 4 port2 35.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N7CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N8BZ2
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N8BZ2 port1 port2
C1 port1 port2 1.08e-13
L2 port1 1 3.73e-9
R2 1 port2 1.40e-1
R3 port1 port2 6.50e+3
L4 port1 2 1.00e-7
R4 2 port2 250
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N8BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N8CZ2
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N8CZ2 port1 port2
C1 port1 port2 1.08e-13
L2 port1 1 3.73e-9
R2 1 port2 1.40e-1
R3 port1 port2 6.50e+3
L4 port1 2 1.00e-7
R4 2 port2 250
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 7.20e-15
R7 6 port2 40.0
.ENDS LQP03TN3N8CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N9BZ2
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N9BZ2 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.83e-9
R2 1 port2 1.30e-1
R3 port1 port2 4.80e+3
L4 port1 2 1.30e-7
R4 2 port2 300
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 40.0
.ENDS LQP03TN3N9BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN3N9CZ2
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN3N9CZ2 port1 port2
C1 port1 port2 1.06e-13
L2 port1 1 3.83e-9
R2 1 port2 1.30e-1
R3 port1 port2 4.80e+3
L4 port1 2 1.30e-7
R4 2 port2 300
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 40.0
.ENDS LQP03TN3N9CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN43NHZ2
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN43NHZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 4.86e-8
R2 1 port2 2.33
R3 port1 port2 1.20e+4
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 8.00e-7
R5 3 port2 120
L6 port1 4 1.30e-6
R6 4 port2 30.0
L7 port1 5 1.14e-8
C7 5 6 2.70e-14
R7 6 port2 100
.ENDS LQP03TN43NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN43NJZ2
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN43NJZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 4.86e-8
R2 1 port2 2.33
R3 port1 port2 1.20e+4
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 8.00e-7
R5 3 port2 120
L6 port1 4 1.30e-6
R6 4 port2 30.0
L7 port1 5 1.14e-8
C7 5 6 2.70e-14
R7 6 port2 100
.ENDS LQP03TN43NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN47NHZ2
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN47NHZ2 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 5.20e-8
R2 1 port2 2.95
R3 port1 port2 2.60e+4
L4 port1 2 7.00e-7
R4 2 port2 1.90e+3
L5 port1 3 7.95e-7
R5 3 port2 200
L6 port1 4 1.05e-6
R6 4 port2 60.0
L7 port1 5 2.48e-8
C7 5 6 1.23e-14
R7 6 port2 85.0
L8 port1 7 6.70e-9
C8 7 8 1.32e-14
R8 8 port2 80.0
.ENDS LQP03TN47NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN47NJZ2
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN47NJZ2 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 5.20e-8
R2 1 port2 2.95
R3 port1 port2 2.60e+4
L4 port1 2 7.00e-7
R4 2 port2 1.90e+3
L5 port1 3 7.95e-7
R5 3 port2 200
L6 port1 4 1.05e-6
R6 4 port2 60.0
L7 port1 5 2.48e-8
C7 5 6 1.23e-14
R7 6 port2 85.0
L8 port1 7 6.70e-9
C8 7 8 1.32e-14
R8 8 port2 80.0
.ENDS LQP03TN47NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N0BZ2
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N0BZ2 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 3.93e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
.ENDS LQP03TN4N0BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N0CZ2
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N0CZ2 port1 port2
C1 port1 port2 9.50e-14
L2 port1 1 3.93e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 65.0
.ENDS LQP03TN4N0CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N1BZ2
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N1BZ2 port1 port2
C1 port1 port2 9.55e-14
L2 port1 1 4.03e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N1BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N1CZ2
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N1CZ2 port1 port2
C1 port1 port2 9.55e-14
L2 port1 1 4.03e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.50e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N1CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N2BZ2
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N2BZ2 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 4.16e-9
R2 1 port2 1.90e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.60e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N2BZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N2CZ2
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N2CZ2 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 4.16e-9
R2 1 port2 1.90e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.60e-7
R4 2 port2 300
L5 port1 3 2.00e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 60.0
.ENDS LQP03TN4N2CZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N3HZ2
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N3HZ2 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 4.30e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.30e+3
L4 port1 2 1.30e-7
R4 2 port2 400
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN4N3HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N3JZ2
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N3JZ2 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 4.30e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.30e+3
L4 port1 2 1.30e-7
R4 2 port2 400
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 6.50e-15
R7 6 port2 60.0
.ENDS LQP03TN4N3JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N7HZ2
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N7HZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.75e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN4N7HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN4N7JZ2
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN4N7JZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 4.75e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN4N7JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN51NHZ2
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN51NHZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 5.80e-8
R2 1 port2 2.58
R3 port1 port2 1.30e+4
L4 port1 2 6.60e-7
R4 2 port2 1.00e+3
L5 port1 3 1.10e-6
R5 3 port2 220
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.05e-8
C7 5 6 1.85e-14
R7 6 port2 150
L8 port1 7 1.10e-8
C8 7 8 7.78e-15
R8 8 port2 180
.ENDS LQP03TN51NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN51NJZ2
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN51NJZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 5.80e-8
R2 1 port2 2.58
R3 port1 port2 1.30e+4
L4 port1 2 6.60e-7
R4 2 port2 1.00e+3
L5 port1 3 1.10e-6
R5 3 port2 220
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.05e-8
C7 5 6 1.85e-14
R7 6 port2 150
L8 port1 7 1.10e-8
C8 7 8 7.78e-15
R8 8 port2 180
.ENDS LQP03TN51NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN56NHZ2
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN56NHZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 6.37e-8
R2 1 port2 3.42
R3 port1 port2 1.70e+4
L4 port1 2 7.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 35.0
L7 port1 5 2.12e-8
C7 5 6 1.85e-14
R7 6 port2 100
L8 port1 7 1.49e-8
C8 7 8 7.58e-15
R8 8 port2 80.0
.ENDS LQP03TN56NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN56NJZ2
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN56NJZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 6.37e-8
R2 1 port2 3.42
R3 port1 port2 1.70e+4
L4 port1 2 7.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 35.0
L7 port1 5 2.12e-8
C7 5 6 1.85e-14
R7 6 port2 100
L8 port1 7 1.49e-8
C8 7 8 7.58e-15
R8 8 port2 80.0
.ENDS LQP03TN56NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N1HZ2
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N1HZ2 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 5.24e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.80e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN5N1HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N1JZ2
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N1JZ2 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 5.24e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.80e+3
L4 port1 2 2.00e-7
R4 2 port2 500
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 50.0
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN5N1JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N6HZ2
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N6HZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 5.80e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.70e-7
R4 2 port2 980
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 37.0
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN5N6HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN5N6JZ2
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN5N6JZ2 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 5.80e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.70e-7
R4 2 port2 980
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 37.0
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN5N6JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN62NHZ2
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN62NHZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 7.17e-8
R2 1 port2 3.32
R3 port1 port2 1.50e+4
L4 port1 2 8.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.45e-8
C7 5 6 1.85e-14
R7 6 port2 140
L8 port1 7 1.70e-8
C8 7 8 7.58e-15
R8 8 port2 100
.ENDS LQP03TN62NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN62NJZ2
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN62NJZ2 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 7.17e-8
R2 1 port2 3.32
R3 port1 port2 1.50e+4
L4 port1 2 8.00e-7
R4 2 port2 1.23e+3
L5 port1 3 1.10e-6
R5 3 port2 160
L6 port1 4 9.00e-7
R6 4 port2 50.0
L7 port1 5 2.45e-8
C7 5 6 1.85e-14
R7 6 port2 140
L8 port1 7 1.70e-8
C8 7 8 7.58e-15
R8 8 port2 100
.ENDS LQP03TN62NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN68NHZ2
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN68NHZ2 port1 port2
C1 port1 port2 1.53e-13
L2 port1 1 7.88e-8
R2 1 port2 5.90
R3 port1 port2 1.10e+4
L4 port1 2 8.50e-7
R4 2 port2 1.20e+3
L5 port1 3 8.50e-7
R5 3 port2 180
L6 port1 4 1.22e-6
R6 4 port2 47.0
L7 port1 5 3.80e-8
C7 5 6 1.33e-14
R7 6 port2 120
L8 port1 7 2.62e-8
C8 7 8 5.31e-15
R8 8 port2 130
.ENDS LQP03TN68NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN68NJZ2
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN68NJZ2 port1 port2
C1 port1 port2 1.53e-13
L2 port1 1 7.88e-8
R2 1 port2 5.90
R3 port1 port2 1.10e+4
L4 port1 2 8.50e-7
R4 2 port2 1.20e+3
L5 port1 3 8.50e-7
R5 3 port2 180
L6 port1 4 1.22e-6
R6 4 port2 47.0
L7 port1 5 3.80e-8
C7 5 6 1.33e-14
R7 6 port2 120
L8 port1 7 2.62e-8
C8 7 8 5.31e-15
R8 8 port2 130
.ENDS LQP03TN68NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N2HZ2
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N2HZ2 port1 port2
C1 port1 port2 6.10e-14
L2 port1 1 6.20e-9
R2 1 port2 3.40e-1
R3 port1 port2 6.00e+3
L4 port1 2 1.40e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 350
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN6N2HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N2JZ2
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N2JZ2 port1 port2
C1 port1 port2 6.10e-14
L2 port1 1 6.20e-9
R2 1 port2 3.40e-1
R3 port1 port2 6.00e+3
L4 port1 2 1.40e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 350
L7 port1 5 8.10e-9
C7 5 6 6.80e-15
R7 6 port2 60.0
.ENDS LQP03TN6N2JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N8HZ2
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N8HZ2 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 6.90e-9
R2 1 port2 2.85e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN6N8HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN6N8JZ2
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN6N8JZ2 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 6.90e-9
R2 1 port2 2.85e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.00e-15
R7 6 port2 60.0
.ENDS LQP03TN6N8JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN75NHZ2
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN75NHZ2 port1 port2
C1 port1 port2 1.55e-13
L2 port1 1 9.00e-8
R2 1 port2 5.70
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-7
R4 2 port2 1.35e+3
L5 port1 3 9.70e-7
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 95.0
L7 port1 5 5.50e-8
C7 5 6 1.04e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.20e-15
R8 8 port2 200
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN75NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN75NJZ2
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN75NJZ2 port1 port2
C1 port1 port2 1.55e-13
L2 port1 1 9.00e-8
R2 1 port2 5.70
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-7
R4 2 port2 1.35e+3
L5 port1 3 9.70e-7
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 95.0
L7 port1 5 5.50e-8
C7 5 6 1.04e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.20e-15
R8 8 port2 200
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN75NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN7N5HZ2
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN7N5HZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 7.74e-9
R2 1 port2 2.95e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 210
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 60.0
.ENDS LQP03TN7N5HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN7N5JZ2
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN7N5JZ2 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 7.74e-9
R2 1 port2 2.95e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 500
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.40e-7
R6 4 port2 210
L7 port1 5 8.10e-9
C7 5 6 8.00e-15
R7 6 port2 60.0
.ENDS LQP03TN7N5JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN82NHZ2
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN82NHZ2 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.00e-7
R2 1 port2 6.20
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 100
L7 port1 5 5.50e-8
C7 5 6 1.10e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.40e-15
R8 8 port2 250
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN82NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN82NJZ2
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN82NJZ2 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.00e-7
R2 1 port2 6.20
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 180
L6 port1 4 8.00e-7
R6 4 port2 100
L7 port1 5 5.50e-8
C7 5 6 1.10e-14
R7 6 port2 140
L8 port1 7 4.00e-8
C8 7 8 4.40e-15
R8 8 port2 250
L9 port1 9 6.19e-8
C9 9 10 1.26e-15
R9 10 port2 300
.ENDS LQP03TN82NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN8N2HZ2
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN8N2HZ2 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 8.40e-9
R2 1 port2 4.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.50e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 80.0
.ENDS LQP03TN8N2HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN8N2JZ2
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN8N2JZ2 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 8.40e-9
R2 1 port2 4.40e-1
R3 port1 port2 7.00e+3
L4 port1 2 2.10e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.50e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 80.0
.ENDS LQP03TN8N2JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN91NHZ2
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN91NHZ2 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.13e-7
R2 1 port2 6.35
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 140
L6 port1 4 8.50e-7
R6 4 port2 60.0
L7 port1 5 5.50e-8
C7 5 6 1.35e-14
R7 6 port2 160
L8 port1 7 4.00e-8
C8 7 8 5.40e-15
R8 8 port2 250
.ENDS LQP03TN91NHZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN91NJZ2
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN91NJZ2 port1 port2
C1 port1 port2 1.45e-13
L2 port1 1 1.13e-7
R2 1 port2 6.35
R3 port1 port2 1.20e+4
L4 port1 2 1.05e-6
R4 2 port2 1.35e+3
L5 port1 3 1.00e-6
R5 3 port2 140
L6 port1 4 8.50e-7
R6 4 port2 60.0
L7 port1 5 5.50e-8
C7 5 6 1.35e-14
R7 6 port2 160
L8 port1 7 4.00e-8
C8 7 8 5.40e-15
R8 8 port2 250
.ENDS LQP03TN91NJZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN9N1HZ2
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN9N1HZ2 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 9.50e-9
R2 1 port2 3.25e-1
R3 port1 port2 7.50e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.30e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 50.0
.ENDS LQP03TN9N1HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TN9N1JZ2
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TN9N1JZ2 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 9.50e-9
R2 1 port2 3.25e-1
R3 port1 port2 7.50e+3
L4 port1 2 2.30e-7
R4 2 port2 750
L5 port1 3 3.00e-7
R5 3 port2 150
L6 port1 4 2.30e-7
R6 4 port2 200
L7 port1 5 8.10e-9
C7 5 6 7.50e-15
R7 6 port2 50.0
.ENDS LQP03TN9N1JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR10HZ2
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR10HZ2 port1 port2
C1 port1 port2 1.42e-13
L2 port1 1 1.15e-7
R2 1 port2 7.05
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 8.80e-7
R5 3 port2 180
L6 port1 4 3.90e-6
R6 4 port2 250
L7 port1 5 8.66e-8
C7 5 6 9.00e-15
R7 6 port2 180
L8 port1 7 5.06e-8
C8 7 8 4.54e-15
R8 8 port2 191
L9 port1 9 1.39e-8
C9 9 10 8.65e-15
R9 10 port2 120
L10 port1 11 5.68e-9
C10 11 12 1.24e-14
R10 12 port2 80.0
.ENDS LQP03TNR10HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR10JZ2
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR10JZ2 port1 port2
C1 port1 port2 1.42e-13
L2 port1 1 1.15e-7
R2 1 port2 7.05
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 8.80e-7
R5 3 port2 180
L6 port1 4 3.90e-6
R6 4 port2 250
L7 port1 5 8.66e-8
C7 5 6 9.00e-15
R7 6 port2 180
L8 port1 7 5.06e-8
C8 7 8 4.54e-15
R8 8 port2 191
L9 port1 9 1.39e-8
C9 9 10 8.65e-15
R9 10 port2 120
L10 port1 11 5.68e-9
C10 11 12 1.24e-14
R10 12 port2 80.0
.ENDS LQP03TNR10JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR11HZ2
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR11HZ2 port1 port2
C1 port1 port2 1.60e-13
L2 port1 1 1.21e-7
R2 1 port2 7.70
R3 port1 port2 1.40e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 9.00e-7
R5 3 port2 180
L6 port1 4 8.00e-6
R6 4 port2 400
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 5.80e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.30e-15
R9 10 port2 200
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 250
.ENDS LQP03TNR11HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR11JZ2
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR11JZ2 port1 port2
C1 port1 port2 1.60e-13
L2 port1 1 1.21e-7
R2 1 port2 7.70
R3 port1 port2 1.40e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 9.00e-7
R5 3 port2 180
L6 port1 4 8.00e-6
R6 4 port2 400
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 5.80e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.30e-15
R9 10 port2 200
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 250
.ENDS LQP03TNR11JZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR12HZ2
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR12HZ2 port1 port2
C1 port1 port2 1.64e-13
L2 port1 1 1.34e-7
R2 1 port2 7.90
R3 port1 port2 1.50e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 8.90e-7
R5 3 port2 205
L6 port1 4 6.80e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 6.08e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.23e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 150
.ENDS LQP03TNR12HZ2
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TNR12JZ2
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TNR12JZ2 port1 port2
C1 port1 port2 1.64e-13
L2 port1 1 1.34e-7
R2 1 port2 7.90
R3 port1 port2 1.50e+4
L4 port1 2 1.60e-6
R4 2 port2 2.50e+3
L5 port1 3 8.90e-7
R5 3 port2 205
L6 port1 4 6.80e-6
R6 4 port2 300
L7 port1 5 7.07e-8
C7 5 6 1.43e-14
R7 6 port2 200
L8 port1 7 4.92e-8
C8 7 8 6.08e-15
R8 8 port2 250
L9 port1 9 2.23e-8
C9 9 10 6.23e-15
R9 10 port2 250
L10 port1 11 1.19e-8
C10 11 12 6.57e-15
R10 12 port2 150
.ENDS LQP03TNR12JZ2
*----------------------------------------------------------------------
