*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN10NG02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN10NG02 port1 port2
C1 port1 port2 8.80e-14
L2 port1 1 1.01e-8
R2 1 port2 7.00e-1
R3 port1 port2 1.30e+4
L4 port1 2 1.40e-7
R4 2 port2 460
L5 port1 3 6.00e-7
R5 3 port2 40.0
.ENDS LQP15MN10NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN12NG02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN12NG02 port1 port2
C1 port1 port2 8.80e-14
L2 port1 1 1.21e-8
R2 1 port2 1.00
R3 port1 port2 1.30e+4
L4 port1 2 2.20e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 50.0
.ENDS LQP15MN12NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN15NG02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN15NG02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 1.54e-8
R2 1 port2 1.30
R3 port1 port2 1.30e+4
L4 port1 2 2.55e-7
R4 2 port2 700
L5 port1 3 5.00e-7
R5 3 port2 50.0
.ENDS LQP15MN15NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN18NG02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN18NG02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 1.84e-8
R2 1 port2 1.55
R3 port1 port2 1.55e+4
L4 port1 2 3.10e-7
R4 2 port2 1.00e+3
L5 port1 3 6.00e-7
R5 3 port2 50.0
.ENDS LQP15MN18NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N0B02 port1 port2
C1 port1 port2 5.00e-15
L2 port1 1 6.35e-10
R2 1 port2 1.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.00e-7
R4 2 port2 2.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.10e-8
R6 4 port2 40.0
.ENDS LQP15MN1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N0W02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N0W02 port1 port2
C1 port1 port2 5.00e-15
L2 port1 1 6.35e-10
R2 1 port2 1.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.00e-7
R4 2 port2 2.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.10e-8
R6 4 port2 40.0
.ENDS LQP15MN1N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N1B02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 7.45e-10
R2 1 port2 1.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.10e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.10e-8
R6 4 port2 40.0
.ENDS LQP15MN1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N1W02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N1W02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 7.45e-10
R2 1 port2 1.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.10e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.10e-8
R6 4 port2 40.0
.ENDS LQP15MN1N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N2B02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 8.48e-10
R2 1 port2 1.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.10e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N2W02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N2W02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 8.48e-10
R2 1 port2 1.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.10e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N3B02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 9.48e-10
R2 1 port2 3.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 9.50e-8
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N3W02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N3W02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 9.48e-10
R2 1 port2 3.80e-2
R3 port1 port2 3.00e+3
L4 port1 2 9.50e-8
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N3W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N4W02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N4W02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 1.07e-9
R2 1 port2 4.30e-2
R3 port1 port2 3.00e+3
L4 port1 2 9.00e-8
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N5B02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 1.17e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.20e+3
L4 port1 2 1.05e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N5W02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N5W02 port1 port2
C1 port1 port2 1.30e-14
L2 port1 1 1.17e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.20e+3
L4 port1 2 1.05e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.20e-8
R6 4 port2 40.0
.ENDS LQP15MN1N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N6B02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 1.28e-9
R2 1 port2 1.20e-1
R3 port1 port2 3.20e+3
L4 port1 2 8.00e-8
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.30e-8
R6 4 port2 40.0
.ENDS LQP15MN1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N6W02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N6W02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 1.28e-9
R2 1 port2 1.20e-1
R3 port1 port2 3.20e+3
L4 port1 2 8.00e-8
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.30e-8
R6 4 port2 40.0
.ENDS LQP15MN1N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N7W02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N7W02 port1 port2
C1 port1 port2 3.10e-14
L2 port1 1 1.40e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.40e+3
L4 port1 2 1.40e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.30e-8
R6 4 port2 40.0
.ENDS LQP15MN1N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N8B02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.51e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.80e+3
L4 port1 2 1.40e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.50e-8
R6 4 port2 40.0
.ENDS LQP15MN1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N8W02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N8W02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.51e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.80e+3
L4 port1 2 1.40e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 2.50e-8
R6 4 port2 40.0
.ENDS LQP15MN1N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN1N9W02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN1N9W02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.61e-9
R2 1 port2 7.00e-2
R3 port1 port2 4.20e+3
L4 port1 2 1.20e-7
R4 2 port2 600
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP15MN1N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN22NG02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN22NG02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 2.25e-8
R2 1 port2 2.00
R3 port1 port2 1.60e+4
L4 port1 2 5.00e-7
R4 2 port2 1.60e+3
L5 port1 3 6.00e-7
R5 3 port2 50.0
.ENDS LQP15MN22NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN27NG02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN27NG02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 2.77e-8
R2 1 port2 2.50
R3 port1 port2 2.20e+4
L4 port1 2 7.00e-7
R4 2 port2 2.80e+3
L5 port1 3 6.00e-7
R5 3 port2 50.0
.ENDS LQP15MN27NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N0B02 port1 port2
C1 port1 port2 4.57e-14
L2 port1 1 1.71e-9
R2 1 port2 7.00e-2
R3 port1 port2 5.00e+3
L4 port1 2 1.30e-7
R4 2 port2 600
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP15MN2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N0W02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N0W02 port1 port2
C1 port1 port2 4.57e-14
L2 port1 1 1.71e-9
R2 1 port2 7.00e-2
R3 port1 port2 5.00e+3
L4 port1 2 1.30e-7
R4 2 port2 600
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP15MN2N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N1W02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N1W02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 1.83e-9
R2 1 port2 8.00e-2
R3 port1 port2 5.00e+3
L4 port1 2 1.70e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.10e-8
R6 4 port2 40.0
.ENDS LQP15MN2N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N2B02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 1.93e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.90e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.10e-8
R6 4 port2 40.0
.ENDS LQP15MN2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N2W02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N2W02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 1.93e-9
R2 1 port2 1.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.90e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.10e-8
R6 4 port2 40.0
.ENDS LQP15MN2N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N3W02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N3W02 port1 port2
C1 port1 port2 5.10e-14
L2 port1 1 2.03e-9
R2 1 port2 1.05e-1
R3 port1 port2 6.00e+3
L4 port1 2 1.50e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.20e-8
R6 4 port2 40.0
.ENDS LQP15MN2N3W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N4B02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 2.14e-9
R2 1 port2 1.15e-1
R3 port1 port2 6.00e+3
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.20e-8
R6 4 port2 40.0
.ENDS LQP15MN2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N4W02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N4W02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 2.14e-9
R2 1 port2 1.15e-1
R3 port1 port2 6.00e+3
L4 port1 2 5.00e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.20e-8
R6 4 port2 40.0
.ENDS LQP15MN2N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N5W02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N5W02 port1 port2
C1 port1 port2 8.30e-14
L2 port1 1 2.25e-9
R2 1 port2 1.00e-1
R3 port1 port2 3.80e+3
L4 port1 2 3.00e-7
R4 2 port2 700
L5 port1 3 1.20e-7
R5 3 port2 1.00e+3
L6 port1 4 3.30e-8
R6 4 port2 40.0
.ENDS LQP15MN2N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N6W02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N6W02 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 2.38e-9
R2 1 port2 1.45e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.35e-7
R4 2 port2 800
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.30e-8
R6 4 port2 30.0
.ENDS LQP15MN2N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N7B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 2.48e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.60e-7
R4 2 port2 800
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.50e-8
R6 4 port2 30.0
.ENDS LQP15MN2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N7W02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N7W02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 2.48e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.60e-7
R4 2 port2 800
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.50e-8
R6 4 port2 30.0
.ENDS LQP15MN2N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N8W02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N8W02 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 2.60e-9
R2 1 port2 1.70e-1
R3 port1 port2 5.70e+3
L4 port1 2 1.50e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.50e-8
R6 4 port2 30.0
.ENDS LQP15MN2N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN2N9W02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN2N9W02 port1 port2
C1 port1 port2 5.75e-14
L2 port1 1 2.70e-9
R2 1 port2 2.05e-1
R3 port1 port2 5.40e+3
L4 port1 2 1.70e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.60e-8
R6 4 port2 30.0
.ENDS LQP15MN2N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN33NG02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN33NG02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 3.45e-8
R2 1 port2 3.25
R3 port1 port2 2.20e+4
L4 port1 2 8.00e-7
R4 2 port2 2.80e+3
L5 port1 3 6.00e-7
R5 3 port2 50.0
.ENDS LQP15MN33NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N0B02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 2.80e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.40e+3
L4 port1 2 1.80e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.60e-8
R6 4 port2 30.0
.ENDS LQP15MN3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N0W02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N0W02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 2.80e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.40e+3
L4 port1 2 1.80e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.60e-8
R6 4 port2 30.0
.ENDS LQP15MN3N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N1W02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N1W02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 2.93e-9
R2 1 port2 2.90e-1
R3 port1 port2 5.40e+3
L4 port1 2 1.80e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.50e-8
R6 4 port2 30.0
.ENDS LQP15MN3N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N2W02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N2W02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 3.08e-9
R2 1 port2 1.90e-1
R3 port1 port2 6.40e+3
L4 port1 2 1.35e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.50e-8
R6 4 port2 35.0
.ENDS LQP15MN3N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N3B02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.20e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.40e+3
L4 port1 2 1.40e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.60e-8
R6 4 port2 35.0
.ENDS LQP15MN3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N3W02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N3W02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 3.20e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.40e+3
L4 port1 2 1.40e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 3.60e-8
R6 4 port2 35.0
.ENDS LQP15MN3N3W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N4W02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N4W02 port1 port2
C1 port1 port2 6.90e-14
L2 port1 1 3.30e-9
R2 1 port2 1.90e-1
R3 port1 port2 6.40e+3
L4 port1 2 1.40e-7
R4 2 port2 1.00e+3
L5 port1 3 1.70e-7
R5 3 port2 1.00e+3
L6 port1 4 4.00e-8
R6 4 port2 35.0
.ENDS LQP15MN3N4W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N5W02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N5W02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 3.40e-9
R2 1 port2 2.10e-1
R3 port1 port2 6.40e+3
L4 port1 2 1.80e-7
R4 2 port2 1.00e+3
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.20e-8
R6 4 port2 35.0
.ENDS LQP15MN3N5W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N6B02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 3.53e-9
R2 1 port2 2.10e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.40e-7
R4 2 port2 800
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.20e-8
R6 4 port2 35.0
.ENDS LQP15MN3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N6W02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N6W02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 3.53e-9
R2 1 port2 2.10e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.40e-7
R4 2 port2 800
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.20e-8
R6 4 port2 35.0
.ENDS LQP15MN3N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N7W02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N7W02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 3.63e-9
R2 1 port2 2.10e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 800
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.30e-8
R6 4 port2 35.0
.ENDS LQP15MN3N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N8W02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N8W02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 3.74e-9
R2 1 port2 2.10e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.50e-7
R4 2 port2 800
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.50e-8
R6 4 port2 35.0
.ENDS LQP15MN3N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N9B02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 3.85e-9
R2 1 port2 2.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.00e-7
R4 2 port2 1.00e+3
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.50e-8
R6 4 port2 35.0
.ENDS LQP15MN3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN3N9W02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN3N9W02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 3.85e-9
R2 1 port2 2.60e-1
R3 port1 port2 8.00e+3
L4 port1 2 2.00e-7
R4 2 port2 1.00e+3
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 4.50e-8
R6 4 port2 35.0
.ENDS LQP15MN3N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN4N3B02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN4N3B02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 4.27e-9
R2 1 port2 3.00e-1
R3 port1 port2 8.50e+3
L4 port1 2 2.40e-7
R4 2 port2 980
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 5.50e-8
R6 4 port2 35.0
.ENDS LQP15MN4N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN4N7B02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN4N7B02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 4.67e-9
R2 1 port2 3.40e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.10e-7
R4 2 port2 980
L5 port1 3 1.80e-7
R5 3 port2 1.00e+3
L6 port1 4 7.00e-8
R6 4 port2 35.0
.ENDS LQP15MN4N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN5N1B02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN5N1B02 port1 port2
C1 port1 port2 7.60e-14
L2 port1 1 5.10e-9
R2 1 port2 3.90e-1
R3 port1 port2 1.10e+4
L4 port1 2 2.10e-7
R4 2 port2 980
L5 port1 3 2.10e-7
R5 3 port2 1.00e+3
L6 port1 4 8.00e-8
R6 4 port2 35.0
.ENDS LQP15MN5N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN5N6B02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN5N6B02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 5.75e-9
R2 1 port2 4.10e-1
R3 port1 port2 1.00e+4
L4 port1 2 1.80e-7
R4 2 port2 980
L5 port1 3 2.30e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 43.0
.ENDS LQP15MN5N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN6N2B02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN6N2B02 port1 port2
C1 port1 port2 7.90e-14
L2 port1 1 6.20e-9
R2 1 port2 5.08e-1
R3 port1 port2 8.00e+3
L4 port1 2 7.30e-8
R4 2 port2 180
L5 port1 3 5.00e-7
R5 3 port2 50.0
.ENDS LQP15MN6N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN6N8B02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN6N8B02 port1 port2
C1 port1 port2 7.90e-14
L2 port1 1 6.79e-9
R2 1 port2 6.00e-1
R3 port1 port2 8.00e+3
L4 port1 2 9.00e-8
R4 2 port2 220
L5 port1 3 5.00e-7
R5 3 port2 50.0
.ENDS LQP15MN6N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN7N5B02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN7N5B02 port1 port2
C1 port1 port2 7.90e-14
L2 port1 1 7.44e-9
R2 1 port2 7.30e-1
R3 port1 port2 1.00e+4
L4 port1 2 1.23e-7
R4 2 port2 340
L5 port1 3 6.00e-7
R5 3 port2 40.0
.ENDS LQP15MN7N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN8N2B02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN8N2B02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 8.15e-9
R2 1 port2 7.80e-1
R3 port1 port2 1.00e+4
L4 port1 2 1.38e-7
R4 2 port2 380
L5 port1 3 6.00e-7
R5 3 port2 40.0
.ENDS LQP15MN8N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP15MN9N1B02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP15MN9N1B02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 9.05e-9
R2 1 port2 1.00
R3 port1 port2 1.30e+4
L4 port1 2 1.60e-7
R4 2 port2 500
L5 port1 3 6.00e-7
R5 3 port2 40.0
.ENDS LQP15MN9N1B02
*----------------------------------------------------------------------
