*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCH1555C1H100JE01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H100JE01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.32e-11
R04 N03 N04 2.11e-01
L05 N04 N05 3.26e-11
R05 N04 N05 8.18e-02
C06 N05 N06 3.81e-11
L06 N05 N06 2.36e-11
R06 N05 N06 5.83e+00
C07 N06 Port2 9.48e-12
L07 N06 Port2 2.70e-11
R07 N06 Port2 4.13e+00
.ENDS GCH1555C1H100JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GCH1555C1H101JE01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H101JE01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.65e-10
R03 N02 N03 7.87e-02
L04 N03 N04 1.32e-11
R04 N03 N04 6.83e-02
L05 N04 N05 1.76e-11
R05 N04 N05 2.48e-02
C06 N05 N06 1.08e-09
L06 N05 N06 6.64e-12
R06 N05 N06 4.45e-01
C07 N06 N07 1.58e-10
L07 N06 N07 1.89e-11
R07 N06 N07 1.24e+00
C08 N07 N08 2.89e-11
L08 N07 N08 2.30e-11
R08 N07 N08 1.17e+00
C09 N08 Port2 8.66e-12
L09 N08 Port2 2.98e-11
R09 N08 Port2 1.00e+05
.ENDS GCH1555C1H101JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCH1555C1H102JE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H102JE01 Port1 Port2
C01 Port1 N01 9.77e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.14e-10
R03 N02 N03 6.26e-03
L04 N03 N04 4.62e-11
R04 N03 N04 5.11e-01
L05 N04 N05 1.65e-11
R05 N04 N05 2.04e-02
L06 N05 N06 8.17e-11
R06 N05 N06 1.18e-02
C07 N06 N07 5.96e-09
L07 N06 N07 1.38e-11
R07 N06 N07 3.31e-01
C08 N07 N08 2.18e-09
L08 N07 N08 1.73e-11
R08 N07 N08 5.34e-01
C09 N08 N09 7.85e-09
L09 N08 N09 2.16e-12
R09 N08 N09 6.48e-02
C10 N09 N10 2.61e-09
L10 N09 N10 4.42e-12
R10 N09 N10 1.43e-01
C11 N10 Port2 5.32e-11
L11 N10 Port2 5.05e-12
R11 N10 Port2 4.06e-01
.ENDS GCH1555C1H102JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GCH1555C1H150JE01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H150JE01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.37e-10
R03 N02 N03 1.06e-01
L04 N03 N04 2.01e-11
R04 N03 N04 4.00e-01
L05 N04 N05 3.51e-11
R05 N04 N05 1.05e-01
C06 N05 N06 1.06e-10
L06 N05 N06 1.01e-11
R06 N05 N06 1.61e+00
C07 N06 N07 2.87e-11
L07 N06 N07 1.18e-11
R07 N06 N07 2.13e+00
C08 N07 Port2 2.32e-12
L08 N07 Port2 8.88e-11
R08 N07 Port2 1.00e+05
.ENDS GCH1555C1H150JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GCH1555C1H151JE01
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H151JE01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.49e-10
R03 N02 N03 8.71e-02
L04 N03 N04 1.15e-11
R04 N03 N04 4.61e-02
C05 N04 N05 1.47e-09
L05 N04 N05 7.15e-12
R05 N04 N05 2.75e-01
C06 N05 N06 2.51e-10
L06 N05 N06 1.73e-11
R06 N05 N06 8.55e-01
C07 N06 N07 6.99e-12
L07 N06 N07 4.64e-11
R07 N06 N07 1.71e+00
C08 N07 Port2 1.46e-12
L08 N07 Port2 1.51e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1555C1H151JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H1R0CE01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H1R0CE01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.16e-10
R03 N02 N03 3.72e-01
L04 N03 N04 3.14e-11
R04 N03 N04 1.81e+00
L05 N04 Port2 1.03e-10
R05 N04 Port2 2.69e-01
.ENDS GCH1555C1H1R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCH1555C1H220JE01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H220JE01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.70e-10
R03 N02 N03 1.01e-01
L04 N03 N04 2.01e-11
R04 N03 N04 1.48e-01
L05 N04 N05 2.75e-11
R05 N04 N05 3.67e-02
C06 N05 N06 1.33e-10
L06 N05 N06 1.24e-11
R06 N05 N06 1.89e+00
C07 N06 N07 1.44e-11
L07 N06 N07 3.19e-11
R07 N06 N07 4.74e+00
C08 N07 Port2 1.91e-12
L08 N07 Port2 1.38e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1555C1H220JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GCH1555C1H221JE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H221JE01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.06e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.84e-11
R04 N03 N04 1.04e+00
C05 N04 N05 2.62e-09
L05 N04 N05 5.20e-12
R05 N04 N05 1.34e-01
C06 N05 N06 3.41e-10
L06 N05 N06 1.62e-11
R06 N05 N06 5.62e-01
C07 N06 N07 6.81e-11
L07 N06 N07 5.33e-12
R07 N06 N07 1.14e+00
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.30e-10
R08 N07 Port2 8.25e+08
.ENDS GCH1555C1H221JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H2R0CE01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H2R0CE01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-10
R03 N02 N03 2.09e-01
L04 N03 N04 2.51e-11
R04 N03 N04 1.31e+00
L05 N04 Port2 2.53e-11
R05 N04 Port2 1.59e-01
.ENDS GCH1555C1H2R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GCH1555C1H330JE01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H330JE01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.32e-10
R03 N02 N03 8.05e-02
L04 N03 N04 1.24e-11
R04 N03 N04 1.42e-01
L05 N04 N05 3.92e-11
R05 N04 N05 8.58e-02
C06 N05 N06 1.81e-10
L06 N05 N06 1.36e-11
R06 N05 N06 1.18e+00
C07 N06 N07 7.62e-11
L07 N06 N07 1.08e-11
R07 N06 N07 1.34e+00
C08 N07 N08 5.35e-11
L08 N07 N08 7.82e-12
R08 N07 N08 1.22e+00
C09 N08 Port2 2.95e-12
L09 N08 Port2 7.19e-11
R09 N08 Port2 1.00e+05
.ENDS GCH1555C1H330JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GCH1555C1H331JE01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H331JE01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.98e-10
R03 N02 N03 7.51e-02
L04 N03 N04 6.24e-11
R04 N03 N04 9.54e-01
C05 N04 N05 4.13e-09
L05 N04 N05 5.92e-12
R05 N04 N05 1.89e-01
C06 N05 N06 7.02e-10
L06 N05 N06 1.50e-11
R06 N05 N06 4.64e-01
C07 N06 N07 6.03e-11
L07 N06 N07 5.81e-12
R07 N06 N07 7.78e-01
C08 N07 Port2 2.33e-12
L08 N07 Port2 1.04e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1555C1H331JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H3R0CE01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H3R0CE01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.10e-10
R03 N02 N03 1.72e-01
L04 N03 N04 2.20e-11
R04 N03 N04 1.03e+00
L05 N04 Port2 2.59e-11
R05 N04 Port2 1.42e-01
.ENDS GCH1555C1H3R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GCH1555C1H470JE01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H470JE01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-10
R03 N02 N03 7.44e-02
L04 N03 N04 3.86e-11
R04 N03 N04 8.55e-02
L05 N04 N05 2.48e-12
R05 N04 N05 5.61e-02
C06 N05 N06 4.56e-10
L06 N05 N06 7.45e-12
R06 N05 N06 7.46e-01
C07 N06 N07 6.40e-11
L07 N06 N07 2.18e-11
R07 N06 N07 2.38e+00
C08 N07 N08 1.34e-11
L08 N07 N08 3.05e-11
R08 N07 N08 3.04e+00
C09 N08 Port2 1.14e-12
L09 N08 Port2 1.82e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1555C1H470JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GCH1555C1H471JE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H471JE01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.30e-10
R03 N02 N03 5.29e-02
L04 N03 N04 7.93e-11
R04 N03 N04 6.77e-01
C05 N04 N05 6.72e-09
L05 N04 N05 5.61e-12
R05 N04 N05 2.07e-01
C06 N05 N06 1.85e-09
L06 N05 N06 9.35e-12
R06 N05 N06 4.02e-01
C07 N06 N07 7.69e-11
L07 N06 N07 4.58e-12
R07 N06 N07 1.64e+00
C08 N07 Port2 1.50e-12
L08 N07 Port2 1.26e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1555C1H471JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H4R0CE01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H4R0CE01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.11e-10
R03 N02 N03 1.42e-01
L04 N03 N04 2.29e-11
R04 N03 N04 1.09e+00
L05 N04 Port2 2.99e-11
R05 N04 Port2 1.41e-01
.ENDS GCH1555C1H4R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H5R0CE01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H5R0CE01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.14e-10
R03 N02 N03 1.37e-01
L04 N03 N04 2.56e-11
R04 N03 N04 6.39e-01
L05 N04 N05 2.33e-11
R05 N04 N05 8.36e-02
C06 N05 Port2 3.68e-11
L06 N05 Port2 1.13e-11
R06 N05 Port2 3.67e+00
.ENDS GCH1555C1H5R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GCH1555C1H680JE01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H680JE01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.48e-10
R03 N02 N03 1.27e-01
L04 N03 N04 8.27e-12
R04 N03 N04 9.27e-02
L05 N04 N05 2.94e-11
R05 N04 N05 6.90e-02
C06 N05 N06 6.75e-10
L06 N05 N06 5.85e-12
R06 N05 N06 3.14e-01
C07 N06 N07 7.64e-11
L07 N06 N07 2.04e-11
R07 N06 N07 1.38e+00
C08 N07 N08 2.68e-11
L08 N07 N08 1.52e-11
R08 N07 N08 1.25e+00
C09 N08 Port2 2.46e-12
L09 N08 Port2 8.79e-11
R09 N08 Port2 1.00e+05
.ENDS GCH1555C1H680JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GCH1555C1H681JE01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H681JE01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 2.79e-10
R03 N02 N03 5.20e-02
L04 N03 N04 3.65e-11
R04 N03 N04 7.72e-01
C05 N04 N05 5.11e-09
L05 N04 N05 9.70e-12
R05 N04 N05 2.66e-01
C06 N05 N06 1.10e-09
L06 N05 N06 1.90e-11
R06 N05 N06 5.34e-01
C07 N06 N07 6.62e-10
L07 N06 N07 9.26e-12
R07 N06 N07 2.18e-01
C08 N07 Port2 6.55e-11
L08 N07 Port2 3.52e-12
R08 N07 Port2 6.60e-01
.ENDS GCH1555C1H681JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H6R0DE01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H6R0DE01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.27e-01
L04 N03 N04 1.90e-11
R04 N03 N04 5.49e-01
L05 N04 N05 2.55e-11
R05 N04 N05 1.29e-01
C06 N05 N06 9.19e-11
L06 N05 N06 5.36e-12
R06 N05 N06 1.38e+00
C07 N06 Port2 1.73e-12
L07 N06 Port2 1.06e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1555C1H6R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H7R0DE01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H7R0DE01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.05e-10
R03 N02 N03 1.10e-01
L04 N03 N04 1.58e-11
R04 N03 N04 3.60e-01
L05 N04 N05 3.57e-11
R05 N04 N05 1.47e-01
C06 N05 N06 2.32e-11
L06 N05 N06 2.57e-11
R06 N05 N06 7.36e+00
C07 N06 Port2 7.27e-11
L07 N06 Port2 4.69e-12
R07 N06 Port2 6.31e-01
.ENDS GCH1555C1H7R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H8R0DE01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H8R0DE01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.21e-10
R03 N02 N03 9.47e-02
L04 N03 N04 2.38e-11
R04 N03 N04 4.47e-01
L05 N04 N05 3.68e-11
R05 N04 N05 8.92e-02
C06 N05 N06 1.47e-10
L06 N05 N06 4.58e-12
R06 N05 N06 1.16e+00
C07 N06 Port2 2.73e-10
L07 N06 Port2 1.27e-12
R07 N06 Port2 2.75e-01
.ENDS GCH1555C1H8R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H9R0DE01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H9R0DE01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-10
R03 N02 N03 1.11e-01
L04 N03 N04 3.73e-11
R04 N03 N04 2.69e+00
L05 N04 N05 4.27e-11
R05 N04 N05 1.72e-01
C06 N05 Port2 5.11e-10
L06 N05 Port2 1.54e-12
R06 N05 Port2 3.68e-01
.ENDS GCH1555C1H9R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7S(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GCH155C71A105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155C71A105KE11 Port1 Port2
C01 Port1 N01 7.88e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.49e-10
R03 N02 N03 1.48e-02
C04 N03 N04 4.54e-05
R04 N03 N04 5.29e+01
C05 N04 N05 4.23e-05
R05 N04 N05 5.82e+00
C06 N05 N06 3.22e-05
R06 N05 N06 7.32e-01
C07 N06 N07 2.85e-05
R07 N06 N07 9.71e-02
C08 N07 N08 2.57e-05
R08 N07 N08 1.57e-02
L09 N08 N09 2.02e-11
R09 N08 N09 2.29e-01
L10 N09 N10 3.79e-11
R10 N09 N10 8.50e-02
L11 N10 N11 1.23e-10
R11 N10 N11 3.96e-02
C12 N11 N12 1.11e-06
L12 N11 N12 6.06e-11
R12 N11 N12 8.63e-03
C13 N12 Port2 3.74e-12
L13 N12 Port2 6.44e-11
R13 N12 Port2 1.76e+01
.ENDS GCH155C71A105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GCH155R71A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71A104KE01 Port1 Port2
C01 Port1 N01 9.21e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.65e-10
R03 N02 N03 1.60e-02
C04 N03 N04 1.03e-05
R04 N03 N04 1.55e+00
C05 N04 N05 2.22e-05
R05 N04 N05 3.64e-01
C06 N05 N06 9.91e-06
R06 N05 N06 2.30e-01
C07 N06 N07 7.39e-06
R07 N06 N07 1.13e-01
C08 N07 N08 5.42e-06
R08 N07 N08 1.88e-02
L09 N08 N09 1.77e-11
R09 N08 N09 1.64e-01
L10 N09 N10 8.27e-11
R10 N09 N10 7.30e-02
C11 N10 N11 1.50e-06
L11 N10 N11 6.34e-12
R11 N10 N11 6.64e-03
C12 N11 N12 1.08e-07
L12 N11 N12 4.17e-11
R12 N11 N12 2.66e-02
C13 N12 N13 9.26e-12
L13 N12 N13 3.51e-11
R13 N12 N13 3.86e+00
C14 N13 Port2 1.37e-11
L14 N13 Port2 2.24e-11
R14 N13 Port2 1.00e+05
.ENDS GCH155R71A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GCH155R71C104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71C104KE01 Port1 Port2
C01 Port1 N01 1.00e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 2.01e-10
R03 N02 N03 1.42e-02
C04 N03 N04 5.65e-06
R04 N03 N04 3.40e+00
C05 N04 N05 1.30e-05
R05 N04 N05 4.59e-01
C06 N05 N06 8.05e-06
R06 N05 N06 2.27e-01
C07 N06 N07 7.31e-06
R07 N06 N07 3.93e-02
C08 N07 N08 8.17e-06
R08 N07 N08 6.63e-03
L09 N08 N09 2.13e-11
R09 N08 N09 1.49e-01
L10 N09 N10 9.48e-11
R10 N09 N10 6.50e-02
C11 N10 N11 2.58e-06
L11 N10 N11 4.03e-12
R11 N10 N11 5.29e-03
C12 N11 N12 1.54e-07
L12 N11 N12 3.36e-11
R12 N11 N12 2.16e-02
C13 N12 Port2 1.01e-11
L13 N12 Port2 3.08e-11
R13 N12 Port2 3.95e+00
.ENDS GCH155R71C104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCH155R71C224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71C224KE01 Port1 Port2
C01 Port1 N01 1.40e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.25e-10
R03 N02 N03 1.70e-02
C04 N03 N04 1.14e-06
R04 N03 N04 2.78e+00
C05 N04 N05 2.53e-06
R05 N04 N05 1.10e-01
C06 N05 N06 2.24e-06
R06 N05 N06 1.71e-02
L07 N06 N07 2.36e-11
R07 N06 N07 1.70e-01
L08 N07 N08 1.12e-10
R08 N07 N08 6.50e-02
C09 N08 N09 9.56e-07
L09 N08 N09 1.19e-11
R09 N08 N09 8.34e-03
C10 N09 N10 3.41e-07
L10 N09 N10 1.84e-11
R10 N09 N10 1.55e-02
C11 N10 Port2 2.25e-12
L11 N10 Port2 1.00e-10
R11 N10 Port2 2.80e+01
.ENDS GCH155R71C224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :GCH155R71C473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71C473KE01 Port1 Port2
C01 Port1 N01 4.51e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.90e-10
R03 N02 N03 2.20e-02
C04 N03 N04 3.84e-06
R04 N03 N04 2.47e+00
C05 N04 N05 3.68e-06
R05 N04 N05 4.86e-01
C06 N05 N06 4.07e-05
R06 N05 N06 3.91e-01
C07 N06 N07 3.41e-06
R07 N06 N07 8.38e-02
C08 N07 N08 3.80e-06
R08 N07 N08 1.32e-02
L09 N08 N09 1.48e-11
R09 N08 N09 1.27e-01
L10 N09 N10 7.69e-11
R10 N09 N10 9.71e-02
C11 N10 N11 7.56e-07
L11 N10 N11 5.69e-12
R11 N10 N11 1.12e-02
C12 N11 N12 6.90e-08
L12 N11 N12 2.90e-11
R12 N11 N12 3.29e-02
C13 N12 N13 7.54e-12
L13 N12 N13 4.01e-11
R13 N12 N13 6.04e+00
C14 N13 Port2 2.20e-11
L14 N13 Port2 1.20e-11
R14 N13 Port2 1.00e+05
.ENDS GCH155R71C473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCH155R71E103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71E103KE01 Port1 Port2
C01 Port1 N01 9.30e-09
R01 Port1 N01 5.00e+09
L02 N01 N02 1.77e-10
R03 N02 N03 7.26e-02
C04 N03 N04 1.06e-06
R04 N03 N04 1.65e+01
C05 N04 N05 1.91e-06
R05 N04 N05 2.67e+00
C06 N05 N06 9.93e-07
R06 N05 N06 1.40e+00
C07 N06 N07 6.08e-07
R07 N06 N07 4.10e-01
C08 N07 N08 7.95e-07
R08 N07 N08 6.60e-02
C09 N08 N09 3.28e-07
R09 N08 N09 3.10e-02
L10 N09 N10 6.49e-11
R10 N09 N10 2.14e-01
C11 N10 N11 1.80e-08
L11 N10 N11 1.54e-11
R11 N10 N11 4.09e-02
C12 N11 Port2 2.60e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 1.77e+01
.ENDS GCH155R71E103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCH155R71E223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71E223KE01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 2.27e+09
L02 N01 N02 1.80e-10
R03 N02 N03 5.15e-02
C04 N03 N04 1.64e-06
R04 N03 N04 5.54e+00
C05 N04 N05 2.10e-06
R05 N04 N05 9.55e-01
C06 N05 N06 1.36e-06
R06 N05 N06 2.65e-01
C07 N06 N07 1.25e-06
R07 N06 N07 4.13e-02
C08 N07 N08 2.13e-06
R08 N07 N08 8.77e-03
L09 N08 N09 6.50e-11
R09 N08 N09 1.67e-01
C10 N09 N10 2.72e-07
L10 N09 N10 5.61e-12
R10 N09 N10 8.34e-03
C11 N10 N11 3.02e-08
L11 N10 N11 2.20e-11
R11 N10 N11 3.18e-02
C12 N11 Port2 2.57e-12
L12 N11 Port2 1.18e-10
R12 N11 Port2 1.64e+01
.ENDS GCH155R71E223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCH155R71E473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71E473KE01 Port1 Port2
C01 Port1 N01 4.67e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.60e-10
R03 N02 N03 2.29e-02
C04 N03 N04 3.78e-06
R04 N03 N04 3.62e+00
C05 N04 N05 5.53e-06
R05 N04 N05 7.40e-01
C06 N05 N06 4.97e-06
R06 N05 N06 2.60e-01
C07 N06 N07 3.32e-06
R07 N06 N07 7.17e-02
C08 N07 N08 3.76e-06
R08 N07 N08 9.85e-03
L09 N08 N09 7.11e-11
R09 N08 N09 9.19e-02
L10 N09 N10 1.23e-11
R10 N09 N10 7.49e-02
C11 N10 N11 8.47e-07
L11 N10 N11 5.08e-12
R11 N10 N11 7.91e-03
C12 N11 N12 5.60e-08
L12 N11 N12 3.57e-11
R12 N11 N12 3.22e-02
C13 N12 N13 5.58e-12
L13 N12 N13 5.53e-11
R13 N12 N13 7.60e+00
C14 N13 Port2 1.20e-11
L14 N13 Port2 2.40e-11
R14 N13 Port2 1.00e+05
.ENDS GCH155R71E473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCH155R71H102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H102KE01 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 2.45e-01
C04 N03 N04 2.89e-08
R04 N03 N04 1.10e+02
C05 N04 N05 7.87e-08
R05 N04 N05 3.37e+00
C06 N05 N06 5.50e-08
R06 N05 N06 1.03e+00
C07 N06 N07 2.93e-08
R07 N06 N07 3.88e-01
C08 N07 N08 1.02e-08
R08 N07 N08 1.74e-01
L09 N08 N09 4.08e-11
R09 N08 N09 5.49e-01
C10 N09 N10 1.85e-09
L10 N09 N10 1.13e-11
R10 N09 N10 1.21e-01
C11 N10 Port2 2.04e-12
L11 N10 Port2 1.59e-10
R11 N10 Port2 2.16e+01
.ENDS GCH155R71H102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCH155R71H103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H103KE01 Port1 Port2
C01 Port1 N01 9.74e-09
R01 Port1 N01 5.00e+09
L02 N01 N02 1.75e-10
R03 N02 N03 4.93e-02
C04 N03 N04 1.59e-06
R04 N03 N04 6.62e+00
C05 N04 N05 1.55e-06
R05 N04 N05 2.46e+00
C06 N05 N06 1.11e-06
R06 N05 N06 9.24e-01
C07 N06 N07 6.61e-07
R07 N06 N07 3.00e-01
C08 N07 N08 5.64e-07
R08 N07 N08 4.42e-02
L09 N08 N09 5.45e-11
R09 N08 N09 1.81e-01
C10 N09 N10 2.31e-08
L10 N09 N10 1.37e-11
R10 N09 N10 4.28e-02
C11 N10 N11 4.55e-12
L11 N10 N11 6.40e-11
R11 N10 N11 8.35e+00
C12 N11 Port2 1.30e-11
L12 N11 Port2 2.20e-11
R12 N11 Port2 1.00e+05
.ENDS GCH155R71H103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCH155R71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H104KE01 Port1 Port2
C01 Port1 N01 9.22e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.80e-10
R03 N02 N03 1.67e-02
C04 N03 N04 4.60e-06
R04 N03 N04 7.00e-01
C05 N04 N05 9.19e-06
R05 N04 N05 4.91e-02
C06 N05 N06 6.72e-06
R06 N05 N06 1.58e-02
L07 N06 N07 1.74e-11
R07 N06 N07 9.26e-02
L08 N07 N08 8.86e-11
R08 N07 N08 6.62e-02
C09 N08 N09 5.03e-07
L09 N08 N09 1.50e-11
R09 N08 N09 1.11e-02
C10 N09 N10 2.18e-07
L10 N09 N10 1.69e-11
R10 N09 N10 1.67e-02
C11 N10 Port2 1.13e-11
L11 N10 Port2 2.90e-11
R11 N10 Port2 6.67e+00
.ENDS GCH155R71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GCH155R71H221KE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H221KE01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 4.82e-01
C04 N03 N04 6.09e-09
R04 N03 N04 8.72e+01
C05 N04 N05 2.30e-08
R05 N04 N05 7.67e+00
C06 N05 N06 9.33e-09
R06 N05 N06 3.10e+00
C07 N06 N07 2.36e-09
R07 N06 N07 1.23e+00
C08 N07 N08 1.00e-09
R08 N07 N08 4.55e-01
C09 N08 N09 9.23e-11
L09 N08 N09 3.26e-11
R09 N08 N09 6.01e-01
C10 N09 Port2 1.90e-12
L10 N09 Port2 1.80e-10
R10 N09 Port2 1.76e+01
.ENDS GCH155R71H221KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCH155R71H222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H222KE01 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 1.65e-01
C04 N03 N04 1.19e-07
R04 N03 N04 1.33e+01
C05 N04 N05 1.23e-07
R05 N04 N05 1.12e+00
C06 N05 N06 7.40e-08
R06 N05 N06 2.15e-01
C07 N06 N07 2.17e-08
R07 N06 N07 9.19e-02
L08 N07 N08 3.52e-11
R08 N07 N08 3.32e-01
C09 N08 N09 1.85e-09
L09 N08 N09 2.44e-11
R09 N08 N09 1.38e-01
C10 N09 Port2 3.05e-12
L10 N09 Port2 1.04e-10
R10 N09 Port2 1.54e+01
.ENDS GCH155R71H222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCH155R71H223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H223KE01 Port1 Port2
C01 Port1 N01 2.04e-08
R01 Port1 N01 2.27e+09
L02 N01 N02 1.50e-10
R03 N02 N03 3.37e-02
C04 N03 N04 2.17e-06
R04 N03 N04 7.34e+00
C05 N04 N05 5.90e-06
R05 N04 N05 1.47e+00
C06 N05 N06 2.80e-06
R06 N05 N06 9.24e-01
C07 N06 N07 2.04e-06
R07 N06 N07 5.34e-01
C08 N07 N08 1.50e-06
R08 N07 N08 1.36e-01
C09 N08 N09 1.59e-06
R09 N08 N09 2.48e-02
L10 N09 N10 2.09e-11
R10 N09 N10 6.78e-01
L11 N10 N11 7.36e-11
R11 N10 N11 1.70e-01
C12 N11 N12 1.13e-07
L12 N11 N12 1.46e-11
R12 N11 N12 2.25e-02
C13 N12 N13 3.36e-08
L13 N12 N13 2.23e-11
R13 N12 N13 4.60e-02
C14 N13 N14 9.13e-12
L14 N13 N14 3.13e-11
R14 N13 N14 4.98e+00
C15 N14 Port2 8.69e-12
L15 N14 Port2 3.13e-11
R15 N14 Port2 1.00e+05
.ENDS GCH155R71H223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GCH155R71H471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H471KE01 Port1 Port2
C01 Port1 N01 4.76e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 4.11e-01
C04 N03 N04 4.71e-08
R04 N03 N04 3.38e+01
C05 N04 N05 3.36e-08
R05 N04 N05 5.27e+00
C06 N05 N06 2.39e-08
R06 N05 N06 1.13e+00
C07 N06 N07 8.90e-09
R07 N06 N07 4.59e-01
C08 N07 N08 4.13e-09
R08 N07 N08 3.21e-01
C09 N08 N09 6.25e-11
L09 N08 N09 4.82e-11
R09 N08 N09 8.87e-01
C10 N09 Port2 1.92e-12
L10 N09 Port2 1.92e-10
R10 N09 Port2 1.88e+01
.ENDS GCH155R71H471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCH155R71H472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H472KE01 Port1 Port2
C01 Port1 N01 4.61e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 1.02e-01
C04 N03 N04 3.06e-07
R04 N03 N04 3.47e+00
C05 N04 N05 2.35e-07
R05 N04 N05 4.52e-01
C06 N05 N06 1.53e-07
R06 N05 N06 6.95e-02
C07 N06 N07 1.54e-07
R07 N06 N07 2.07e-02
L08 N07 N08 4.76e-11
R08 N07 N08 1.87e-01
C09 N08 N09 6.41e-09
L09 N08 N09 1.95e-11
R09 N08 N09 5.60e-02
C10 N09 Port2 2.26e-12
L10 N09 Port2 1.32e-10
R10 N09 Port2 1.79e+01
.ENDS GCH155R71H472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCH155R71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R71H473KE01 Port1 Port2
C01 Port1 N01 4.34e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.77e-10
R03 N02 N03 2.31e-02
C04 N03 N04 1.92e-06
R04 N03 N04 1.36e+00
C05 N04 N05 2.64e-06
R05 N04 N05 8.46e-02
C06 N05 N06 3.58e-06
R06 N05 N06 8.16e-03
L07 N06 N07 1.71e-11
R07 N06 N07 2.64e-01
L08 N07 N08 8.21e-11
R08 N07 N08 1.33e-01
C09 N08 N09 1.12e-07
L09 N08 N09 2.75e-11
R09 N08 N09 2.45e-02
C10 N09 N10 7.10e-08
L10 N09 N10 1.81e-11
R10 N09 N10 2.62e-02
C11 N10 Port2 9.59e-12
L11 N10 Port2 3.08e-11
R11 N10 Port2 6.02e+00
.ENDS GCH155R71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCH155R72A102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A102KE01 Port1 Port2
C01 Port1 N01 9.75e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 2.43e-01
C04 N03 N04 1.64e-07
R04 N03 N04 1.02e+01
C05 N04 N05 7.98e-08
R05 N04 N05 3.32e+00
C06 N05 N06 3.94e-08
R06 N05 N06 8.77e-01
C07 N06 N07 1.64e-08
R07 N06 N07 2.65e-01
C08 N07 N08 1.01e-08
R08 N07 N08 7.82e-02
L09 N08 N09 1.83e-11
R09 N08 N09 5.96e-01
C10 N09 N10 9.65e-10
L10 N09 N10 1.82e-11
R10 N09 N10 1.95e-01
C11 N10 Port2 2.20e-12
L11 N10 Port2 1.35e-10
R11 N10 Port2 1.23e+01
.ENDS GCH155R72A102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCH155R72A221KE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A221KE01 Port1 Port2
C01 Port1 N01 2.25e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 5.28e-01
C04 N03 N04 6.24e-09
R04 N03 N04 8.50e+01
C05 N04 N05 1.84e-08
R05 N04 N05 9.63e+00
C06 N05 N06 7.71e-09
R06 N05 N06 2.75e+00
C07 N06 N07 1.75e-09
R07 N06 N07 1.21e+00
C08 N07 N08 1.79e-09
R08 N07 N08 2.96e-01
C09 N08 N09 7.67e-11
L09 N08 N09 3.93e-11
R09 N08 N09 7.22e-01
C10 N09 Port2 1.91e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.81e+01
.ENDS GCH155R72A221KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCH155R72A222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A222KE01 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 1.50e-01
C04 N03 N04 1.64e-07
R04 N03 N04 9.68e+00
C05 N04 N05 1.52e-07
R05 N04 N05 1.50e+00
C06 N05 N06 8.03e-08
R06 N05 N06 3.96e-01
C07 N06 N07 2.55e-08
R07 N06 N07 1.04e-01
L08 N07 N08 3.82e-11
R08 N07 N08 3.60e-01
C09 N08 N09 1.84e-09
L09 N08 N09 2.45e-11
R09 N08 N09 1.39e-01
C10 N09 Port2 3.05e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.53e+01
.ENDS GCH155R72A222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCH155R72A331KE01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 300[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A331KE01 Port1 Port2
C01 Port1 N01 3.40e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 4.60e-01
C04 N03 N04 3.76e-09
R04 N03 N04 2.82e+02
C05 N04 N05 5.29e-08
R05 N04 N05 1.00e+01
C06 N05 N06 1.84e-08
R06 N05 N06 3.75e+00
C07 N06 N07 8.11e-09
R07 N06 N07 1.12e+00
C08 N07 N08 1.70e-09
R08 N07 N08 6.47e-01
C09 N08 N09 2.20e-10
L09 N08 N09 2.38e-11
R09 N08 N09 3.52e-01
C10 N09 N10 1.45e-12
L10 N09 N10 2.42e-10
R10 N09 N10 2.38e+01
C11 N10 Port2 2.58e-12
L11 N10 Port2 9.64e-11
R11 N10 Port2 1.00e+05
.ENDS GCH155R72A331KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCH155R72A471KE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A471KE01 Port1 Port2
C01 Port1 N01 4.74e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 4.03e-01
C04 N03 N04 6.92e-09
R04 N03 N04 4.60e+02
C05 N04 N05 3.85e-08
R05 N04 N05 1.38e+01
C06 N05 N06 2.13e-08
R06 N05 N06 2.41e+00
C07 N06 N07 1.03e-08
R07 N06 N07 6.17e-01
C08 N07 N08 3.75e-09
R08 N07 N08 3.53e-01
C09 N08 N09 6.27e-11
L09 N08 N09 4.75e-11
R09 N08 N09 8.98e-01
C10 N09 Port2 1.92e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.61e+01
.ENDS GCH155R72A471KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCH155R72A472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155R72A472KE01 Port1 Port2
C01 Port1 N01 4.81e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 9.30e-02
C04 N03 N04 3.29e-07
R04 N03 N04 6.91e+00
C05 N04 N05 2.89e-07
R05 N04 N05 7.86e-01
C06 N05 N06 2.56e-07
R06 N05 N06 1.38e-01
C07 N06 N07 1.01e-07
R07 N06 N07 4.62e-02
L08 N07 N08 5.25e-11
R08 N07 N08 2.85e-01
C09 N08 N09 6.09e-09
L09 N08 N09 2.25e-11
R09 N08 N09 8.27e-02
C10 N09 Port2 3.82e-12
L10 N09 Port2 8.84e-11
R10 N09 Port2 1.13e+01
.ENDS GCH155R72A472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCH1885C1H100JE01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H100JE01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.47e-11
R03 N02 N03 2.40e-01
L04 N03 N04 3.32e-11
R04 N03 N04 2.57e-01
C05 N04 N05 1.97e-11
L05 N04 N05 3.08e-11
R05 N04 N05 6.43e+00
C06 N05 N06 2.83e-12
L06 N05 N06 1.17e-10
R06 N05 N06 1.51e+01
C07 N06 Port2 7.50e-13
L07 N06 Port2 3.47e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H100JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/50[V]
* Murata P/N :GCH1885C1H101JE01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H101JE01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.15e-11
R03 N02 N03 1.20e-01
L04 N03 N04 1.71e-11
R04 N03 N04 8.03e-02
C05 N04 N05 1.14e-09
L05 N04 N05 7.24e-12
R05 N04 N05 2.77e-01
C06 N05 N06 1.01e-10
L06 N05 N06 2.88e-11
R06 N05 N06 1.50e+00
C07 N06 N07 1.61e-12
L07 N06 N07 1.77e-10
R07 N06 N07 4.25e+01
C08 N07 Port2 7.25e-13
L08 N07 Port2 3.51e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H101JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCH1885C1H102JE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H102JE01 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.05e-10
R03 N02 N03 1.97e-02
L04 N03 N04 6.73e-11
R04 N03 N04 5.39e-01
L05 N04 N05 7.18e-11
R05 N04 N05 1.80e-02
C06 N05 N06 5.83e-09
L06 N05 N06 2.40e-11
R06 N05 N06 5.42e-01
C07 N06 N07 2.45e-09
L07 N06 N07 2.16e-11
R07 N06 N07 5.68e-01
C08 N07 N08 1.40e-09
L08 N07 N08 1.29e-11
R08 N07 N08 2.60e-01
C09 N08 N09 2.09e-11
L09 N08 N09 1.67e-11
R09 N08 N09 4.40e+00
C10 N09 Port2 1.12e-12
L10 N09 Port2 2.07e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C1H102JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GCH1885C1H150JE01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H150JE01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 3.98e-11
R03 N02 N03 2.10e-01
L04 N03 N04 1.85e-11
R04 N03 N04 2.55e-01
C05 N04 N05 2.10e-12
L05 N04 N05 1.53e-10
R05 N04 N05 3.16e+01
C06 N05 Port2 8.69e-13
L06 N05 Port2 3.06e-10
R06 N05 Port2 1.00e+05
.ENDS GCH1885C1H150JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/50[V]
* Murata P/N :GCH1885C1H151JE01
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H151JE01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 5.42e-11
R03 N02 N03 8.50e-02
L04 N03 N04 8.61e-11
R04 N03 N04 1.87e+00
C05 N04 N05 1.88e-09
L05 N04 N05 8.09e-12
R05 N04 N05 3.87e-01
C06 N05 N06 2.93e-10
L06 N05 N06 2.00e-11
R06 N05 N06 1.08e+00
C07 N06 N07 6.83e-12
L07 N06 N07 5.01e-11
R07 N06 N07 1.18e+01
C08 N07 Port2 6.74e-13
L08 N07 Port2 3.68e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H151JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCH1885C1H152JE01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H152JE01 Port1 Port2
C01 Port1 N01 1.47e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.69e-11
R03 N02 N03 1.50e-02
L04 N03 N04 5.04e-11
R04 N03 N04 3.80e-01
L05 N04 N05 1.23e-10
R05 N04 N05 2.76e-02
C06 N05 N06 1.07e-08
L06 N05 N06 1.59e-11
R06 N05 N06 2.42e-01
C07 N06 N07 1.84e-09
L07 N06 N07 4.15e-11
R07 N06 N07 5.96e-01
C08 N07 N08 2.63e-09
L08 N07 N08 9.52e-12
R08 N07 N08 1.88e-01
C09 N08 N09 7.18e-13
L09 N08 N09 3.26e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 2.37e-12
L10 N09 Port2 6.81e-11
R10 N09 Port2 6.44e+00
.ENDS GCH1885C1H152JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H1R0CE01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H1R0CE01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.29e-10
R03 N02 N03 3.62e-01
L04 N03 N04 4.22e-11
R04 N03 N04 2.27e-01
C05 N04 N05 2.44e-11
L05 N04 N05 1.31e-11
R05 N04 N05 1.00e+05
C06 N05 Port2 2.61e-11
L06 N05 Port2 1.01e-11
R06 N05 Port2 1.58e+00
.ENDS GCH1885C1H1R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCH1885C1H220JE01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H220JE01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.27e-12
R03 N02 N03 1.50e-01
L04 N03 N04 2.29e-11
R04 N03 N04 1.57e-01
C05 N04 N05 2.90e-10
L05 N04 N05 8.91e-12
R05 N04 N05 1.05e+00
C06 N05 N06 1.26e-12
L06 N05 N06 2.54e-10
R06 N05 N06 6.69e+01
C07 N06 Port2 1.01e-12
L07 N06 Port2 2.46e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H220JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/50[V]
* Murata P/N :GCH1885C1H221JE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H221JE01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.63e-10
R03 N02 N03 9.46e-02
L04 N03 N04 5.00e-11
R04 N03 N04 8.98e-01
L05 N04 N05 1.16e-11
R05 N04 N05 3.50e-02
C06 N05 N06 3.19e-09
L06 N05 N06 6.00e-12
R06 N05 N06 2.04e-01
C07 N06 N07 2.98e-10
L07 N06 N07 2.41e-11
R07 N06 N07 8.75e-01
C08 N07 N08 4.98e-12
L08 N07 N08 5.35e-11
R08 N07 N08 6.35e+00
C09 N08 Port2 7.56e-13
L09 N08 Port2 3.29e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1885C1H221JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCH1885C1H222JE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H222JE01 Port1 Port2
C01 Port1 N01 2.23e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.99e-10
R03 N02 N03 1.55e-02
L04 N03 N04 5.14e-11
R04 N03 N04 7.13e-01
L05 N04 N05 6.80e-11
R05 N04 N05 1.43e-02
C06 N05 N06 1.14e-08
L06 N05 N06 2.50e-11
R06 N05 N06 2.67e-01
C07 N06 N07 4.72e-09
L07 N06 N07 2.23e-11
R07 N06 N07 3.43e-01
C08 N07 N08 1.26e-09
L08 N07 N08 2.41e-11
R08 N07 N08 2.09e-01
C09 N08 N09 1.10e-10
L09 N08 N09 2.64e-12
R09 N08 N09 3.79e-01
C10 N09 Port2 1.49e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C1H222JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H2R0CE01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H2R0CE01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.27e-10
R03 N02 N03 2.45e-01
L04 N03 N04 3.13e-11
R04 N03 N04 2.81e-01
C05 N04 N05 1.86e-11
L05 N04 N05 1.52e-11
R05 N04 N05 1.49e+00
C06 N05 Port2 2.34e-12
L06 N05 Port2 1.06e-10
R06 N05 Port2 1.00e+05
.ENDS GCH1885C1H2R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GCH1885C1H330JE01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H330JE01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.64e-11
R03 N02 N03 1.30e-01
L04 N03 N04 1.36e-11
R04 N03 N04 1.05e-01
C05 N04 N05 3.70e-10
L05 N04 N05 1.03e-11
R05 N04 N05 9.32e-01
C06 N05 N06 7.83e-11
L06 N05 N06 1.49e-11
R06 N05 N06 2.34e+00
C07 N06 N07 3.96e-12
L07 N06 N07 7.95e-11
R07 N06 N07 7.59e+00
C08 N07 Port2 7.10e-13
L08 N07 Port2 3.27e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H330JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GCH1885C1H331JE01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H331JE01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.00e-11
R03 N02 N03 7.68e-02
L04 N03 N04 1.49e-11
R04 N03 N04 3.22e-01
C05 N04 N05 2.76e-09
L05 N04 N05 1.31e-11
R05 N04 N05 3.72e-01
C06 N05 N06 4.29e-10
L06 N05 N06 3.33e-11
R06 N05 N06 9.57e-01
C07 N06 N07 1.51e-10
L07 N06 N07 2.20e-11
R07 N06 N07 4.79e-01
C08 N07 N08 4.83e-10
L08 N07 N08 2.06e-12
R08 N07 N08 4.85e-01
C09 N08 N09 2.99e-12
L09 N08 N09 1.07e-10
R09 N08 N09 3.37e+01
C10 N09 Port2 8.93e-13
L10 N09 Port2 2.78e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C1H331JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCH1885C1H332JE01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H332JE01 Port1 Port2
C01 Port1 N01 3.31e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 5.56e-12
R03 N02 N03 1.44e-02
L04 N03 N04 6.68e-11
R04 N03 N04 3.80e-01
L05 N04 N05 4.26e-11
R05 N04 N05 1.03e-02
C06 N05 N06 2.49e-08
L06 N05 N06 1.62e-11
R06 N05 N06 2.44e-01
C07 N06 N07 5.06e-09
L07 N06 N07 3.86e-11
R07 N06 N07 4.21e-01
C08 N07 N08 3.78e-09
L08 N07 N08 1.70e-11
R08 N07 N08 1.15e-01
C09 N08 N09 3.45e-11
L09 N08 N09 8.69e-12
R09 N08 N09 9.69e-01
C10 N09 Port2 7.72e-13
L10 N09 Port2 3.15e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C1H332JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H3R0CE01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H3R0CE01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.40e-10
R03 N02 N03 1.70e-01
L04 N03 N04 1.65e-11
R04 N03 N04 3.18e-01
L05 N04 N05 3.15e-11
R05 N04 N05 1.41e-01
C06 N05 N06 1.08e-11
L06 N05 N06 2.79e-11
R06 N05 N06 5.51e+00
C07 N06 Port2 6.58e-12
L07 N06 Port2 4.50e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H3R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GCH1885C1H470JE01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H470JE01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.75e-10
R03 N02 N03 1.02e-01
L04 N03 N04 9.02e-12
R04 N03 N04 7.35e-02
C05 N04 N05 3.17e-10
L05 N04 N05 1.92e-11
R05 N04 N05 1.63e+00
C06 N05 N06 8.31e-11
L06 N05 N06 2.18e-11
R06 N05 N06 2.16e+00
C07 N06 N07 3.68e-12
L07 N06 N07 8.20e-11
R07 N06 N07 9.21e+00
C08 N07 Port2 1.22e-12
L08 N07 Port2 2.04e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H470JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GCH1885C1H471JE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H471JE01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.90e-11
R03 N02 N03 6.33e-02
L04 N03 N04 3.93e-11
R04 N03 N04 1.04e+00
C05 N04 N05 3.06e-09
L05 N04 N05 2.00e-11
R05 N04 N05 6.16e-01
C06 N05 N06 7.33e-10
L06 N05 N06 2.84e-11
R06 N05 N06 7.32e-01
C07 N06 N07 4.64e-10
L07 N06 N07 1.27e-11
R07 N06 N07 4.03e-01
C08 N07 N08 7.61e-12
L08 N07 N08 3.95e-11
R08 N07 N08 8.00e+00
C09 N08 Port2 8.13e-13
L09 N08 Port2 2.85e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1885C1H471JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H4R0CE01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H4R0CE01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.09e-10
R03 N02 N03 1.54e-01
L04 N03 N04 2.07e-11
R04 N03 N04 5.72e-01
L05 N04 N05 2.04e-11
R05 N04 N05 1.20e-01
C06 N05 N06 1.50e-11
L06 N05 N06 2.86e-11
R06 N05 N06 1.37e+01
C07 N06 Port2 4.25e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H4R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H5R0CE01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H5R0CE01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.45e-10
R03 N02 N03 1.42e-01
L04 N03 N04 2.85e-11
R04 N03 N04 1.94e-01
C05 N04 N05 1.78e-11
L05 N04 N05 3.23e-11
R05 N04 N05 1.55e+01
C06 N05 N06 6.36e-12
L06 N05 N06 4.90e-11
R06 N05 N06 2.07e+01
C07 N06 Port2 4.62e-12
L07 N06 Port2 6.34e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H5R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/50[V]
* Murata P/N :GCH1885C1H680JE01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H680JE01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 4.67e-12
R03 N02 N03 1.40e-01
L04 N03 N04 7.84e-11
R04 N03 N04 2.96e+00
L05 N04 N05 7.78e-13
R05 N04 N05 4.79e-03
C06 N05 N06 8.28e-10
L06 N05 N06 9.34e-12
R06 N05 N06 5.69e-01
C07 N06 N07 2.34e-12
L07 N06 N07 1.36e-10
R07 N06 N07 6.09e+01
C08 N07 Port2 7.45e-13
L08 N07 Port2 3.41e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H680JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/50[V]
* Murata P/N :GCH1885C1H681JE01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H681JE01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.94e-10
R03 N02 N03 6.00e-02
L04 N03 N04 4.78e-11
R04 N03 N04 6.28e+00
L05 N04 N05 4.96e-11
R05 N04 N05 7.39e-01
C06 N05 N06 4.86e-09
L06 N05 N06 1.87e-11
R06 N05 N06 3.84e-01
C07 N06 N07 1.03e-09
L07 N06 N07 3.01e-11
R07 N06 N07 5.69e-01
C08 N07 N08 1.38e-09
L08 N07 N08 6.98e-12
R08 N07 N08 2.33e-01
C09 N08 N09 5.10e-10
L09 N08 N09 2.02e-12
R09 N08 N09 8.65e-01
C10 N09 Port2 1.68e-12
L10 N09 Port2 1.70e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C1H681JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H6R0DE01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H6R0DE01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.60e-10
R03 N02 N03 1.38e-01
L04 N03 N04 1.72e-11
R04 N03 N04 4.49e-01
L05 N04 N05 4.02e-11
R05 N04 N05 1.53e-01
C06 N05 N06 1.20e-11
L06 N05 N06 2.48e-11
R06 N05 N06 3.45e+00
C07 N06 Port2 1.91e-12
L07 N06 Port2 1.32e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H6R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H7R0DE01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H7R0DE01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.11e-10
R03 N02 N03 1.32e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.70e-01
L05 N04 N05 4.67e-11
R05 N04 N05 1.63e-01
C06 N05 N06 5.96e-12
L06 N05 N06 5.38e-11
R06 N05 N06 1.33e+01
C07 N06 Port2 1.16e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C1H7R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H8R0DE01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H8R0DE01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 1.29e-01
L04 N03 N04 2.81e-11
R04 N03 N04 1.21e-01
C05 N04 N05 3.15e-11
L05 N04 N05 2.88e-11
R05 N04 N05 1.20e+01
C06 N05 N06 6.27e-12
L06 N05 N06 6.72e-11
R06 N05 N06 2.51e+01
C07 N06 Port2 1.63e-11
L07 N06 Port2 1.96e-11
R07 N06 Port2 4.09e+01
.ENDS GCH1885C1H8R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCH1885C1H9R0DE01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C1H9R0DE01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.21e-10
R03 N02 N03 1.16e-01
L04 N03 N04 7.31e-12
R04 N03 N04 1.08e-01
L05 N04 N05 2.31e-11
R05 N04 N05 1.03e-01
C06 N05 N06 3.73e-11
L06 N05 N06 2.75e-11
R06 N05 N06 1.23e+01
C07 N06 N07 7.08e-12
L07 N06 N07 6.43e-11
R07 N06 N07 2.16e+01
C08 N07 Port2 5.13e-12
L08 N07 Port2 5.71e-11
R08 N07 Port2 1.00e+05
.ENDS GCH1885C1H9R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/100[V]
* Murata P/N :GCH1885C2A100JE01
* Property : C = 1.00e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A100JE01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.31e-10
R03 N02 N03 1.79e-01
L04 N03 N04 3.69e-11
R04 N03 N04 3.67e-01
L05 N04 N05 1.85e-11
R05 N04 N05 7.60e-02
C06 N05 N06 1.24e-11
L06 N05 N06 4.62e-11
R06 N05 N06 9.89e+00
C07 N06 N07 2.91e-12
L07 N06 N07 1.14e-10
R07 N06 N07 2.68e+01
C08 N07 Port2 1.13e-12
L08 N07 Port2 2.47e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A100JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GCH1885C2A101JE01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A101JE01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.09e-11
R03 N02 N03 8.99e-02
L04 N03 N04 4.29e-11
R04 N03 N04 1.57e-01
C05 N04 N05 1.03e-10
L05 N04 N05 2.90e-11
R05 N04 N05 1.37e+00
C06 N05 N06 3.48e-12
L06 N05 N06 9.43e-11
R06 N05 N06 1.62e+01
C07 N06 Port2 5.94e-13
L07 N06 Port2 4.38e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A101JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCH1885C2A102JE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A102JE01 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.11e-10
R03 N02 N03 2.19e-02
L04 N03 N04 4.69e-11
R04 N03 N04 4.85e-01
L05 N04 N05 5.09e-11
R05 N04 N05 1.63e-02
C06 N05 N06 4.28e-09
L06 N05 N06 3.32e-11
R06 N05 N06 5.56e-01
C07 N06 N07 1.79e-09
L07 N06 N07 3.08e-11
R07 N06 N07 6.20e-01
C08 N07 N08 8.50e-09
L08 N07 N08 3.79e-12
R08 N07 N08 1.30e-01
C09 N08 N09 9.54e-10
L09 N08 N09 1.81e-11
R09 N08 N09 3.47e-01
C10 N09 N10 4.40e-12
L10 N09 N10 6.64e-11
R10 N09 N10 1.00e+05
C11 N10 Port2 5.32e-12
L11 N10 Port2 4.71e-11
R11 N10 Port2 3.34e+00
.ENDS GCH1885C2A102JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-05[uF]/100[V]
* Murata P/N :GCH1885C2A150JE01
* Property : C = 1.50e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A150JE01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.78e-11
R03 N02 N03 1.45e-01
L04 N03 N04 1.72e-11
R04 N03 N04 1.83e-01
L05 N04 N05 2.25e-11
R05 N04 N05 7.30e-02
C06 N05 N06 1.93e-12
L06 N05 N06 1.66e-10
R06 N05 N06 3.59e+01
C07 N06 Port2 8.04e-13
L07 N06 Port2 3.02e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A150JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GCH1885C2A151JE01
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A151JE01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 3.58e-12
R03 N02 N03 8.50e-02
L04 N03 N04 8.47e-11
R04 N03 N04 1.87e+00
C05 N04 N05 1.49e-09
L05 N04 N05 9.98e-12
R05 N04 N05 3.96e-01
C06 N05 N06 2.99e-10
L06 N05 N06 1.94e-11
R06 N05 N06 1.04e+00
C07 N06 N07 5.99e-12
L07 N06 N07 5.75e-11
R07 N06 N07 1.65e+01
C08 N07 Port2 6.25e-13
L08 N07 Port2 3.97e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A151JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCH1885C2A152JE01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A152JE01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.65e-10
R03 N02 N03 1.70e-02
L04 N03 N04 5.16e-11
R04 N03 N04 5.07e-01
L05 N04 N05 1.13e-10
R05 N04 N05 2.92e-02
C06 N05 N06 9.04e-09
L06 N05 N06 2.01e-11
R06 N05 N06 2.38e-01
C07 N06 N07 2.77e-09
L07 N06 N07 3.03e-11
R07 N06 N07 4.23e-01
C08 N07 N08 1.14e-09
L08 N07 N08 2.10e-11
R08 N07 N08 1.74e-01
C09 N08 N09 1.83e-11
L09 N08 N09 2.03e-11
R09 N08 N09 1.03e+00
C10 N09 Port2 1.20e-12
L10 N09 Port2 2.27e-10
R10 N09 Port2 1.00e+05
.ENDS GCH1885C2A152JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A1R0CE01
* Property : C = 1.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A1R0CE01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 5.29e-10
R03 N02 N03 3.62e-01
L04 N03 N04 4.22e-11
R04 N03 N04 2.27e-01
C05 N04 N05 2.44e-11
L05 N04 N05 1.31e-11
R05 N04 N05 1.00e+05
C06 N05 Port2 2.61e-11
L06 N05 Port2 1.01e-11
R06 N05 Port2 1.58e+00
.ENDS GCH1885C2A1R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GCH1885C2A220JE01
* Property : C = 2.20e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A220JE01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 6.37e-11
R03 N02 N03 1.12e-01
L04 N03 N04 3.13e-11
R04 N03 N04 1.03e-01
C05 N04 N05 3.33e-10
L05 N04 N05 7.74e-12
R05 N04 N05 9.78e-01
C06 N05 N06 1.28e-12
L06 N05 N06 2.48e-10
R06 N05 N06 6.86e+01
C07 N06 Port2 1.33e-12
L07 N06 Port2 2.00e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A220JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCH1885C2A221JE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A221JE01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.80e-11
R03 N02 N03 9.00e-02
L04 N03 N04 6.40e-11
R04 N03 N04 1.28e+00
C05 N04 N05 2.17e-09
L05 N04 N05 8.83e-12
R05 N04 N05 2.20e-01
C06 N05 N06 3.09e-10
L06 N05 N06 2.29e-11
R06 N05 N06 8.04e-01
C07 N06 N07 6.03e-10
L07 N06 N07 1.61e-12
R07 N06 N07 5.79e-01
C08 N07 N08 3.00e-12
L08 N07 N08 1.19e-10
R08 N07 N08 5.44e+01
C09 N08 Port2 7.69e-13
L09 N08 Port2 3.62e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1885C2A221JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A2R0CE01
* Property : C = 2.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A2R0CE01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.27e-10
R03 N02 N03 2.45e-01
L04 N03 N04 3.13e-11
R04 N03 N04 2.81e-01
C05 N04 N05 1.86e-11
L05 N04 N05 1.52e-11
R05 N04 N05 1.49e+00
C06 N05 Port2 2.34e-12
L06 N05 Port2 1.06e-10
R06 N05 Port2 1.00e+05
.ENDS GCH1885C2A2R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-05[uF]/100[V]
* Murata P/N :GCH1885C2A330JE01
* Property : C = 3.30e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A330JE01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.50e-11
R03 N02 N03 1.06e-01
L04 N03 N04 3.17e-11
R04 N03 N04 1.75e-01
C05 N04 N05 9.91e-10
L05 N04 N05 3.59e-12
R05 N04 N05 3.10e-01
C06 N05 N06 5.48e-11
L06 N05 N06 2.02e-11
R06 N05 N06 2.56e+00
C07 N06 N07 5.15e-12
L07 N06 N07 7.08e-11
R07 N06 N07 1.20e+01
C08 N07 Port2 6.14e-13
L08 N07 Port2 3.86e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A330JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCH1885C2A331JE01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A331JE01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-10
R03 N02 N03 7.49e-02
L04 N03 N04 3.21e-11
R04 N03 N04 8.25e-01
C05 N04 N05 5.50e-10
L05 N04 N05 2.59e-11
R05 N04 N05 7.96e-01
C06 N05 N06 3.27e-10
L06 N05 N06 1.17e-11
R06 N05 N06 3.72e-01
C07 N06 N07 2.09e-11
L07 N06 N07 1.70e-11
R07 N06 N07 2.21e+00
C08 N07 Port2 6.97e-13
L08 N07 Port2 3.40e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A331JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A3R0CE01
* Property : C = 3.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A3R0CE01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.40e-10
R03 N02 N03 1.70e-01
L04 N03 N04 1.65e-11
R04 N03 N04 3.18e-01
L05 N04 N05 3.15e-11
R05 N04 N05 1.41e-01
C06 N05 N06 1.08e-11
L06 N05 N06 2.79e-11
R06 N05 N06 5.51e+00
C07 N06 Port2 6.58e-12
L07 N06 Port2 4.50e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A3R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/100[V]
* Murata P/N :GCH1885C2A470JE01
* Property : C = 4.70e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A470JE01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 8.30e-11
R03 N02 N03 9.36e-02
L04 N03 N04 1.81e-11
R04 N03 N04 5.64e-02
C05 N04 N05 3.41e-10
L05 N04 N05 1.76e-11
R05 N04 N05 1.46e+00
C06 N05 N06 8.02e-11
L06 N05 N06 2.24e-11
R06 N05 N06 2.28e+00
C07 N06 N07 3.40e-12
L07 N06 N07 8.37e-11
R07 N06 N07 8.18e+00
C08 N07 Port2 8.47e-13
L08 N07 Port2 2.74e-10
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A470JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCH1885C2A471JE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A471JE01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.05e-10
R03 N02 N03 5.73e-02
L04 N03 N04 2.47e-11
R04 N03 N04 5.08e-01
C05 N04 N05 2.92e-09
L05 N04 N05 2.15e-11
R05 N04 N05 6.77e-01
C06 N05 N06 8.44e-10
L06 N05 N06 2.40e-11
R06 N05 N06 7.31e-01
C07 N06 N07 3.52e-10
L07 N06 N07 1.75e-11
R07 N06 N07 4.36e-01
C08 N07 N08 3.96e-12
L08 N07 N08 6.72e-11
R08 N07 N08 7.97e+00
C09 N08 Port2 1.06e-12
L09 N08 Port2 2.33e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1885C2A471JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A4R0CE01
* Property : C = 4.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A4R0CE01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.09e-10
R03 N02 N03 1.54e-01
L04 N03 N04 2.07e-11
R04 N03 N04 5.72e-01
L05 N04 N05 2.04e-11
R05 N04 N05 1.20e-01
C06 N05 N06 1.50e-11
L06 N05 N06 2.86e-11
R06 N05 N06 1.37e+01
C07 N06 Port2 4.25e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A4R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A5R0CE01
* Property : C = 5.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A5R0CE01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.45e-10
R03 N02 N03 1.42e-01
L04 N03 N04 2.85e-11
R04 N03 N04 1.94e-01
C05 N04 N05 1.78e-11
L05 N04 N05 3.23e-11
R05 N04 N05 1.55e+01
C06 N05 N06 6.36e-12
L06 N05 N06 4.90e-11
R06 N05 N06 2.07e+01
C07 N06 Port2 4.62e-12
L07 N06 Port2 6.34e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A5R0CE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/100[V]
* Murata P/N :GCH1885C2A680JE01
* Property : C = 6.80e-05[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A680JE01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 7.56e-11
R03 N02 N03 9.03e-02
L04 N03 N04 3.55e-11
R04 N03 N04 1.14e-01
C05 N04 N05 3.35e-09
L05 N04 N05 2.17e-12
R05 N04 N05 1.10e-01
C06 N05 N06 8.09e-11
L06 N05 N06 2.26e-11
R06 N05 N06 1.06e+00
C07 N06 N07 2.02e-12
L07 N06 N07 1.62e-10
R07 N06 N07 5.69e+01
C08 N07 Port2 6.90e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 3.16e+07
.ENDS GCH1885C2A680JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCH1885C2A681JE01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A681JE01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 8.66e-11
R03 N02 N03 5.45e-02
L04 N03 N04 3.14e-11
R04 N03 N04 1.32e+00
L05 N04 N05 6.44e-11
R05 N04 N05 4.02e-01
C06 N05 N06 6.92e-09
L06 N05 N06 1.31e-11
R06 N05 N06 3.50e-01
C07 N06 N07 1.89e-09
L07 N06 N07 1.69e-11
R07 N06 N07 4.75e-01
C08 N07 N08 2.85e-11
L08 N07 N08 1.17e-11
R08 N07 N08 5.70e+00
C09 N08 Port2 7.27e-13
L09 N08 Port2 3.19e-10
R09 N08 Port2 1.00e+05
.ENDS GCH1885C2A681JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A6R0DE01
* Property : C = 6.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A6R0DE01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.60e-10
R03 N02 N03 1.38e-01
L04 N03 N04 1.72e-11
R04 N03 N04 4.49e-01
L05 N04 N05 4.02e-11
R05 N04 N05 1.53e-01
C06 N05 N06 1.20e-11
L06 N05 N06 2.48e-11
R06 N05 N06 3.45e+00
C07 N06 Port2 1.91e-12
L07 N06 Port2 1.32e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A6R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A7R0DE01
* Property : C = 7.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A7R0DE01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 4.11e-10
R03 N02 N03 1.32e-01
L04 N03 N04 9.41e-12
R04 N03 N04 1.70e-01
L05 N04 N05 4.67e-11
R05 N04 N05 1.63e-01
C06 N05 N06 5.96e-12
L06 N05 N06 5.38e-11
R06 N05 N06 1.33e+01
C07 N06 Port2 1.16e-11
L07 N06 Port2 2.70e-11
R07 N06 Port2 1.00e+05
.ENDS GCH1885C2A7R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A8R0DE01
* Property : C = 8.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A8R0DE01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.52e-10
R03 N02 N03 1.29e-01
L04 N03 N04 2.81e-11
R04 N03 N04 1.21e-01
C05 N04 N05 3.15e-11
L05 N04 N05 2.88e-11
R05 N04 N05 1.20e+01
C06 N05 N06 6.27e-12
L06 N05 N06 6.72e-11
R06 N05 N06 2.51e+01
C07 N06 Port2 1.63e-11
L07 N06 Port2 1.96e-11
R07 N06 Port2 4.09e+01
.ENDS GCH1885C2A8R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/100[V]
* Murata P/N :GCH1885C2A9R0DE01
* Property : C = 9.00e-06[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1885C2A9R0DE01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.21e-10
R03 N02 N03 1.16e-01
L04 N03 N04 7.31e-12
R04 N03 N04 1.08e-01
L05 N04 N05 2.31e-11
R05 N04 N05 1.03e-01
C06 N05 N06 3.73e-11
L06 N05 N06 2.75e-11
R06 N05 N06 1.23e+01
C07 N06 N07 7.08e-12
L07 N06 N07 6.43e-11
R07 N06 N07 2.16e+01
C08 N07 Port2 5.13e-12
L08 N07 Port2 5.71e-11
R08 N07 Port2 1.00e+05
.ENDS GCH1885C2A9R0DE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GCH188C71A225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188C71A225KE01 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.15e-10
R03 N02 N03 6.37e-03
C04 N03 N04 1.12e-05
R04 N03 N04 8.23e+02
C05 N04 N05 5.86e-05
R05 N04 N05 2.46e+01
C06 N05 N06 5.59e-05
R06 N05 N06 3.02e+00
C07 N06 N07 5.87e-05
R07 N06 N07 6.97e-01
C08 N07 N08 4.13e-05
R08 N07 N08 1.35e-01
C09 N08 N09 3.89e-05
R09 N08 N09 2.19e-02
C10 N09 N10 2.24e-05
R10 N09 N10 6.28e-03
L11 N10 N11 3.49e-11
R11 N10 N11 1.19e-01
L12 N11 N12 1.88e-10
R12 N11 N12 3.66e-02
C13 N12 N13 4.07e-06
L13 N12 N13 4.77e-11
R13 N12 N13 6.51e-03
C14 N13 N14 1.67e-06
L14 N13 N14 5.43e-11
R14 N13 N14 8.88e-03
C15 N14 Port2 7.69e-12
L15 N14 Port2 5.18e-11
R15 N14 Port2 6.38e+00
.ENDS GCH188C71A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GCH188R70J225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R70J225KE01 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.69e-10
R03 N02 N03 5.97e-03
C04 N03 N04 1.90e-05
R04 N03 N04 3.07e+02
C05 N04 N05 4.34e-05
R05 N04 N05 9.88e+00
C06 N05 N06 3.83e-05
R06 N05 N06 1.11e+00
C07 N06 N07 3.33e-05
R07 N06 N07 1.23e-01
C08 N07 N08 2.66e-05
R08 N07 N08 1.66e-02
L09 N08 N09 3.37e-11
R09 N08 N09 9.20e-02
L10 N09 N10 2.06e-10
R10 N09 N10 3.25e-02
C11 N10 N11 7.94e-06
L11 N10 N11 2.72e-11
R11 N10 N11 4.64e-03
C12 N11 N12 3.18e-06
L12 N11 N12 3.60e-11
R12 N11 N12 7.37e-03
C13 N12 Port2 2.77e-12
L13 N12 Port2 1.22e-10
R13 N12 Port2 3.22e+01
.ENDS GCH188R70J225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GCH188R71C104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71C104KE01 Port1 Port2
C01 Port1 N01 9.72e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.63e-10
R03 N02 N03 2.16e-02
C04 N03 N04 5.57e-06
R04 N03 N04 2.99e-01
C05 N04 N05 6.54e-06
R05 N04 N05 2.84e-02
L06 N05 N06 1.58e-11
R06 N05 N06 1.17e-01
L07 N06 N07 1.12e-10
R07 N06 N07 9.73e-02
C08 N07 N08 9.54e-07
L08 N07 N08 1.52e-11
R08 N07 N08 1.05e-02
C09 N08 N09 1.15e-07
L09 N08 N09 5.03e-11
R09 N08 N09 2.90e-02
C10 N09 Port2 4.32e-12
L10 N09 Port2 1.02e-10
R10 N09 Port2 9.76e+00
.ENDS GCH188R71C104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCH188R71C105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71C105KE01 Port1 Port2
C01 Port1 N01 7.40e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 8.09e-11
R03 N02 N03 7.70e-03
C04 N03 N04 5.36e-06
R04 N03 N04 1.25e+03
C05 N04 N05 1.82e-05
R05 N04 N05 1.91e+01
C06 N05 N06 1.78e-05
R06 N05 N06 1.75e+00
C07 N06 N07 1.39e-05
R07 N06 N07 2.03e-01
C08 N07 N08 1.04e-05
R08 N07 N08 2.32e-02
L09 N08 N09 2.93e-11
R09 N08 N09 1.10e-01
L10 N09 N10 1.74e-10
R10 N09 N10 4.23e-02
C11 N10 N11 3.08e-06
L11 N10 N11 3.06e-11
R11 N10 N11 1.02e-02
C12 N11 N12 9.65e-07
L12 N11 N12 4.54e-11
R12 N11 N12 1.55e-02
C13 N12 Port2 1.23e-12
L13 N12 Port2 2.21e-10
R13 N12 Port2 8.74e+01
.ENDS GCH188R71C105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GCH188R71C474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71C474KE01 Port1 Port2
C01 Port1 N01 4.36e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.21e-10
R03 N02 N03 9.10e-03
C04 N03 N04 3.68e-05
R04 N03 N04 8.32e-02
C05 N04 N05 3.44e-05
R05 N04 N05 1.37e-02
L06 N05 N06 1.99e-11
R06 N05 N06 6.86e-02
L07 N06 N07 1.59e-10
R07 N06 N07 4.70e-02
C08 N07 N08 3.11e-06
L08 N07 N08 2.07e-11
R08 N07 N08 8.59e-03
C09 N08 N09 9.14e-07
L09 N08 N09 3.51e-11
R09 N08 N09 1.52e-02
C10 N09 Port2 5.75e-12
L10 N09 Port2 8.99e-11
R10 N09 Port2 8.28e+00
.ENDS GCH188R71C474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GCH188R71E104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71E104KE01 Port1 Port2
C01 Port1 N01 9.60e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.04e-10
R03 N02 N03 1.27e-02
C04 N03 N04 7.31e-06
R04 N03 N04 2.60e-01
C05 N04 N05 1.34e-05
R05 N04 N05 2.99e-02
C06 N05 N06 8.06e-06
R06 N05 N06 1.33e-02
L07 N06 N07 1.34e-10
R07 N06 N07 9.34e-02
L08 N07 N08 1.32e-11
R08 N07 N08 7.95e-02
C09 N08 N09 4.79e-07
L09 N08 N09 2.83e-11
R09 N08 N09 2.91e-02
C10 N09 N10 1.33e-07
L10 N09 N10 4.72e-11
R10 N09 N10 4.14e-02
C11 N10 Port2 5.72e-12
L11 N10 Port2 7.45e-11
R11 N10 Port2 7.44e+00
.ENDS GCH188R71E104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCH188R71E105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71E105KE01 Port1 Port2
C01 Port1 N01 7.40e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 8.09e-11
R03 N02 N03 7.70e-03
C04 N03 N04 5.36e-06
R04 N03 N04 1.25e+03
C05 N04 N05 1.82e-05
R05 N04 N05 1.91e+01
C06 N05 N06 1.78e-05
R06 N05 N06 1.75e+00
C07 N06 N07 1.39e-05
R07 N06 N07 2.03e-01
C08 N07 N08 1.04e-05
R08 N07 N08 2.32e-02
L09 N08 N09 2.93e-11
R09 N08 N09 1.10e-01
L10 N09 N10 1.74e-10
R10 N09 N10 4.23e-02
C11 N10 N11 3.08e-06
L11 N10 N11 3.06e-11
R11 N10 N11 1.02e-02
C12 N11 N12 9.65e-07
L12 N11 N12 4.54e-11
R12 N11 N12 1.55e-02
C13 N12 Port2 1.23e-12
L13 N12 Port2 2.21e-10
R13 N12 Port2 8.74e+01
.ENDS GCH188R71E105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCH188R71E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71E224KE01 Port1 Port2
C01 Port1 N01 2.16e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 8.00e-11
R03 N02 N03 1.04e-02
C04 N03 N04 3.30e-05
R04 N03 N04 4.21e-01
C05 N04 N05 3.53e-05
R05 N04 N05 1.79e-01
C06 N05 N06 1.92e-05
R06 N05 N06 7.72e-02
C07 N06 N07 1.75e-05
R07 N06 N07 1.19e-02
C08 N07 N08 2.44e-05
R08 N07 N08 1.67e-03
L09 N08 N09 2.01e-11
R09 N08 N09 9.46e-02
L10 N09 N10 1.48e-10
R10 N09 N10 5.18e-02
C11 N10 N11 1.40e-06
L11 N10 N11 2.01e-11
R11 N10 N11 1.03e-02
C12 N11 N12 4.92e-07
L12 N11 N12 2.79e-11
R12 N11 N12 1.75e-02
C13 N12 N13 9.57e-12
L13 N12 N13 6.67e-11
R13 N12 N13 6.83e+00
C14 N13 Port2 1.10e-12
L14 N13 Port2 1.60e-10
R14 N13 Port2 6.00e+01
.ENDS GCH188R71E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCH188R71E473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71E473KE01 Port1 Port2
C01 Port1 N01 4.49e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 2.31e-10
R03 N02 N03 3.33e-02
C04 N03 N04 2.63e-06
R04 N03 N04 6.33e-01
C05 N04 N05 6.92e-06
R05 N04 N05 6.22e-02
C06 N05 N06 2.50e-06
R06 N05 N06 3.51e-02
L07 N06 N07 1.01e-10
R07 N06 N07 1.21e-01
C08 N07 N08 1.18e-07
L08 N07 N08 3.52e-11
R08 N07 N08 2.66e-02
C09 N08 N09 1.20e-07
L09 N08 N09 1.69e-11
R09 N08 N09 2.66e-02
C10 N09 Port2 3.88e-12
L10 N09 Port2 1.38e-10
R10 N09 Port2 1.23e+01
.ENDS GCH188R71E473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCH188R71H102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H102KE01 Port1 Port2
C01 Port1 N01 9.87e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 2.33e-01
C04 N03 N04 1.60e-08
R04 N03 N04 1.50e+02
C05 N04 N05 5.51e-08
R05 N04 N05 1.78e+00
C06 N05 N06 2.99e-07
R06 N05 N06 1.27e+00
C07 N06 N07 4.58e-08
R07 N06 N07 3.15e-01
C08 N07 N08 1.38e-08
R08 N07 N08 2.45e-01
L09 N08 N09 3.99e-11
R09 N08 N09 5.01e-01
C10 N09 N10 6.54e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.47e-01
C11 N10 N11 9.14e-10
L11 N10 N11 3.05e-11
R11 N10 N11 3.09e-01
C12 N11 N12 6.97e-12
L12 N11 N12 1.03e-10
R12 N11 N12 1.43e+01
C13 N12 Port2 3.04e-12
L13 N12 Port2 1.21e-10
R13 N12 Port2 2.21e+01
.ENDS GCH188R71H102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCH188R71H103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H103KE01 Port1 Port2
C01 Port1 N01 9.62e-09
R01 Port1 N01 5.00e+09
L02 N01 N02 2.56e-10
R03 N02 N03 6.09e-02
C04 N03 N04 4.91e-07
R04 N03 N04 3.05e+00
C05 N04 N05 5.77e-07
R05 N04 N05 3.04e-01
C06 N05 N06 3.66e-07
R06 N05 N06 6.31e-02
L07 N06 N07 6.40e-11
R07 N06 N07 1.88e-01
C08 N07 N08 5.54e-08
L08 N07 N08 2.05e-11
R08 N07 N08 5.03e-02
C09 N08 N09 1.66e-08
L09 N08 N09 2.36e-11
R09 N08 N09 7.23e-02
C10 N09 Port2 4.60e-12
L10 N09 Port2 1.26e-10
R10 N09 Port2 1.13e+01
.ENDS GCH188R71H103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCH188R71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H104KE01 Port1 Port2
C01 Port1 N01 9.59e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 6.50e-11
R03 N02 N03 1.25e-02
C04 N03 N04 8.77e-06
R04 N03 N04 1.04e+00
C05 N04 N05 2.69e-05
R05 N04 N05 1.55e-01
C06 N05 N06 1.30e-05
R06 N05 N06 9.48e-02
C07 N06 N07 1.02e-05
R07 N06 N07 2.52e-02
C08 N07 N08 1.43e-05
R08 N07 N08 5.66e-03
L09 N08 N09 1.44e-10
R09 N08 N09 8.80e-02
L10 N09 N10 1.06e-11
R10 N09 N10 5.01e-02
C11 N10 N11 7.05e-07
L11 N10 N11 1.94e-11
R11 N10 N11 2.12e-02
C12 N11 N12 1.56e-07
L12 N11 N12 4.23e-11
R12 N11 N12 3.80e-02
C13 N12 N13 1.22e-11
L13 N12 N13 4.83e-11
R13 N12 N13 5.36e+00
C14 N13 Port2 8.34e-13
L14 N13 Port2 1.53e-10
R14 N13 Port2 5.23e+01
.ENDS GCH188R71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCH188R71H222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H222KE01 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.73e-10
R03 N02 N03 1.59e-01
C04 N03 N04 6.91e-08
R04 N03 N04 3.05e+01
C05 N04 N05 1.50e-07
R05 N04 N05 1.22e+00
C06 N05 N06 1.26e-07
R06 N05 N06 2.67e-01
C07 N06 N07 4.73e-08
R07 N06 N07 1.27e-01
L08 N07 N08 3.87e-11
R08 N07 N08 2.32e-01
C09 N08 N09 1.68e-08
L09 N08 N09 1.31e-11
R09 N08 N09 6.42e-02
C10 N09 N10 3.69e-09
L10 N09 N10 2.54e-11
R10 N09 N10 1.67e-01
C11 N10 N11 5.43e-12
L11 N10 N11 1.54e-10
R11 N10 N11 1.20e+01
C12 N11 Port2 7.64e-12
L12 N11 Port2 4.98e-11
R12 N11 Port2 5.06e+00
.ENDS GCH188R71H222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCH188R71H223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H223KE01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 2.27e+09
L02 N01 N02 2.63e-10
R03 N02 N03 4.80e-02
C04 N03 N04 1.14e-06
R04 N03 N04 1.02e+00
C05 N04 N05 1.44e-06
R05 N04 N05 9.17e-02
C06 N05 N06 1.42e-06
R06 N05 N06 2.08e-02
L07 N06 N07 6.28e-11
R07 N06 N07 1.58e-01
C08 N07 N08 1.11e-07
L08 N07 N08 1.97e-11
R08 N07 N08 2.94e-02
C09 N08 N09 2.46e-08
L09 N08 N09 3.65e-11
R09 N08 N09 5.92e-02
C10 N09 Port2 3.97e-12
L10 N09 Port2 1.55e-10
R10 N09 Port2 1.03e+01
.ENDS GCH188R71H223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCH188R71H224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H224KE01 Port1 Port2
C01 Port1 N01 2.13e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.55e-10
R03 N02 N03 8.21e-03
C04 N03 N04 3.69e-05
R04 N03 N04 2.16e-01
C05 N04 N05 4.14e-05
R05 N04 N05 3.85e-02
C06 N05 N06 9.40e-05
R06 N05 N06 3.76e-02
C07 N06 N07 3.12e-05
R07 N06 N07 8.60e-03
C08 N07 N08 2.16e-05
R08 N07 N08 9.63e-04
L09 N08 N09 1.72e-11
R09 N08 N09 7.22e-02
L10 N09 N10 1.42e-10
R10 N09 N10 5.34e-02
C11 N10 N11 1.14e-06
L11 N10 N11 2.59e-11
R11 N10 N11 1.38e-02
C12 N11 N12 4.64e-07
L12 N11 N12 3.11e-11
R12 N11 N12 2.12e-02
C13 N12 N13 8.00e-12
L13 N12 N13 7.49e-11
R13 N12 N13 1.09e+01
C14 N13 Port2 2.50e-12
L14 N13 Port2 1.00e-10
R14 N13 Port2 4.00e+01
.ENDS GCH188R71H224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCH188R71H472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H472KE01 Port1 Port2
C01 Port1 N01 4.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 1.11e-01
C04 N03 N04 1.98e-07
R04 N03 N04 7.55e+00
C05 N04 N05 2.74e-07
R05 N04 N05 4.73e-01
C06 N05 N06 1.53e-07
R06 N05 N06 9.29e-02
C07 N06 N07 3.34e-06
R07 N06 N07 1.05e-02
L08 N07 N08 8.02e-11
R08 N07 N08 3.69e-01
C09 N08 N09 2.31e-08
L09 N08 N09 1.92e-11
R09 N08 N09 6.33e-02
C10 N09 N10 9.92e-09
L10 N09 N10 1.95e-11
R10 N09 N10 1.03e-01
C11 N10 N11 5.01e-12
L11 N10 N11 1.29e-10
R11 N10 N11 1.25e+01
C12 N11 Port2 9.31e-12
L12 N11 Port2 3.97e-11
R12 N11 Port2 8.64e+00
.ENDS GCH188R71H472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCH188R71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R71H473KE01 Port1 Port2
C01 Port1 N01 4.61e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 2.41e-10
R03 N02 N03 2.00e-02
C04 N03 N04 3.28e-06
R04 N03 N04 4.33e-01
C05 N04 N05 3.72e-06
R05 N04 N05 3.42e-02
C06 N05 N06 2.04e-05
R06 N05 N06 1.52e-02
L07 N06 N07 1.01e-10
R07 N06 N07 1.24e-01
L08 N07 N08 1.06e-11
R08 N07 N08 9.88e-02
C09 N08 N09 2.31e-07
L09 N08 N09 2.48e-11
R09 N08 N09 3.03e-02
C10 N09 N10 5.73e-08
L10 N09 N10 4.42e-11
R10 N09 N10 5.27e-02
C11 N10 Port2 9.31e-12
L11 N10 Port2 6.86e-11
R11 N10 Port2 6.66e+00
.ENDS GCH188R71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCH188R72A102KE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A102KE01 Port1 Port2
C01 Port1 N01 9.87e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 2.33e-01
C04 N03 N04 1.60e-08
R04 N03 N04 1.50e+02
C05 N04 N05 5.51e-08
R05 N04 N05 1.78e+00
C06 N05 N06 2.99e-07
R06 N05 N06 1.27e+00
C07 N06 N07 4.58e-08
R07 N06 N07 3.15e-01
C08 N07 N08 1.38e-08
R08 N07 N08 2.45e-01
L09 N08 N09 3.99e-11
R09 N08 N09 5.01e-01
C10 N09 N10 6.54e-09
L10 N09 N10 1.19e-11
R10 N09 N10 1.47e-01
C11 N10 N11 9.14e-10
L11 N10 N11 3.05e-11
R11 N10 N11 3.09e-01
C12 N11 N12 6.97e-12
L12 N11 N12 1.03e-10
R12 N11 N12 1.43e+01
C13 N12 Port2 3.04e-12
L13 N12 Port2 1.21e-10
R13 N12 Port2 2.21e+01
.ENDS GCH188R72A102KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCH188R72A103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A103KE01 Port1 Port2
C01 Port1 N01 9.87e-09
R01 Port1 N01 5.00e+09
L02 N01 N02 1.95e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.92e-06
R04 N03 N04 8.29e+00
C05 N04 N05 1.29e-06
R05 N04 N05 4.66e+00
C06 N05 N06 9.02e-07
R06 N05 N06 1.47e+00
C07 N06 N07 5.37e-07
R07 N06 N07 3.29e-01
C08 N07 N08 3.52e-07
R08 N07 N08 6.47e-02
L09 N08 N09 8.51e-11
R09 N08 N09 2.56e-01
C10 N09 N10 1.75e-07
L10 N09 N10 5.93e-12
R10 N09 N10 1.39e-02
C11 N10 N11 1.32e-08
L11 N10 N11 3.08e-11
R11 N10 N11 6.91e-02
C12 N11 N12 3.29e-11
L12 N11 N12 1.34e-10
R12 N11 N12 2.42e+00
C13 N12 Port2 2.51e-12
L13 N12 Port2 1.25e-10
R13 N12 Port2 1.32e+01
.ENDS GCH188R72A103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCH188R72A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A104KE01 Port1 Port2
C01 Port1 N01 9.52e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.06e-10
R03 N02 N03 1.30e-02
C04 N03 N04 1.30e-05
R04 N03 N04 7.75e-01
C05 N04 N05 1.64e-05
R05 N04 N05 2.45e-01
C06 N05 N06 1.45e-05
R06 N05 N06 8.71e-02
C07 N06 N07 1.10e-05
R07 N06 N07 2.03e-02
C08 N07 N08 1.15e-05
R08 N07 N08 4.11e-03
L09 N08 N09 1.01e-10
R09 N08 N09 8.58e-02
L10 N09 N10 9.35e-12
R10 N09 N10 5.03e-02
C11 N10 N11 5.19e-07
L11 N10 N11 2.64e-11
R11 N10 N11 2.87e-02
C12 N11 N12 1.24e-07
L12 N11 N12 3.34e-11
R12 N11 N12 2.81e-02
C13 N12 Port2 2.98e-12
L13 N12 Port2 1.00e-10
R13 N12 Port2 1.17e+01
.ENDS GCH188R72A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCH188R72A222KE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A222KE01 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.73e-10
R03 N02 N03 1.59e-01
C04 N03 N04 6.91e-08
R04 N03 N04 3.05e+01
C05 N04 N05 1.50e-07
R05 N04 N05 1.22e+00
C06 N05 N06 1.26e-07
R06 N05 N06 2.67e-01
C07 N06 N07 4.73e-08
R07 N06 N07 1.27e-01
L08 N07 N08 3.87e-11
R08 N07 N08 2.32e-01
C09 N08 N09 1.68e-08
L09 N08 N09 1.31e-11
R09 N08 N09 6.42e-02
C10 N09 N10 3.69e-09
L10 N09 N10 2.54e-11
R10 N09 N10 1.67e-01
C11 N10 N11 5.43e-12
L11 N10 N11 1.54e-10
R11 N10 N11 1.20e+01
C12 N11 Port2 7.64e-12
L12 N11 Port2 4.98e-11
R12 N11 Port2 5.06e+00
.ENDS GCH188R72A222KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCH188R72A223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A223KE01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 2.27e+09
L02 N01 N02 2.63e-10
R03 N02 N03 4.80e-02
C04 N03 N04 1.14e-06
R04 N03 N04 1.02e+00
C05 N04 N05 1.44e-06
R05 N04 N05 9.17e-02
C06 N05 N06 1.42e-06
R06 N05 N06 2.08e-02
L07 N06 N07 6.28e-11
R07 N06 N07 1.58e-01
C08 N07 N08 1.11e-07
L08 N07 N08 1.97e-11
R08 N07 N08 2.94e-02
C09 N08 N09 2.46e-08
L09 N08 N09 3.65e-11
R09 N08 N09 5.92e-02
C10 N09 Port2 3.97e-12
L10 N09 Port2 1.55e-10
R10 N09 Port2 1.03e+01
.ENDS GCH188R72A223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCH188R72A472KE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R72A472KE01 Port1 Port2
C01 Port1 N01 4.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 8.10e-02
C04 N03 N04 3.29e-07
R04 N03 N04 4.35e+00
C05 N04 N05 2.55e-07
R05 N04 N05 6.58e-01
C06 N05 N06 2.55e-07
R06 N05 N06 1.09e-01
C07 N06 N07 9.00e-08
R07 N06 N07 4.86e-02
L08 N07 N08 9.02e-11
R08 N07 N08 4.45e-01
C09 N08 N09 4.03e-08
L09 N08 N09 1.30e-11
R09 N08 N09 4.44e-02
C10 N09 N10 4.98e-09
L10 N09 N10 4.40e-11
R10 N09 N10 1.32e-01
C11 N10 N11 6.93e-11
L11 N10 N11 4.66e-11
R11 N10 N11 1.03e+00
C12 N11 Port2 2.84e-12
L12 N11 Port2 1.20e-10
R12 N11 Port2 1.54e+01
.ENDS GCH188R72A472KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCH2165C1H102JE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C1H102JE01 Port1 Port2
C01 Port1 N01 9.87e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.35e-10
R03 N02 N03 1.92e-02
L04 N03 N04 3.19e-11
R04 N03 N04 4.38e-01
L05 N04 N05 9.79e-11
R05 N04 N05 3.19e-02
C06 N05 N06 7.24e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.04e-01
C07 N06 N07 5.42e-10
L07 N06 N07 2.60e-11
R07 N06 N07 3.37e-01
C08 N07 Port2 1.26e-12
L08 N07 Port2 3.24e-10
R08 N07 Port2 3.82e+02
.ENDS GCH2165C1H102JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCH2165C1H152JE01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C1H152JE01 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.98e-11
R03 N02 N03 1.38e-02
L04 N03 N04 5.98e-11
R04 N03 N04 5.18e-01
L05 N04 N05 7.30e-11
R05 N04 N05 2.45e-02
C06 N05 N06 9.64e-09
L06 N05 N06 9.86e-12
R06 N05 N06 1.38e-01
C07 N06 N07 1.46e-09
L07 N06 N07 2.03e-11
R07 N06 N07 3.35e-01
C08 N07 N08 1.82e-12
L08 N07 N08 1.96e-10
R08 N07 N08 1.70e+02
C09 N08 Port2 1.48e-12
L09 N08 Port2 1.93e-10
R09 N08 Port2 1.00e+05
.ENDS GCH2165C1H152JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCH2165C1H222JE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C1H222JE01 Port1 Port2
C01 Port1 N01 2.27e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.51e-11
R04 N03 N04 3.77e-01
L05 N04 N05 7.62e-11
R05 N04 N05 1.62e-02
C06 N05 N06 1.57e-08
L06 N05 N06 1.41e-11
R06 N05 N06 2.23e-01
C07 N06 N07 2.62e-09
L07 N06 N07 3.14e-11
R07 N06 N07 4.52e-01
C08 N07 Port2 2.05e-12
L08 N07 Port2 1.72e-10
R08 N07 Port2 8.24e+01
.ENDS GCH2165C1H222JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCH2165C1H332JE01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C1H332JE01 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 9.77e-11
R03 N02 N03 9.29e-03
L04 N03 N04 9.61e-11
R04 N03 N04 4.14e-01
L05 N04 N05 7.02e-11
R05 N04 N05 1.35e-02
C06 N05 N06 1.63e-08
L06 N05 N06 2.20e-11
R06 N05 N06 2.07e-01
C07 N06 N07 3.68e-09
L07 N06 N07 4.17e-11
R07 N06 N07 4.46e-01
C08 N07 N08 2.59e-12
L08 N07 N08 1.44e-10
R08 N07 N08 8.93e+01
C09 N08 Port2 2.67e-12
L09 N08 Port2 1.20e-10
R09 N08 Port2 1.00e+05
.ENDS GCH2165C1H332JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCH2165C1H472JE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C1H472JE01 Port1 Port2
C01 Port1 N01 4.84e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 6.31e-11
R03 N02 N03 7.28e-03
L04 N03 N04 7.68e-11
R04 N03 N04 2.96e-01
L05 N04 N05 6.53e-11
R05 N04 N05 1.42e-02
C06 N05 N06 2.55e-08
L06 N05 N06 1.77e-11
R06 N05 N06 1.89e-01
C07 N06 N07 5.90e-09
L07 N06 N07 2.85e-11
R07 N06 N07 3.32e-01
C08 N07 N08 5.56e-12
L08 N07 N08 6.32e-11
R08 N07 N08 1.84e+01
C09 N08 Port2 1.32e-12
L09 N08 Port2 2.11e-10
R09 N08 Port2 1.00e+05
.ENDS GCH2165C1H472JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GCH2165C2A101JE01
* Property : C = 1.00e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A101JE01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 6.40e-11
R03 N02 N03 1.00e-01
C04 N03 N04 3.20e-10
L04 N03 N04 1.77e-11
R04 N03 N04 1.06e+00
C05 N04 N05 7.88e-11
L05 N04 N05 2.23e-11
R05 N04 N05 2.64e+00
C06 N05 Port2 9.11e-13
L06 N05 Port2 3.67e-10
R06 N05 Port2 2.08e+02
.ENDS GCH2165C2A101JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCH2165C2A102JE01
* Property : C = 1.00e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A102JE01 Port1 Port2
C01 Port1 N01 9.87e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.35e-10
R03 N02 N03 1.92e-02
L04 N03 N04 3.19e-11
R04 N03 N04 4.38e-01
L05 N04 N05 9.79e-11
R05 N04 N05 3.19e-02
C06 N05 N06 7.24e-09
L06 N05 N06 6.36e-12
R06 N05 N06 1.04e-01
C07 N06 N07 5.42e-10
L07 N06 N07 2.60e-11
R07 N06 N07 3.37e-01
C08 N07 Port2 1.26e-12
L08 N07 Port2 3.24e-10
R08 N07 Port2 3.82e+02
.ENDS GCH2165C2A102JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GCH2165C2A151JE01
* Property : C = 1.50e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A151JE01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.59e-10
R03 N02 N03 8.00e-02
C04 N03 N04 4.49e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.28e-01
C05 N04 N05 9.50e-11
L05 N04 N05 2.95e-11
R05 N04 N05 1.98e+00
C06 N05 N06 2.92e-11
L06 N05 N06 2.29e-11
R06 N05 N06 2.13e+00
C07 N06 N07 3.38e-12
L07 N06 N07 1.04e-10
R07 N06 N07 3.91e+01
C08 N07 Port2 2.11e-12
L08 N07 Port2 1.53e-10
R08 N07 Port2 1.00e+05
.ENDS GCH2165C2A151JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCH2165C2A152JE01
* Property : C = 1.50e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A152JE01 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 3.98e-11
R03 N02 N03 1.38e-02
L04 N03 N04 5.98e-11
R04 N03 N04 5.18e-01
L05 N04 N05 7.30e-11
R05 N04 N05 2.45e-02
C06 N05 N06 9.64e-09
L06 N05 N06 9.86e-12
R06 N05 N06 1.38e-01
C07 N06 N07 1.46e-09
L07 N06 N07 2.03e-11
R07 N06 N07 3.35e-01
C08 N07 N08 1.82e-12
L08 N07 N08 1.96e-10
R08 N07 N08 1.70e+02
C09 N08 Port2 1.48e-12
L09 N08 Port2 1.93e-10
R09 N08 Port2 1.00e+05
.ENDS GCH2165C2A152JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GCH2165C2A221JE01
* Property : C = 2.20e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A221JE01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 7.40e-11
R03 N02 N03 7.35e-02
L04 N03 N04 1.74e-11
R04 N03 N04 3.38e-01
C05 N04 N05 7.83e-10
L05 N04 N05 1.81e-11
R05 N04 N05 8.79e-01
C06 N05 N06 1.62e-10
L06 N05 N06 2.89e-11
R06 N05 N06 1.65e+00
C07 N06 N07 1.45e-10
L07 N06 N07 7.82e-12
R07 N06 N07 8.02e-01
C08 N07 Port2 1.17e-12
L08 N07 Port2 3.13e-10
R08 N07 Port2 2.34e+02
.ENDS GCH2165C2A221JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCH2165C2A222JE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A222JE01 Port1 Port2
C01 Port1 N01 2.27e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.51e-11
R04 N03 N04 3.77e-01
L05 N04 N05 7.62e-11
R05 N04 N05 1.62e-02
C06 N05 N06 1.57e-08
L06 N05 N06 1.41e-11
R06 N05 N06 2.23e-01
C07 N06 N07 2.62e-09
L07 N06 N07 3.14e-11
R07 N06 N07 4.52e-01
C08 N07 Port2 2.05e-12
L08 N07 Port2 1.72e-10
R08 N07 Port2 8.24e+01
.ENDS GCH2165C2A222JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCH2165C2A331JE01
* Property : C = 3.30e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A331JE01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 9.14e-11
R03 N02 N03 7.53e-02
L04 N03 N04 1.93e-11
R04 N03 N04 5.64e-01
L05 N04 N05 1.09e-11
R05 N04 N05 3.44e-02
C06 N05 N06 1.03e-09
L06 N05 N06 1.21e-11
R06 N05 N06 2.45e-01
C07 N06 N07 1.49e-10
L07 N06 N07 2.18e-11
R07 N06 N07 6.71e-01
C08 N07 N08 1.95e-12
L08 N07 N08 1.61e-10
R08 N07 N08 1.00e+05
C09 N08 Port2 1.37e-12
L09 N08 Port2 2.24e-10
R09 N08 Port2 2.42e+02
.ENDS GCH2165C2A331JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCH2165C2A332JE01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A332JE01 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 9.77e-11
R03 N02 N03 9.29e-03
L04 N03 N04 9.61e-11
R04 N03 N04 4.14e-01
L05 N04 N05 7.02e-11
R05 N04 N05 1.35e-02
C06 N05 N06 1.63e-08
L06 N05 N06 2.20e-11
R06 N05 N06 2.07e-01
C07 N06 N07 3.68e-09
L07 N06 N07 4.17e-11
R07 N06 N07 4.46e-01
C08 N07 N08 2.59e-12
L08 N07 N08 1.44e-10
R08 N07 N08 8.93e+01
C09 N08 Port2 2.67e-12
L09 N08 Port2 1.20e-10
R09 N08 Port2 1.00e+05
.ENDS GCH2165C2A332JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCH2165C2A471JE01
* Property : C = 4.70e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A471JE01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 1.31e-10
R03 N02 N03 6.00e-02
L04 N03 N04 3.94e-11
R04 N03 N04 1.17e+00
C05 N04 N05 1.59e-09
L05 N04 N05 1.50e-11
R05 N04 N05 2.83e-01
C06 N05 N06 2.75e-10
L06 N05 N06 2.56e-11
R06 N05 N06 6.52e-01
C07 N06 Port2 1.22e-12
L07 N06 Port2 3.10e-10
R07 N06 Port2 2.99e+02
.ENDS GCH2165C2A471JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCH2165C2A681JE01
* Property : C = 6.80e-04[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2165C2A681JE01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+11
L02 N01 N02 4.36e-12
R03 N02 N03 5.00e-02
L04 N03 N04 6.97e-11
R04 N03 N04 8.55e-01
C05 N04 N05 3.29e-09
L05 N04 N05 1.32e-11
R05 N04 N05 3.27e-01
C06 N05 N06 7.20e-10
L06 N05 N06 2.00e-11
R06 N05 N06 5.82e-01
C07 N06 N07 1.64e-11
L07 N06 N07 2.39e-11
R07 N06 N07 6.05e+00
C08 N07 Port2 7.57e-13
L08 N07 Port2 3.75e-10
R08 N07 Port2 1.00e+05
.ENDS GCH2165C2A681JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCH2195C1H103JE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2195C1H103JE01 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.47e-11
R03 N02 N03 5.33e-03
L04 N03 N04 9.88e-11
R04 N03 N04 2.89e-01
L05 N04 N05 5.99e-11
R05 N04 N05 7.45e-03
C06 N05 N06 3.56e-08
L06 N05 N06 3.69e-11
R06 N05 N06 2.47e-01
C07 N06 N07 1.26e-08
L07 N06 N07 4.23e-11
R07 N06 N07 3.05e-01
C08 N07 N08 1.16e-07
L08 N07 N08 2.40e-12
R08 N07 N08 2.53e-02
C09 N08 N09 1.22e-08
L09 N08 N09 1.38e-11
R09 N08 N09 1.01e-01
C10 N09 N10 3.44e-11
L10 N09 N10 1.00e-11
R10 N09 N10 1.16e+00
C11 N10 Port2 9.78e-13
L11 N10 Port2 2.63e-10
R11 N10 Port2 1.00e+05
.ENDS GCH2195C1H103JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCH2195C1H153JE01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2195C1H153JE01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 6.67e+10
L02 N01 N02 7.59e-11
R03 N02 N03 5.00e-03
L04 N03 N04 1.20e-10
R04 N03 N04 2.44e-01
L05 N04 N05 7.16e-11
R05 N04 N05 5.09e-03
C06 N05 N06 3.89e-08
L06 N05 N06 4.81e-11
R06 N05 N06 2.42e-01
C07 N06 N07 2.29e-08
L07 N06 N07 3.60e-11
R07 N06 N07 2.69e-01
C08 N07 N08 1.47e-07
L08 N07 N08 2.74e-12
R08 N07 N08 4.32e-02
C09 N08 N09 3.21e-08
L09 N08 N09 7.97e-12
R09 N08 N09 7.21e-02
C10 N09 N10 1.09e-11
L10 N09 N10 3.12e-11
R10 N09 N10 6.29e+00
C11 N10 Port2 1.54e-12
L11 N10 Port2 1.62e-10
R11 N10 Port2 1.00e+05
.ENDS GCH2195C1H153JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCH2195C1H682JE01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH2195C1H682JE01 Port1 Port2
C01 Port1 N01 6.69e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.59e-11
R03 N02 N03 5.74e-03
L04 N03 N04 8.04e-11
R04 N03 N04 2.53e-01
L05 N04 N05 8.57e-11
R05 N04 N05 1.07e-02
C06 N05 N06 3.89e-08
L06 N05 N06 2.00e-11
R06 N05 N06 2.08e-01
C07 N06 N07 8.38e-09
L07 N06 N07 3.58e-11
R07 N06 N07 3.24e-01
C08 N07 N08 1.53e-07
L08 N07 N08 9.43e-13
R08 N07 N08 9.43e-03
C09 N08 N09 1.32e-08
L09 N08 N09 6.54e-12
R09 N08 N09 8.62e-02
C10 N09 Port2 7.13e-13
L10 N09 Port2 3.99e-10
R10 N09 Port2 9.87e+02
.ENDS GCH2195C1H682JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCH219R71C105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH219R71C105KE01 Port1 Port2
C01 Port1 N01 9.57e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.71e-10
R03 N02 N03 5.26e-03
C04 N03 N04 1.19e-04
R04 N03 N04 3.62e+01
C05 N04 N05 1.44e-04
R05 N04 N05 5.09e+00
C06 N05 N06 1.34e-04
R06 N05 N06 9.26e-01
C07 N06 N07 1.19e-04
R07 N06 N07 1.41e-01
C08 N07 N08 1.24e-04
R08 N07 N08 2.09e-02
C09 N08 N09 8.50e-05
R09 N08 N09 6.10e-03
L10 N09 N10 2.45e-11
R10 N09 N10 1.03e-01
L11 N10 N11 1.77e-10
R11 N10 N11 4.10e-02
C12 N11 N12 3.94e-06
L12 N11 N12 3.60e-11
R12 N11 N12 1.27e-02
C13 N12 N13 1.12e-06
L13 N12 N13 6.01e-11
R13 N12 N13 1.81e-02
C14 N13 N14 2.56e-11
L14 N13 N14 2.39e-11
R14 N13 N14 3.91e+00
C15 N14 Port2 3.55e-12
L15 N14 Port2 8.54e-11
R15 N14 Port2 1.20e+01
.ENDS GCH219R71C105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCH219R71E474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH219R71E474KE01 Port1 Port2
C01 Port1 N01 4.52e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.10e-10
R03 N02 N03 7.84e-03
C04 N03 N04 3.89e-05
R04 N03 N04 1.46e-01
C05 N04 N05 3.97e-05
R05 N04 N05 2.12e-02
C06 N05 N06 6.49e-05
R06 N05 N06 2.36e-03
L07 N06 N07 1.74e-11
R07 N06 N07 5.26e-02
L08 N07 N08 1.39e-10
R08 N07 N08 4.48e-02
C09 N08 N09 2.45e-06
L09 N08 N09 2.28e-11
R09 N08 N09 1.08e-02
C10 N09 N10 4.85e-07
L10 N09 N10 4.98e-11
R10 N09 N10 1.93e-02
C11 N10 N11 1.19e-11
L11 N10 N11 7.05e-11
R11 N10 N11 9.87e+00
C12 N11 Port2 2.19e-12
L12 N11 Port2 1.64e-10
R12 N11 Port2 3.03e+01
.ENDS GCH219R71E474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCH21B5C1H223JE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21B5C1H223JE01 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+10
L02 N01 N02 6.17e-11
R03 N02 N03 3.28e-03
L04 N03 N04 1.25e-10
R04 N03 N04 2.03e-01
L05 N04 N05 7.39e-11
R05 N04 N05 5.06e-03
C06 N05 N06 5.98e-08
L06 N05 N06 5.67e-11
R06 N05 N06 2.80e-01
C07 N06 N07 2.98e-08
L07 N06 N07 4.96e-11
R07 N06 N07 2.37e-01
C08 N07 N08 7.48e-08
L08 N07 N08 1.02e-11
R08 N07 N08 6.61e-02
C09 N08 N09 4.79e-08
L09 N08 N09 9.99e-12
R09 N08 N09 8.13e-02
C10 N09 N10 2.85e-12
L10 N09 N10 1.05e-10
R10 N09 N10 4.56e+01
C11 N10 Port2 2.23e-12
L11 N10 Port2 1.31e-10
R11 N10 Port2 1.00e+05
.ENDS GCH21B5C1H223JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCH21BC71E475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BC71E475KE11 Port1 Port2
C01 Port1 N01 3.72e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.28e-10
R03 N02 N03 3.66e-03
C04 N03 N04 4.36e-04
R04 N03 N04 1.02e+01
C05 N04 N05 2.02e-04
R05 N04 N05 5.59e+00
C06 N05 N06 1.87e-04
R06 N05 N06 6.07e-01
C07 N06 N07 1.58e-04
R07 N06 N07 7.39e-02
C08 N07 N08 1.03e-04
R08 N07 N08 1.23e-02
L09 N08 N09 1.20e-11
R09 N08 N09 8.87e-02
L10 N09 N10 3.74e-11
R10 N09 N10 3.00e-02
L11 N10 N11 2.67e-10
R11 N10 N11 2.15e-02
C12 N11 N12 9.96e-06
L12 N11 N12 6.46e-11
R12 N11 N12 1.10e-02
C13 N12 N13 7.93e-06
L13 N12 N13 3.71e-11
R13 N12 N13 8.44e-03
C14 N13 N14 1.05e-11
L14 N13 N14 4.68e-11
R14 N13 N14 5.70e+00
C15 N14 Port2 3.14e-14
L15 N14 Port2 8.58e-11
R15 N14 Port2 2.71e+03
.ENDS GCH21BC71E475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCH21BC72A105KE11
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BC72A105KE11 Port1 Port2
C01 Port1 N01 9.83e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.56e-10
R03 N02 N03 5.49e-03
C04 N03 N04 7.73e-05
R04 N03 N04 2.08e+01
C05 N04 N05 1.08e-04
R05 N04 N05 2.17e+00
C06 N05 N06 8.49e-05
R06 N05 N06 3.12e-01
C07 N06 N07 8.11e-05
R07 N06 N07 3.59e-02
C08 N07 N08 5.20e-05
R08 N07 N08 7.44e-03
L09 N08 N09 2.57e-11
R09 N08 N09 4.55e-02
L10 N09 N10 2.38e-10
R10 N09 N10 4.09e-02
C11 N10 N11 2.90e-06
L11 N10 N11 5.69e-11
R11 N10 N11 1.61e-02
C12 N11 N12 1.74e-06
L12 N11 N12 4.49e-11
R12 N11 N12 1.34e-02
C13 N12 N13 3.11e-11
L13 N12 N13 3.39e-11
R13 N12 N13 4.47e+00
C14 N13 Port2 2.92e-12
L14 N13 Port2 9.18e-11
R14 N13 Port2 7.14e+00
.ENDS GCH21BC72A105KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GCH21BC7YA475KE11
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BC7YA475KE11 Port1 Port2
C01 Port1 N01 3.72e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.28e-10
R03 N02 N03 3.66e-03
C04 N03 N04 4.36e-04
R04 N03 N04 1.02e+01
C05 N04 N05 2.02e-04
R05 N04 N05 5.59e+00
C06 N05 N06 1.87e-04
R06 N05 N06 6.07e-01
C07 N06 N07 1.58e-04
R07 N06 N07 7.39e-02
C08 N07 N08 1.03e-04
R08 N07 N08 1.23e-02
L09 N08 N09 1.20e-11
R09 N08 N09 8.87e-02
L10 N09 N10 3.74e-11
R10 N09 N10 3.00e-02
L11 N10 N11 2.67e-10
R11 N10 N11 2.15e-02
C12 N11 N12 9.96e-06
L12 N11 N12 6.46e-11
R12 N11 N12 1.10e-02
C13 N12 N13 7.93e-06
L13 N12 N13 3.71e-11
R13 N12 N13 8.44e-03
C14 N13 N14 1.05e-11
L14 N13 N14 4.68e-11
R14 N13 N14 5.70e+00
C15 N14 Port2 3.14e-14
L15 N14 Port2 8.58e-11
R15 N14 Port2 2.71e+03
.ENDS GCH21BC7YA475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCH21BR71A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71A106KE01 Port1 Port2
C01 Port1 N01 6.48e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.66e-10
R03 N02 N03 3.30e-03
C04 N03 N04 2.02e-04
R04 N03 N04 2.14e+01
C05 N04 N05 3.09e-04
R05 N04 N05 1.83e+00
C06 N05 N06 3.01e-04
R06 N05 N06 3.76e-01
C07 N06 N07 3.36e-04
R07 N06 N07 7.72e-02
C08 N07 N08 2.37e-04
R08 N07 N08 2.78e-02
C09 N08 N09 1.50e-04
R09 N08 N09 7.28e-03
L10 N09 N10 1.36e-11
R10 N09 N10 7.73e-02
L11 N10 N11 3.79e-11
R11 N10 N11 2.73e-02
L12 N11 N12 2.97e-10
R12 N11 N12 1.79e-02
C13 N12 N13 2.20e-05
L13 N12 N13 5.09e-11
R13 N12 N13 4.23e-03
C14 N13 N14 1.10e-05
L14 N13 N14 5.17e-11
R14 N13 N14 4.53e-03
C15 N14 N15 1.76e-11
L15 N14 N15 4.46e-11
R15 N14 N15 6.75e+00
C16 N15 Port2 9.75e-12
L16 N15 Port2 3.60e-11
R16 N15 Port2 5.52e+00
.ENDS GCH21BR71A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GCH21BR71A225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71A225KE01 Port1 Port2
C01 Port1 N01 2.07e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 8.40e-11
R03 N02 N03 3.97e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.98e+01
C05 N04 N05 3.73e-04
R05 N04 N05 1.92e+00
C06 N05 N06 2.96e-04
R06 N05 N06 4.93e-01
C07 N06 N07 2.71e-04
R07 N06 N07 9.39e-02
C08 N07 N08 2.68e-04
R08 N07 N08 1.68e-02
C09 N08 N09 1.75e-04
R09 N08 N09 4.87e-03
L10 N09 N10 2.74e-11
R10 N09 N10 5.47e-02
L11 N10 N11 2.24e-10
R11 N10 N11 2.85e-02
C12 N11 N12 6.85e-06
L12 N11 N12 5.56e-11
R12 N11 N12 9.29e-03
C13 N12 N13 3.48e-06
L13 N12 N13 5.20e-11
R13 N12 N13 1.14e-02
C14 N13 N14 1.01e-11
L14 N13 N14 7.22e-11
R14 N13 N14 1.06e+01
C15 N14 Port2 2.16e-12
L15 N14 Port2 1.60e-10
R15 N14 Port2 2.85e+01
.ENDS GCH21BR71A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCH21BR71C225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71C225KE01 Port1 Port2
C01 Port1 N01 2.07e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 8.40e-11
R03 N02 N03 3.97e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.98e+01
C05 N04 N05 3.73e-04
R05 N04 N05 1.92e+00
C06 N05 N06 2.96e-04
R06 N05 N06 4.93e-01
C07 N06 N07 2.71e-04
R07 N06 N07 9.39e-02
C08 N07 N08 2.68e-04
R08 N07 N08 1.68e-02
C09 N08 N09 1.75e-04
R09 N08 N09 4.87e-03
L10 N09 N10 2.74e-11
R10 N09 N10 5.47e-02
L11 N10 N11 2.24e-10
R11 N10 N11 2.85e-02
C12 N11 N12 6.85e-06
L12 N11 N12 5.56e-11
R12 N11 N12 9.29e-03
C13 N12 N13 3.48e-06
L13 N12 N13 5.20e-11
R13 N12 N13 1.14e-02
C14 N13 N14 1.01e-11
L14 N13 N14 7.22e-11
R14 N13 N14 1.06e+01
C15 N14 Port2 2.16e-12
L15 N14 Port2 1.60e-10
R15 N14 Port2 2.85e+01
.ENDS GCH21BR71C225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCH21BR71E105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71E105KE01 Port1 Port2
C01 Port1 N01 9.92e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.97e-12
R03 N02 N03 4.95e-03
C04 N03 N04 1.48e-04
R04 N03 N04 2.79e+01
C05 N04 N05 2.13e-04
R05 N04 N05 2.67e+00
C06 N05 N06 1.35e-04
R06 N05 N06 6.52e-01
C07 N06 N07 1.21e-04
R07 N06 N07 9.61e-02
C08 N07 N08 1.30e-04
R08 N07 N08 1.49e-02
C09 N08 N09 1.11e-04
R09 N08 N09 4.00e-03
L10 N09 N10 1.42e-11
R10 N09 N10 4.86e-02
L11 N10 N11 2.01e-10
R11 N10 N11 3.97e-02
C12 N11 N12 2.98e-06
L12 N11 N12 5.78e-11
R12 N11 N12 1.67e-02
C13 N12 N13 1.50e-06
L13 N12 N13 5.35e-11
R13 N12 N13 1.76e-02
C14 N13 N14 2.97e-11
L14 N13 N14 3.44e-11
R14 N13 N14 6.28e+00
C15 N14 N15 4.18e-12
L15 N14 N15 7.31e-11
R15 N14 N15 1.00e+05
C16 N15 Port2 1.38e-12
L16 N15 Port2 2.19e-10
R16 N15 Port2 2.24e+01
.ENDS GCH21BR71E105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCH21BR71E224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71E224KE01 Port1 Port2
C01 Port1 N01 2.12e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.54e-10
R03 N02 N03 8.63e-03
C04 N03 N04 1.49e-05
R04 N03 N04 3.56e-01
C05 N04 N05 2.15e-05
R05 N04 N05 3.11e-02
C06 N05 N06 3.66e-05
R06 N05 N06 4.58e-03
L07 N06 N07 2.68e-11
R07 N06 N07 1.12e-01
L08 N07 N08 1.93e-10
R08 N07 N08 7.21e-02
C09 N08 N09 1.23e-06
L09 N08 N09 3.20e-11
R09 N08 N09 2.59e-02
C10 N09 N10 2.96e-07
L10 N09 N10 6.78e-11
R10 N09 N10 3.55e-02
C11 N10 N11 2.40e-11
L11 N10 N11 3.60e-11
R11 N10 N11 3.70e+00
C12 N11 Port2 3.44e-12
L12 N11 Port2 9.56e-11
R12 N11 Port2 1.16e+01
.ENDS GCH21BR71E224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCH21BR71H104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71H104KE01 Port1 Port2
C01 Port1 N01 9.99e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.68e-10
R03 N02 N03 1.50e-02
C04 N03 N04 1.05e-05
R04 N03 N04 8.46e-01
C05 N04 N05 4.07e-05
R05 N04 N05 2.68e-01
C06 N05 N06 8.37e-06
R06 N05 N06 1.75e-01
C07 N06 N07 6.83e-06
R07 N06 N07 2.60e-02
C08 N07 N08 1.67e-05
R08 N07 N08 1.57e-03
L09 N08 N09 1.07e-10
R09 N08 N09 8.48e-02
L10 N09 N10 1.24e-11
R10 N09 N10 6.15e-02
C11 N10 N11 4.33e-07
L11 N10 N11 3.43e-11
R11 N10 N11 3.68e-02
C12 N11 N12 9.55e-08
L12 N11 N12 6.46e-11
R12 N11 N12 4.77e-02
C13 N12 N13 8.92e-12
L13 N12 N13 8.71e-11
R13 N12 N13 9.68e+00
C14 N13 Port2 3.01e-12
L14 N13 Port2 1.23e-10
R14 N13 Port2 2.06e+01
.ENDS GCH21BR71H104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCH21BR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71H105KE01 Port1 Port2
C01 Port1 N01 9.39e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.89e-10
R03 N02 N03 4.20e-03
C04 N03 N04 2.65e-04
R04 N03 N04 1.50e+01
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.76e-04
R06 N05 N06 4.58e-01
C07 N06 N07 1.89e-04
R07 N06 N07 9.91e-02
C08 N07 N08 1.52e-04
R08 N07 N08 1.58e-02
C09 N08 N09 3.22e-04
R09 N08 N09 1.94e-03
L10 N09 N10 2.38e-11
R10 N09 N10 7.83e-02
L11 N10 N11 2.31e-10
R11 N10 N11 3.87e-02
C12 N11 N12 3.52e-06
L12 N11 N12 4.72e-11
R12 N11 N12 1.52e-02
C13 N12 N13 2.26e-06
L13 N12 N13 3.52e-11
R13 N12 N13 1.51e-02
C14 N13 N14 1.80e-11
L14 N13 N14 6.17e-11
R14 N13 N14 6.01e+00
C15 N14 Port2 1.36e-11
L15 N14 Port2 2.94e-11
R15 N14 Port2 2.95e+00
.ENDS GCH21BR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCH21BR71H224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71H224KE01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.16e-10
R03 N02 N03 8.05e-03
C04 N03 N04 2.00e-05
R04 N03 N04 2.65e-01
C05 N04 N05 2.12e-05
R05 N04 N05 3.96e-02
C06 N05 N06 1.68e-05
R06 N05 N06 6.32e-03
L07 N06 N07 1.87e-11
R07 N06 N07 6.16e-02
L08 N07 N08 1.68e-10
R08 N07 N08 5.69e-02
C09 N08 N09 7.62e-07
L09 N08 N09 4.29e-11
R09 N08 N09 3.48e-02
C10 N09 N10 3.92e-07
L10 N09 N10 3.81e-11
R10 N09 N10 3.01e-02
C11 N10 N11 1.86e-11
L11 N10 N11 4.46e-11
R11 N10 N11 5.99e+00
C12 N11 Port2 2.02e-12
L12 N11 Port2 1.52e-10
R12 N11 Port2 2.25e+01
.ENDS GCH21BR71H224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCH21BR71H473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71H473KE01 Port1 Port2
C01 Port1 N01 4.65e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.39e-10
R03 N02 N03 2.09e-02
C04 N03 N04 3.10e-06
R04 N03 N04 1.71e+00
C05 N04 N05 4.64e-06
R05 N04 N05 1.81e-01
C06 N05 N06 4.51e-06
R06 N05 N06 4.27e-02
C07 N06 N07 3.21e-06
R07 N06 N07 1.31e-02
L08 N07 N08 1.07e-10
R08 N07 N08 1.29e-01
C09 N08 N09 1.73e-07
L09 N08 N09 4.21e-11
R09 N08 N09 6.14e-02
C10 N09 N10 4.38e-08
L10 N09 N10 4.53e-11
R10 N09 N10 5.28e-02
C11 N10 N11 1.33e-11
L11 N10 N11 8.15e-11
R11 N10 N11 7.19e+00
C12 N11 Port2 2.45e-12
L12 N11 Port2 1.42e-10
R12 N11 Port2 2.70e+01
.ENDS GCH21BR71H473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GCH21BR71H474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71H474KE01 Port1 Port2
C01 Port1 N01 4.33e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.15e-10
R03 N02 N03 6.15e-03
C04 N03 N04 3.84e-05
R04 N03 N04 1.38e-01
C05 N04 N05 4.10e-05
R05 N04 N05 1.29e-02
C06 N05 N06 1.45e-04
R06 N05 N06 1.21e-02
C07 N06 N07 2.43e-05
R07 N06 N07 2.34e-03
L08 N07 N08 1.56e-10
R08 N07 N08 4.49e-02
L09 N08 N09 9.59e-12
R09 N08 N09 2.89e-02
C10 N09 N10 1.51e-06
L10 N09 N10 4.49e-11
R10 N09 N10 2.11e-02
C11 N10 N11 6.88e-07
L11 N10 N11 4.23e-11
R11 N10 N11 2.10e-02
C12 N11 N12 1.19e-11
L12 N11 N12 8.40e-11
R12 N11 N12 8.97e+00
C13 N12 Port2 1.69e-12
L13 N12 Port2 2.00e-10
R13 N12 Port2 3.77e+01
.ENDS GCH21BR71H474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCH21BR72A103KE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR72A103KE01 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.30e-10
R03 N02 N03 5.25e-02
C04 N03 N04 4.51e-07
R04 N03 N04 1.18e+01
C05 N04 N05 9.42e-07
R05 N04 N05 8.93e-01
C06 N05 N06 6.06e-07
R06 N05 N06 2.36e-01
C07 N06 N07 3.80e-07
R07 N06 N07 4.42e-02
L08 N07 N08 9.99e-11
R08 N07 N08 2.20e-01
C09 N08 N09 4.43e-08
L09 N08 N09 3.09e-11
R09 N08 N09 1.16e-01
C10 N09 N10 1.26e-08
L10 N09 N10 3.40e-11
R10 N09 N10 1.07e-01
C11 N10 N11 1.23e-11
L11 N10 N11 8.38e-11
R11 N10 N11 6.69e+00
C12 N11 Port2 2.23e-12
L12 N11 Port2 1.54e-10
R12 N11 Port2 2.75e+01
.ENDS GCH21BR72A103KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCH21BR72A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR72A104KE01 Port1 Port2
C01 Port1 N01 9.99e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 1.68e-10
R03 N02 N03 1.50e-02
C04 N03 N04 1.05e-05
R04 N03 N04 8.46e-01
C05 N04 N05 4.07e-05
R05 N04 N05 2.68e-01
C06 N05 N06 8.37e-06
R06 N05 N06 1.75e-01
C07 N06 N07 6.83e-06
R07 N06 N07 2.60e-02
C08 N07 N08 1.67e-05
R08 N07 N08 1.57e-03
L09 N08 N09 1.07e-10
R09 N08 N09 8.48e-02
L10 N09 N10 1.24e-11
R10 N09 N10 6.15e-02
C11 N10 N11 4.33e-07
L11 N10 N11 3.43e-11
R11 N10 N11 3.68e-02
C12 N11 N12 9.55e-08
L12 N11 N12 6.46e-11
R12 N11 N12 4.77e-02
C13 N12 N13 8.92e-12
L13 N12 N13 8.71e-11
R13 N12 N13 9.68e+00
C14 N13 Port2 3.01e-12
L14 N13 Port2 1.23e-10
R14 N13 Port2 2.06e+01
.ENDS GCH21BR72A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCH21BR72A223KE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR72A223KE01 Port1 Port2
C01 Port1 N01 2.13e-08
R01 Port1 N01 2.27e+09
L02 N01 N02 8.03e-11
R03 N02 N03 3.54e-02
C04 N03 N04 1.16e-06
R04 N03 N04 4.57e+00
C05 N04 N05 2.03e-06
R05 N04 N05 3.29e-01
C06 N05 N06 1.59e-06
R06 N05 N06 8.60e-02
C07 N06 N07 1.29e-06
R07 N06 N07 1.64e-02
L08 N07 N08 9.74e-11
R08 N07 N08 1.53e-01
C09 N08 N09 9.72e-08
L09 N08 N09 2.71e-11
R09 N08 N09 5.15e-02
C10 N09 N10 2.72e-08
L10 N09 N10 3.98e-11
R10 N09 N10 7.80e-02
C11 N10 N11 1.31e-11
L11 N10 N11 1.17e-10
R11 N10 N11 9.01e+00
C12 N11 Port2 1.86e-12
L12 N11 Port2 2.22e-10
R12 N11 Port2 3.01e+01
.ENDS GCH21BR72A223KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCH21BR72A473KE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR72A473KE01 Port1 Port2
C01 Port1 N01 4.65e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.39e-10
R03 N02 N03 2.09e-02
C04 N03 N04 3.10e-06
R04 N03 N04 1.71e+00
C05 N04 N05 4.64e-06
R05 N04 N05 1.81e-01
C06 N05 N06 4.51e-06
R06 N05 N06 4.27e-02
C07 N06 N07 3.21e-06
R07 N06 N07 1.31e-02
L08 N07 N08 1.07e-10
R08 N07 N08 1.29e-01
C09 N08 N09 1.73e-07
L09 N08 N09 4.21e-11
R09 N08 N09 6.14e-02
C10 N09 N10 4.38e-08
L10 N09 N10 4.53e-11
R10 N09 N10 5.28e-02
C11 N10 N11 1.33e-11
L11 N10 N11 8.15e-11
R11 N10 N11 7.19e+00
C12 N11 Port2 2.45e-12
L12 N11 Port2 1.42e-10
R12 N11 Port2 2.70e+01
.ENDS GCH21BR72A473KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GCH21BR7YA105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR7YA105KE01 Port1 Port2
C01 Port1 N01 9.97e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 6.98e-11
R03 N02 N03 4.20e-03
C04 N03 N04 1.60e-04
R04 N03 N04 2.41e+01
C05 N04 N05 2.42e-04
R05 N04 N05 2.19e+00
C06 N05 N06 2.01e-04
R06 N05 N06 3.41e-01
C07 N06 N07 1.85e-04
R07 N06 N07 5.58e-02
C08 N07 N08 2.20e-04
R08 N07 N08 7.63e-03
C09 N08 N09 2.05e-04
R09 N08 N09 2.46e-03
L10 N09 N10 2.05e-11
R10 N09 N10 5.51e-02
L11 N10 N11 2.12e-10
R11 N10 N11 3.66e-02
C12 N11 N12 3.69e-06
L12 N11 N12 4.84e-11
R12 N11 N12 1.81e-02
C13 N12 N13 1.91e-06
L13 N12 N13 4.43e-11
R13 N12 N13 1.67e-02
C14 N13 N14 1.95e-11
L14 N13 N14 4.86e-11
R14 N13 N14 4.87e+00
C15 N14 N15 3.84e-12
L15 N14 N15 8.61e-11
R15 N14 N15 1.40e+01
C16 N15 Port2 3.52e-12
L16 N15 Port2 7.06e-11
R16 N15 Port2 1.00e+05
.ENDS GCH21BR7YA105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCH3195C1H103JE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H103JE01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 7.51e-03
L04 N03 N04 1.33e-10
R04 N03 N04 3.09e-01
L05 N04 N05 1.09e-10
R05 N04 N05 1.08e-02
C06 N05 N06 5.16e-08
L06 N05 N06 3.76e-11
R06 N05 N06 2.12e-01
C07 N06 N07 1.36e-08
L07 N06 N07 5.17e-11
R07 N06 N07 3.22e-01
C08 N07 N08 7.28e-08
L08 N07 N08 4.82e-12
R08 N07 N08 4.16e-02
C09 N08 N09 2.21e-08
L09 N08 N09 8.83e-12
R09 N08 N09 1.02e-01
C10 N09 Port2 1.22e-12
L10 N09 Port2 4.41e-10
R10 N09 Port2 7.52e+02
.ENDS GCH3195C1H103JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCH3195C1H153JE01
* Property : C = 1.50e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H153JE01 Port1 Port2
C01 Port1 N01 1.47e-08
R01 Port1 N01 6.67e+10
L02 N01 N02 5.00e-12
R03 N02 N03 8.40e-03
L04 N03 N04 1.26e-10
R04 N03 N04 2.39e-01
L05 N04 N05 1.13e-10
R05 N04 N05 5.45e-03
C06 N05 N06 5.81e-08
L06 N05 N06 3.48e-11
R06 N05 N06 1.33e-01
C07 N06 N07 1.61e-08
L07 N06 N07 4.67e-11
R07 N06 N07 2.35e-01
C08 N07 N08 8.83e-08
L08 N07 N08 2.30e-12
R08 N07 N08 2.55e-02
C09 N08 N09 9.44e-13
L09 N08 N09 5.63e-10
R09 N08 N09 1.86e+03
C10 N09 Port2 1.08e-11
L10 N09 Port2 2.90e-11
R10 N09 Port2 1.47e+01
.ENDS GCH3195C1H153JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCH3195C1H223JE01
* Property : C = 2.20e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H223JE01 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+10
L02 N01 N02 1.96e-10
R03 N02 N03 6.30e-03
L04 N03 N04 7.70e-11
R04 N03 N04 3.11e-01
L05 N04 N05 1.04e-10
R05 N04 N05 6.19e-03
C06 N05 N06 6.88e-08
L06 N05 N06 5.16e-11
R06 N05 N06 2.42e-01
C07 N06 N07 4.17e-08
L07 N06 N07 3.34e-11
R07 N06 N07 2.44e-01
C08 N07 N08 6.05e-09
L08 N07 N08 7.26e-11
R08 N07 N08 1.16e-01
C09 N08 Port2 1.43e-12
L09 N08 Port2 2.83e-10
R09 N08 Port2 4.95e+02
.ENDS GCH3195C1H223JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCH3195C1H333JE01
* Property : C = 3.30e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H333JE01 Port1 Port2
C01 Port1 N01 3.30e-08
R01 Port1 N01 3.03e+10
L02 N01 N02 1.14e-13
R03 N02 N03 5.02e-03
L04 N03 N04 1.55e-10
R04 N03 N04 2.07e-01
L05 N04 N05 1.59e-10
R05 N04 N05 9.13e-04
C06 N05 N06 7.59e-08
L06 N05 N06 7.12e-11
R06 N05 N06 1.75e-01
C07 N06 N07 5.05e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.17e-01
C08 N07 N08 6.71e-08
L08 N07 N08 1.59e-11
R08 N07 N08 3.65e-02
C09 N08 N09 7.49e-08
L09 N08 N09 9.07e-12
R09 N08 N09 4.37e-02
C10 N09 Port2 8.82e-13
L10 N09 Port2 4.48e-10
R10 N09 Port2 1.25e+03
.ENDS GCH3195C1H333JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCH3195C1H472JE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H472JE01 Port1 Port2
C01 Port1 N01 4.73e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 5.07e-11
R03 N02 N03 8.06e-03
L04 N03 N04 1.37e-10
R04 N03 N04 3.75e-01
L05 N04 N05 8.83e-11
R05 N04 N05 1.00e-02
C06 N05 N06 2.53e-08
L06 N05 N06 3.63e-11
R06 N05 N06 2.74e-01
C07 N06 N07 6.72e-09
L07 N06 N07 4.62e-11
R07 N06 N07 4.60e-01
C08 N07 N08 8.36e-09
L08 N07 N08 1.12e-11
R08 N07 N08 1.24e-01
C09 N08 N09 1.13e-12
L09 N08 N09 5.04e-10
R09 N08 N09 4.70e+02
C10 N09 Port2 6.88e-13
L10 N09 Port2 4.54e-12
R10 N09 Port2 1.26e+05
.ENDS GCH3195C1H472JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCH3195C1H682JE01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C1H682JE01 Port1 Port2
C01 Port1 N01 6.65e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 2.00e-11
R03 N02 N03 1.00e-02
L04 N03 N04 1.14e-10
R04 N03 N04 3.63e-01
L05 N04 N05 1.22e-10
R05 N04 N05 1.64e-02
C06 N05 N06 3.62e-08
L06 N05 N06 3.30e-11
R06 N05 N06 1.83e-01
C07 N06 N07 8.82e-09
L07 N06 N07 4.25e-11
R07 N06 N07 3.16e-01
C08 N07 Port2 8.08e-13
L08 N07 Port2 6.45e-10
R08 N07 Port2 1.35e+03
.ENDS GCH3195C1H682JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCH3195C2A103JE01
* Property : C = 1.00e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C2A103JE01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+11
L02 N01 N02 1.07e-10
R03 N02 N03 7.51e-03
L04 N03 N04 1.33e-10
R04 N03 N04 3.09e-01
L05 N04 N05 1.09e-10
R05 N04 N05 1.08e-02
C06 N05 N06 5.16e-08
L06 N05 N06 3.76e-11
R06 N05 N06 2.12e-01
C07 N06 N07 1.36e-08
L07 N06 N07 5.17e-11
R07 N06 N07 3.22e-01
C08 N07 N08 7.28e-08
L08 N07 N08 4.82e-12
R08 N07 N08 4.16e-02
C09 N08 N09 2.21e-08
L09 N08 N09 8.83e-12
R09 N08 N09 1.02e-01
C10 N09 Port2 1.22e-12
L10 N09 Port2 4.41e-10
R10 N09 Port2 7.52e+02
.ENDS GCH3195C2A103JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCH3195C2A222JE01
* Property : C = 2.20e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C2A222JE01 Port1 Port2
C01 Port1 N01 2.21e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 5.01e-11
R03 N02 N03 1.17e-02
L04 N03 N04 9.78e-11
R04 N03 N04 5.27e-01
L05 N04 N05 9.50e-11
R05 N04 N05 2.49e-02
C06 N05 N06 1.17e-08
L06 N05 N06 2.06e-11
R06 N05 N06 2.49e-01
C07 N06 N07 2.56e-09
L07 N06 N07 3.18e-11
R07 N06 N07 4.31e-01
C08 N07 Port2 9.94e-13
L08 N07 Port2 5.98e-10
R08 N07 Port2 1.54e+03
.ENDS GCH3195C2A222JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCH3195C2A332JE01
* Property : C = 3.30e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C2A332JE01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.00e-10
R03 N02 N03 9.68e-03
L04 N03 N04 1.36e-10
R04 N03 N04 4.26e-01
L05 N04 N05 8.39e-11
R05 N04 N05 1.21e-02
C06 N05 N06 1.57e-08
L06 N05 N06 3.80e-11
R06 N05 N06 4.20e-01
C07 N06 N07 4.38e-09
L07 N06 N07 4.82e-11
R07 N06 N07 5.97e-01
C08 N07 N08 6.79e-08
L08 N07 N08 1.66e-12
R08 N07 N08 6.23e-02
C09 N08 N09 6.88e-09
L09 N08 N09 8.73e-12
R09 N08 N09 1.56e-01
C10 N09 Port2 1.24e-12
L10 N09 Port2 4.21e-10
R10 N09 Port2 3.71e+02
.ENDS GCH3195C2A332JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCH3195C2A472JE01
* Property : C = 4.70e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C2A472JE01 Port1 Port2
C01 Port1 N01 4.73e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 5.07e-11
R03 N02 N03 8.06e-03
L04 N03 N04 1.37e-10
R04 N03 N04 3.75e-01
L05 N04 N05 8.83e-11
R05 N04 N05 1.00e-02
C06 N05 N06 2.53e-08
L06 N05 N06 3.63e-11
R06 N05 N06 2.74e-01
C07 N06 N07 6.72e-09
L07 N06 N07 4.62e-11
R07 N06 N07 4.60e-01
C08 N07 N08 8.36e-09
L08 N07 N08 1.12e-11
R08 N07 N08 1.24e-01
C09 N08 N09 1.13e-12
L09 N08 N09 5.04e-10
R09 N08 N09 4.70e+02
C10 N09 Port2 6.88e-13
L10 N09 Port2 4.54e-12
R10 N09 Port2 1.26e+05
.ENDS GCH3195C2A472JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCH3195C2A682JE01
* Property : C = 6.80e-03[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH3195C2A682JE01 Port1 Port2
C01 Port1 N01 6.70e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 7.94e-11
R03 N02 N03 8.53e-03
L04 N03 N04 1.16e-10
R04 N03 N04 3.64e-01
L05 N04 N05 9.66e-11
R05 N04 N05 1.57e-02
C06 N05 N06 3.97e-08
L06 N05 N06 2.94e-11
R06 N05 N06 1.55e-01
C07 N06 N07 7.50e-09
L07 N06 N07 5.40e-11
R07 N06 N07 3.00e-01
C08 N07 N08 1.37e-08
L08 N07 N08 8.06e-12
R08 N07 N08 8.65e-02
C09 N08 Port2 1.16e-12
L09 N08 Port2 5.56e-10
R09 N08 Port2 1.21e+03
.ENDS GCH3195C2A682JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCH319R72A104KE01
* Property : C = 1.00e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH319R72A104KE01 Port1 Port2
C01 Port1 N01 1.01e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.71e-10
R03 N02 N03 2.78e-02
C04 N03 N04 7.88e-06
R04 N03 N04 8.48e-01
C05 N04 N05 2.82e-05
R05 N04 N05 8.88e-02
C06 N05 N06 1.15e-05
R06 N05 N06 5.80e-02
C07 N06 N07 7.11e-06
R07 N06 N07 1.71e-02
L08 N07 N08 9.59e-11
R08 N07 N08 1.29e-01
C09 N08 N09 3.17e-07
L09 N08 N09 2.99e-11
R09 N08 N09 1.36e-02
C10 N09 N10 4.75e-08
L10 N09 N10 5.41e-11
R10 N09 N10 3.40e-02
C11 N10 N11 1.25e-11
L11 N10 N11 1.24e-10
R11 N10 N11 1.15e+01
C12 N11 Port2 1.74e-12
L12 N11 Port2 3.48e-10
R12 N11 Port2 6.52e+01
.ENDS GCH319R72A104KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCH31CR71A106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31CR71A106KE01 Port1 Port2
C01 Port1 N01 9.96e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.33e-11
R03 N02 N03 2.54e-03
C04 N03 N04 2.13e-03
R04 N03 N04 1.98e+00
C05 N04 N05 1.75e-03
R05 N04 N05 4.80e-01
C06 N05 N06 1.17e-03
R06 N05 N06 1.14e-01
C07 N06 N07 1.44e-03
R07 N06 N07 1.17e-02
C08 N07 N08 1.30e-03
R08 N07 N08 2.58e-03
L09 N08 N09 2.99e-11
R09 N08 N09 7.37e-02
L10 N09 N10 5.45e-11
R10 N09 N10 2.43e-02
L11 N10 N11 4.40e-10
R11 N10 N11 1.86e-02
C12 N11 N12 3.02e-05
L12 N11 N12 1.11e-10
R12 N11 N12 5.65e-03
C13 N12 N13 1.57e-05
L13 N12 N13 1.00e-10
R13 N12 N13 5.96e-03
C14 N13 N14 2.67e-11
L14 N13 N14 4.29e-11
R14 N13 N14 3.14e+00
C15 N14 Port2 1.41e-12
L15 N14 Port2 2.75e-10
R15 N14 Port2 1.25e+02
.ENDS GCH31CR71A106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCH31CR71C475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31CR71C475KE01 Port1 Port2
C01 Port1 N01 4.64e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 4.53e-11
R03 N02 N03 3.18e-03
C04 N03 N04 6.88e-04
R04 N03 N04 6.12e+00
C05 N04 N05 8.71e-04
R05 N04 N05 7.85e-01
C06 N05 N06 5.99e-04
R06 N05 N06 1.89e-01
C07 N06 N07 6.18e-04
R07 N06 N07 2.53e-02
C08 N07 N08 4.80e-04
R08 N07 N08 4.30e-03
L09 N08 N09 4.68e-11
R09 N08 N09 4.86e-02
L10 N09 N10 3.77e-10
R10 N09 N10 2.52e-02
C11 N10 N11 1.59e-05
L11 N10 N11 8.84e-11
R11 N10 N11 8.99e-03
C12 N11 N12 6.97e-06
L12 N11 N12 9.14e-11
R12 N11 N12 1.04e-02
C13 N12 N13 2.13e-11
L13 N12 N13 7.00e-11
R13 N12 N13 4.67e+00
C14 N13 Port2 1.40e-12
L14 N13 Port2 3.23e-10
R14 N13 Port2 1.27e+02
.ENDS GCH31CR71C475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCH31CR71E475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31CR71E475KE01 Port1 Port2
C01 Port1 N01 4.64e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 4.53e-11
R03 N02 N03 3.18e-03
C04 N03 N04 6.88e-04
R04 N03 N04 6.12e+00
C05 N04 N05 8.71e-04
R05 N04 N05 7.85e-01
C06 N05 N06 5.99e-04
R06 N05 N06 1.89e-01
C07 N06 N07 6.18e-04
R07 N06 N07 2.53e-02
C08 N07 N08 4.80e-04
R08 N07 N08 4.30e-03
L09 N08 N09 4.68e-11
R09 N08 N09 4.86e-02
L10 N09 N10 3.77e-10
R10 N09 N10 2.52e-02
C11 N10 N11 1.59e-05
L11 N10 N11 8.84e-11
R11 N10 N11 8.99e-03
C12 N11 N12 6.97e-06
L12 N11 N12 9.14e-11
R12 N11 N12 1.04e-02
C13 N12 N13 2.13e-11
L13 N12 N13 7.00e-11
R13 N12 N13 4.67e+00
C14 N13 Port2 1.40e-12
L14 N13 Port2 3.23e-10
R14 N13 Port2 1.27e+02
.ENDS GCH31CR71E475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GCH31CR71H225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31CR71H225KE01 Port1 Port2
C01 Port1 N01 2.23e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.09e-11
R03 N02 N03 4.29e-03
C04 N03 N04 3.31e-04
R04 N03 N04 1.16e+01
C05 N04 N05 4.37e-04
R05 N04 N05 1.46e+00
C06 N05 N06 2.76e-04
R06 N05 N06 3.49e-01
C07 N06 N07 2.54e-04
R07 N06 N07 5.01e-02
C08 N07 N08 3.48e-04
R08 N07 N08 6.21e-03
C09 N08 N09 2.43e-04
R09 N08 N09 2.18e-03
L10 N09 N10 4.28e-11
R10 N09 N10 6.72e-02
L11 N10 N11 3.21e-10
R11 N10 N11 3.86e-02
C12 N11 N12 5.72e-06
L12 N11 N12 1.02e-10
R12 N11 N12 1.64e-02
C13 N12 N13 2.41e-06
L13 N12 N13 1.07e-10
R13 N12 N13 1.61e-02
C14 N13 N14 2.14e-11
L14 N13 N14 5.72e-11
R14 N13 N14 3.92e+00
C15 N14 Port2 1.50e-12
L15 N14 Port2 3.05e-10
R15 N14 Port2 1.18e+02
.ENDS GCH31CR71H225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCH31CR72A105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31CR72A105KE01 Port1 Port2
C01 Port1 N01 9.91e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.59e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.50e-04
R04 N03 N04 1.86e+01
C05 N04 N05 2.54e-04
R05 N04 N05 1.99e+00
C06 N05 N06 2.02e-04
R06 N05 N06 4.39e-01
C07 N06 N07 1.95e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.72e-04
R08 N07 N08 2.92e-02
C09 N08 N09 1.00e-04
R09 N08 N09 7.18e-03
L10 N09 N10 2.45e-10
R10 N09 N10 4.67e-02
C11 N10 N11 2.06e-06
L11 N10 N11 1.19e-10
R11 N10 N11 3.20e-02
C12 N11 N12 1.25e-06
L12 N11 N12 8.26e-11
R12 N11 N12 2.49e-02
C13 N12 N13 3.08e-10
L13 N12 N13 7.21e-11
R13 N12 N13 4.32e-01
C14 N13 Port2 2.60e-12
L14 N13 Port2 1.58e-10
R14 N13 Port2 6.05e+01
.ENDS GCH31CR72A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCH31M5C1H473JE01
* Property : C = 4.70e-02[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31M5C1H473JE01 Port1 Port2
C01 Port1 N01 4.70e-08
R01 Port1 N01 2.13e+10
L02 N01 N02 1.48e-11
R03 N02 N03 4.04e-03
L04 N03 N04 2.13e-10
R04 N03 N04 1.55e-01
L05 N04 N05 5.45e-11
R05 N04 N05 1.72e-03
C06 N05 N06 1.29e-07
L06 N05 N06 7.78e-11
R06 N05 N06 2.21e-01
C07 N06 N07 6.32e-08
L07 N06 N07 6.76e-11
R07 N06 N07 1.86e-01
C08 N07 N08 2.32e-07
L08 N07 N08 8.71e-12
R08 N07 N08 3.41e-02
C09 N08 N09 1.57e-07
L09 N08 N09 8.01e-12
R09 N08 N09 4.97e-02
C10 N09 Port2 1.11e-12
L10 N09 Port2 4.23e-10
R10 N09 Port2 6.40e+02
.ENDS GCH31M5C1H473JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCH31MR71E225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31MR71E225KE01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.89e-11
R03 N02 N03 4.79e-03
C04 N03 N04 3.25e-04
R04 N03 N04 1.30e+01
C05 N04 N05 5.29e-04
R05 N04 N05 1.55e+00
C06 N05 N06 3.30e-04
R06 N05 N06 4.64e-01
C07 N06 N07 3.16e-04
R07 N06 N07 8.42e-02
C08 N07 N08 2.95e-04
R08 N07 N08 1.60e-02
C09 N08 N09 2.07e-04
R09 N08 N09 3.44e-03
L10 N09 N10 3.87e-11
R10 N09 N10 6.08e-02
L11 N10 N11 2.82e-10
R11 N10 N11 3.77e-02
C12 N11 N12 6.87e-06
L12 N11 N12 7.68e-11
R12 N11 N12 1.16e-02
C13 N12 N13 2.25e-06
L13 N12 N13 1.02e-10
R13 N12 N13 1.57e-02
C14 N13 N14 2.14e-11
L14 N13 N14 6.57e-11
R14 N13 N14 5.31e+00
C15 N14 Port2 1.30e-12
L15 N14 Port2 3.49e-10
R15 N14 Port2 1.36e+02
.ENDS GCH31MR71E225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCH31MR71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31MR71H105KE01 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 3.45e-11
R03 N02 N03 7.05e-03
C04 N03 N04 1.25e-04
R04 N03 N04 2.56e+01
C05 N04 N05 2.00e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.55e-04
R06 N05 N06 6.68e-01
C07 N06 N07 1.26e-04
R07 N06 N07 1.33e-01
C08 N07 N08 1.37e-04
R08 N07 N08 2.12e-02
C09 N08 N09 8.56e-05
R09 N08 N09 6.44e-03
L10 N09 N10 5.60e-11
R10 N09 N10 1.51e-01
L11 N10 N11 1.98e-10
R11 N10 N11 4.28e-02
C12 N11 N12 3.45e-06
L12 N11 N12 5.73e-11
R12 N11 N12 1.15e-02
C13 N12 N13 1.07e-06
L13 N12 N13 7.34e-11
R13 N12 N13 1.61e-02
C14 N13 N14 1.94e-11
L14 N13 N14 8.34e-11
R14 N13 N14 6.83e+00
C15 N14 Port2 1.22e-12
L15 N14 Port2 3.95e-10
R15 N14 Port2 1.24e+02
.ENDS GCH31MR71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GCH31MR71H474KE01
* Property : C = 4.70e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31MR71H474KE01 Port1 Port2
C01 Port1 N01 4.58e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 7.52e-11
R03 N02 N03 8.52e-03
C04 N03 N04 5.76e-05
R04 N03 N04 1.16e-01
C05 N04 N05 4.30e-05
R05 N04 N05 2.46e-02
C06 N05 N06 7.39e-05
R06 N05 N06 2.85e-03
L07 N06 N07 2.47e-11
R07 N06 N07 6.65e-02
L08 N07 N08 1.89e-10
R08 N07 N08 5.94e-02
C09 N08 N09 1.73e-06
L09 N08 N09 4.89e-11
R09 N08 N09 1.84e-02
C10 N09 N10 4.58e-07
L10 N09 N10 7.98e-11
R10 N09 N10 2.90e-02
C11 N10 N11 2.70e-11
L11 N10 N11 7.00e-11
R11 N10 N11 5.35e+00
C12 N11 Port2 1.46e-12
L12 N11 Port2 3.22e-10
R12 N11 Port2 1.21e+02
.ENDS GCH31MR71H474KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GCH31MR72A224KE01
* Property : C = 2.20e-01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH31MR72A224KE01 Port1 Port2
C01 Port1 N01 2.18e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 1.06e-10
R03 N02 N03 1.20e-02
C04 N03 N04 1.78e-05
R04 N03 N04 4.73e-01
C05 N04 N05 2.18e-05
R05 N04 N05 4.86e-02
C06 N05 N06 3.04e-05
R06 N05 N06 7.15e-03
C07 N06 N07 1.01e-05
R07 N06 N07 5.28e-03
L08 N07 N08 2.39e-11
R08 N07 N08 8.95e-02
L09 N08 N09 2.27e-10
R09 N08 N09 7.91e-02
C10 N09 N10 1.11e-06
L10 N09 N10 3.45e-11
R10 N09 N10 2.06e-02
C11 N10 N11 2.80e-07
L11 N10 N11 5.76e-11
R11 N10 N11 2.65e-02
C12 N11 N12 1.40e-11
L12 N11 N12 9.49e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 1.64e-12
L13 N12 Port2 3.22e-10
R13 N12 Port2 8.84e+01
.ENDS GCH31MR72A224KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCH32DR71C106KE01
* Property : C = 1.00e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32DR71C106KE01 Port1 Port2
C01 Port1 N01 9.50e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 6.25e-11
R03 N02 N03 1.64e-03
C04 N03 N04 2.57e-03
R04 N03 N04 2.07e+00
C05 N04 N05 1.76e-03
R05 N04 N05 4.57e-01
C06 N05 N06 1.21e-03
R06 N05 N06 9.18e-02
C07 N06 N07 1.48e-03
R07 N06 N07 1.13e-02
C08 N07 N08 1.22e-03
R08 N07 N08 1.64e-03
L09 N08 N09 1.21e-11
R09 N08 N09 3.30e-02
L10 N09 N10 2.71e-11
R10 N09 N10 2.10e-02
L11 N10 N11 3.59e-10
R11 N10 N11 1.82e-02
C12 N11 N12 1.62e-05
L12 N11 N12 1.55e-10
R12 N11 N12 1.22e-02
C13 N12 N13 1.21e-05
L13 N12 N13 9.04e-11
R13 N12 N13 1.01e-02
C14 N13 N14 1.12e-11
L14 N13 N14 6.23e-11
R14 N13 N14 7.09e+00
C15 N14 Port2 1.63e-12
L15 N14 Port2 1.92e-10
R15 N14 Port2 9.76e+01
.ENDS GCH32DR71C106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCH32DR71E475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32DR71E475KE01 Port1 Port2
C01 Port1 N01 4.58e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.06e-10
R03 N02 N03 2.17e-03
C04 N03 N04 7.19e-04
R04 N03 N04 7.05e+00
C05 N04 N05 1.29e-03
R05 N04 N05 6.51e-01
C06 N05 N06 7.30e-04
R06 N05 N06 2.30e-01
C07 N06 N07 6.67e-04
R07 N06 N07 4.08e-02
C08 N07 N08 7.04e-04
R08 N07 N08 6.08e-03
C09 N08 N09 7.18e-04
R09 N08 N09 1.32e-03
L10 N09 N10 2.69e-11
R10 N09 N10 3.37e-02
L11 N10 N11 3.23e-10
R11 N10 N11 2.34e-02
C12 N11 N12 9.07e-06
L12 N11 N12 1.23e-10
R12 N11 N12 1.75e-02
C13 N12 N13 5.83e-06
L13 N12 N13 8.21e-11
R13 N12 N13 1.30e-02
C14 N13 N14 1.50e-11
L14 N13 N14 4.59e-11
R14 N13 N14 3.84e+00
C15 N14 Port2 2.21e-12
L15 N14 Port2 1.59e-10
R15 N14 Port2 4.64e+01
.ENDS GCH32DR71E475KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCH32DR72A225KE01
* Property : C = 2.20e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32DR72A225KE01 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 8.02e-11
R03 N02 N03 2.70e-03
C04 N03 N04 3.58e-04
R04 N03 N04 1.45e+01
C05 N04 N05 4.97e-04
R05 N04 N05 1.73e+00
C06 N05 N06 3.90e-04
R06 N05 N06 3.75e-01
C07 N06 N07 3.04e-04
R07 N06 N07 7.10e-02
C08 N07 N08 3.55e-04
R08 N07 N08 1.03e-02
C09 N08 N09 2.69e-04
R09 N08 N09 2.65e-03
L10 N09 N10 1.92e-10
R10 N09 N10 3.16e-02
L11 N10 N11 1.30e-11
R11 N10 N11 3.09e-02
C12 N11 N12 3.57e-06
L12 N11 N12 1.36e-10
R12 N11 N12 2.97e-02
C13 N12 N13 2.23e-06
L13 N12 N13 7.11e-11
R13 N12 N13 2.04e-02
C14 N13 N14 1.86e-11
L14 N13 N14 6.09e-11
R14 N13 N14 9.51e+00
C15 N14 Port2 2.00e-12
L15 N14 Port2 2.43e-10
R15 N14 Port2 6.13e+01
.ENDS GCH32DR72A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GCH32ER71A226KE01
* Property : C = 2.20e+01[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32ER71A226KE01 Port1 Port2
C01 Port1 N01 2.19e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.16e-11
R03 N02 N03 1.32e-03
C04 N03 N04 3.37e-03
R04 N03 N04 1.47e+00
C05 N04 N05 2.98e-03
R05 N04 N05 2.14e-01
C06 N05 N06 2.22e-03
R06 N05 N06 3.71e-02
C07 N06 N07 3.52e-03
R07 N06 N07 2.68e-03
C08 N07 N08 6.58e-03
R08 N07 N08 4.99e-04
L09 N08 N09 2.43e-11
R09 N08 N09 3.81e-02
L10 N09 N10 4.68e-10
R10 N09 N10 1.36e-02
L11 N10 N11 2.93e-11
R11 N10 N11 8.08e-03
C12 N11 N12 4.11e-05
L12 N11 N12 1.83e-10
R12 N11 N12 8.49e-03
C13 N12 N13 3.13e-05
L13 N12 N13 1.04e-10
R13 N12 N13 5.99e-03
C14 N13 N14 1.24e-11
L14 N13 N14 5.60e-11
R14 N13 N14 5.52e+00
C15 N14 Port2 1.54e-12
L15 N14 Port2 2.23e-10
R15 N14 Port2 1.48e+02
.ENDS GCH32ER71A226KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCH32ER71H105KE01
* Property : C = 1.00e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32ER71H105KE01 Port1 Port2
C01 Port1 N01 9.80e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.14e-10
R03 N02 N03 5.01e-03
C04 N03 N04 1.62e-04
R04 N03 N04 3.28e+01
C05 N04 N05 1.81e-04
R05 N04 N05 3.68e+00
C06 N05 N06 1.40e-04
R06 N05 N06 5.99e-01
C07 N06 N07 1.09e-04
R07 N06 N07 9.45e-02
C08 N07 N08 2.77e-04
R08 N07 N08 7.21e-03
C09 N08 N09 9.91e-05
R09 N08 N09 7.06e-03
L10 N09 N10 1.91e-10
R10 N09 N10 3.78e-02
C11 N10 N11 2.07e-06
L11 N10 N11 8.97e-11
R11 N10 N11 3.08e-02
C12 N11 N12 1.14e-06
L12 N11 N12 6.69e-11
R12 N11 N12 2.34e-02
C13 N12 N13 1.38e-11
L13 N12 N13 1.53e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 3.03e-12
L14 N13 Port2 2.44e-10
R14 N13 Port2 3.18e+01
.ENDS GCH32ER71H105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCH32ER71H475KE01
* Property : C = 4.70e+00[uF]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH32ER71H475KE01 Port1 Port2
C01 Port1 N01 4.64e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.64e-11
R03 N02 N03 2.12e-03
C04 N03 N04 6.48e-04
R04 N03 N04 6.50e+00
C05 N04 N05 1.10e-03
R05 N04 N05 6.79e-01
C06 N05 N06 6.86e-04
R06 N05 N06 2.50e-01
C07 N06 N07 6.43e-04
R07 N06 N07 4.30e-02
C08 N07 N08 7.76e-04
R08 N07 N08 6.38e-03
C09 N08 N09 5.46e-04
R09 N08 N09 1.88e-03
L10 N09 N10 2.31e-11
R10 N09 N10 3.86e-02
L11 N10 N11 3.20e-10
R11 N10 N11 2.50e-02
C12 N11 N12 8.60e-06
L12 N11 N12 1.41e-10
R12 N11 N12 2.06e-02
C13 N12 N13 5.81e-06
L13 N12 N13 8.93e-11
R13 N12 N13 1.44e-02
C14 N13 N14 1.82e-11
L14 N13 N14 5.30e-11
R14 N13 N14 4.85e+00
C15 N14 Port2 1.54e-12
L15 N14 Port2 2.54e-10
R15 N14 Port2 1.15e+02
.ENDS GCH32ER71H475KE01
