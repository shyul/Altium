*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03PN2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03PN2N2C02 port1 port2
C1 port1 port2 1.15e-13
L2 port1 1 2.21e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.50e+4
L4 port1 2 3.50e-8
R4 2 port2 100
L5 port1 3 1.60e-8
R5 3 port2 12.0
L6 port1 4 4.50e-8
R6 4 port2 900
.ENDS LQP03PN2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03PN2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03PN2N7C02 port1 port2
C1 port1 port2 1.81e-13
L2 port1 1 2.90e-9
R2 1 port2 7.00e-2
R3 port1 port2 1.80e+4
L4 port1 2 3.00e-8
R4 2 port2 65.0
L5 port1 3 1.90e-8
R5 3 port2 9.00
L6 port1 4 5.60e-8
R6 4 port2 1.00e+3
.ENDS LQP03PN2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03PN3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03PN3N3C02 port1 port2
C1 port1 port2 1.76e-13
L2 port1 1 3.86e-9
R2 1 port2 8.00e-2
R3 port1 port2 2.00e+4
L4 port1 2 3.40e-8
R4 2 port2 65.0
L5 port1 3 1.90e-8
R5 3 port2 5.00
L6 port1 4 6.30e-8
R6 4 port2 1.00e+3
.ENDS LQP03PN3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03PN3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03PN3N9C02 port1 port2
C1 port1 port2 2.23e-13
L2 port1 1 4.90e-9
R2 1 port2 8.00e-2
R3 port1 port2 2.00e+4
L4 port1 2 3.50e-8
R4 2 port2 55.0
L5 port1 3 1.90e-8
R5 3 port2 3.50
L6 port1 4 8.00e-8
R6 4 port2 1.00e+3
.ENDS LQP03PN3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03PN4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03PN4N7J02 port1 port2
C1 port1 port2 2.16e-13
L2 port1 1 6.44e-9
R2 1 port2 1.20e-1
R3 port1 port2 2.00e+4
L4 port1 2 4.00e-8
R4 2 port2 50.0
L5 port1 3 1.90e-8
R5 3 port2 2.50
L6 port1 4 9.00e-8
R6 4 port2 900
.ENDS LQP03PN4N7J02
*----------------------------------------------------------------------
