*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N2B02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N2B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 2.95e-10
R2 1 port2 1.30e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 9.00
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TQ0N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N2C02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N2C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 2.95e-10
R2 1 port2 1.30e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 3.50e-8
R5 3 port2 220
L6 port1 4 3.00e-9
R6 4 port2 9.00
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TQ0N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N3B02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N3B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 3.70e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 200
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TQ0N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N3C02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N3C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 3.70e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-7
R4 2 port2 800
L5 port1 3 3.50e-8
R5 3 port2 200
L6 port1 4 3.00e-9
R6 4 port2 11.0
L7 port1 5 2.50e-7
R7 5 port2 400
.ENDS LQP02TQ0N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N4B02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N4B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 5.03e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.70e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N4C02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N4C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 5.03e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.70e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N5B02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N5B02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 6.00e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.60e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N5C02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N5C02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 6.00e-10
R2 1 port2 2.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.60e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N6B02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 7.20e-10
R2 1 port2 3.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.60e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N6C02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 7.20e-10
R2 1 port2 3.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.60e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 400
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N7B02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 8.40e-10
R2 1 port2 3.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.80e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 40.0
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N7C02 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 8.40e-10
R2 1 port2 3.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.80e-8
R4 2 port2 20.0
L5 port1 3 4.00e-8
R5 3 port2 40.0
L6 port1 4 1.00e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N8B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 9.60e-10
R2 1 port2 4.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.90e-8
R4 2 port2 20.0
L5 port1 3 5.00e-8
R5 3 port2 400
L6 port1 4 1.30e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N8C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 9.60e-10
R2 1 port2 4.50e-2
R3 port1 port2 3.00e+3
L4 port1 2 1.90e-8
R4 2 port2 20.0
L5 port1 3 5.00e-8
R5 3 port2 400
L6 port1 4 1.30e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N9B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.07e-9
R2 1 port2 4.50e-2
R3 port1 port2 3.20e+3
L4 port1 2 1.90e-8
R4 2 port2 20.0
L5 port1 3 5.00e-8
R5 3 port2 400
L6 port1 4 1.30e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ0N9C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.07e-9
R2 1 port2 4.50e-2
R3 port1 port2 3.20e+3
L4 port1 2 1.90e-8
R4 2 port2 20.0
L5 port1 3 5.00e-8
R5 3 port2 400
L6 port1 4 1.30e-8
R6 4 port2 60.0
.ENDS LQP02TQ0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ10NH02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.15e-8
R2 1 port2 1.05
R3 port1 port2 2.50e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 60.0
.ENDS LQP02TQ10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ10NJ02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.15e-8
R2 1 port2 1.05
R3 port1 port2 2.50e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 60.0
.ENDS LQP02TQ10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ11NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.28e-8
R2 1 port2 9.50e-1
R3 port1 port2 2.30e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 75.0
.ENDS LQP02TQ11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ11NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.28e-8
R2 1 port2 9.50e-1
R3 port1 port2 2.30e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 75.0
.ENDS LQP02TQ11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ12NH02 port1 port2
C1 port1 port2 6.60e-14
L2 port1 1 1.40e-8
R2 1 port2 1.25
R3 port1 port2 2.20e+4
L4 port1 2 1.90e-7
R4 2 port2 1.00e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 48.0
.ENDS LQP02TQ12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ12NJ02 port1 port2
C1 port1 port2 6.60e-14
L2 port1 1 1.40e-8
R2 1 port2 1.25
R3 port1 port2 2.20e+4
L4 port1 2 1.90e-7
R4 2 port2 1.00e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 48.0
.ENDS LQP02TQ12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ13NH02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.52e-8
R2 1 port2 1.70
R3 port1 port2 2.60e+4
L4 port1 2 2.20e-7
R4 2 port2 1.30e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 48.0
.ENDS LQP02TQ13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ13NJ02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.52e-8
R2 1 port2 1.70
R3 port1 port2 2.60e+4
L4 port1 2 2.20e-7
R4 2 port2 1.30e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.00e-7
R6 4 port2 48.0
.ENDS LQP02TQ13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ15NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.80e-8
R2 1 port2 1.25
R3 port1 port2 2.10e+4
L4 port1 2 2.20e-7
R4 2 port2 1.10e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.05e-7
R6 4 port2 55.0
.ENDS LQP02TQ15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ15NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.80e-8
R2 1 port2 1.25
R3 port1 port2 2.10e+4
L4 port1 2 2.20e-7
R4 2 port2 1.10e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.05e-7
R6 4 port2 55.0
.ENDS LQP02TQ15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ16NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.92e-8
R2 1 port2 1.50
R3 port1 port2 2.40e+4
L4 port1 2 2.60e-7
R4 2 port2 1.40e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.05e-7
R6 4 port2 40.0
.ENDS LQP02TQ16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ16NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.92e-8
R2 1 port2 1.50
R3 port1 port2 2.40e+4
L4 port1 2 2.60e-7
R4 2 port2 1.40e+3
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 2.05e-7
R6 4 port2 40.0
.ENDS LQP02TQ16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ18NH02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.20e-8
R2 1 port2 1.70
R3 port1 port2 2.10e+4
L4 port1 2 2.70e-7
R4 2 port2 1.40e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 60.0
.ENDS LQP02TQ18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ18NJ02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.20e-8
R2 1 port2 1.70
R3 port1 port2 2.10e+4
L4 port1 2 2.70e-7
R4 2 port2 1.40e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 60.0
.ENDS LQP02TQ18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N0B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.16e-9
R2 1 port2 1.00e-1
R3 port1 port2 3.00e+3
L4 port1 2 2.40e-8
R4 2 port2 140
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N0C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.16e-9
R2 1 port2 1.00e-1
R3 port1 port2 3.00e+3
L4 port1 2 2.40e-8
R4 2 port2 140
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N1B02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.28e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 2.60e-8
R4 2 port2 200
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N1C02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.28e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 2.60e-8
R4 2 port2 200
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N2B02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.40e-9
R2 1 port2 1.10e-1
R3 port1 port2 4.70e+3
L4 port1 2 2.80e-8
R4 2 port2 200
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N2C02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.40e-9
R2 1 port2 1.10e-1
R3 port1 port2 4.70e+3
L4 port1 2 2.80e-8
R4 2 port2 200
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N3B02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.50e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.60e-8
R4 2 port2 320
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N3C02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.50e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.60e-8
R4 2 port2 320
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N4B02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 1.60e-9
R2 1 port2 1.41e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.70e-8
R4 2 port2 300
L5 port1 3 8.00e-8
R5 3 port2 500
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N4C02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 1.60e-9
R2 1 port2 1.41e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.70e-8
R4 2 port2 300
L5 port1 3 8.00e-8
R5 3 port2 500
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N5B02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.75e-9
R2 1 port2 1.48e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.80e-8
R4 2 port2 300
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N5C02 port1 port2
C1 port1 port2 3.50e-14
L2 port1 1 1.75e-9
R2 1 port2 1.48e-1
R3 port1 port2 4.70e+3
L4 port1 2 3.80e-8
R4 2 port2 300
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 30.0
.ENDS LQP02TQ1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N6B02 port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 1.87e-9
R2 1 port2 1.48e-1
R3 port1 port2 4.00e+3
L4 port1 2 5.00e-8
R4 2 port2 350
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 31.0
.ENDS LQP02TQ1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N6C02 port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 1.87e-9
R2 1 port2 1.48e-1
R3 port1 port2 4.00e+3
L4 port1 2 5.00e-8
R4 2 port2 350
L5 port1 3 8.00e-8
R5 3 port2 400
L6 port1 4 2.50e-8
R6 4 port2 31.0
.ENDS LQP02TQ1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N7B02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.93e-9
R2 1 port2 1.65e-1
R3 port1 port2 5.00e+3
L4 port1 2 3.60e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 45.0
.ENDS LQP02TQ1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N7C02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.93e-9
R2 1 port2 1.65e-1
R3 port1 port2 5.00e+3
L4 port1 2 3.60e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 45.0
.ENDS LQP02TQ1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N8B02 port1 port2
C1 port1 port2 4.25e-14
L2 port1 1 2.06e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.00e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 45.0
.ENDS LQP02TQ1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N8C02 port1 port2
C1 port1 port2 4.25e-14
L2 port1 1 2.06e-9
R2 1 port2 1.85e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.00e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 45.0
.ENDS LQP02TQ1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N9B02 port1 port2
C1 port1 port2 4.50e-14
L2 port1 1 2.19e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.25e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 2.80e-8
R6 4 port2 40.0
.ENDS LQP02TQ1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ1N9C02 port1 port2
C1 port1 port2 4.50e-14
L2 port1 1 2.19e-9
R2 1 port2 1.80e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.25e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 2.80e-8
R6 4 port2 40.0
.ENDS LQP02TQ1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ20NH02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 2.49e-8
R2 1 port2 1.82
R3 port1 port2 2.10e+4
L4 port1 2 2.70e-7
R4 2 port2 1.40e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 58.0
.ENDS LQP02TQ20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ20NJ02 port1 port2
C1 port1 port2 6.70e-14
L2 port1 1 2.49e-8
R2 1 port2 1.82
R3 port1 port2 2.10e+4
L4 port1 2 2.70e-7
R4 2 port2 1.40e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 58.0
.ENDS LQP02TQ20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ22NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.79e-8
R2 1 port2 2.50
R3 port1 port2 2.30e+4
L4 port1 2 3.10e-7
R4 2 port2 1.70e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 40.0
.ENDS LQP02TQ22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ22NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.79e-8
R2 1 port2 2.50
R3 port1 port2 2.30e+4
L4 port1 2 3.10e-7
R4 2 port2 1.70e+3
L5 port1 3 3.00e-7
R5 3 port2 600
L6 port1 4 2.00e-7
R6 4 port2 40.0
.ENDS LQP02TQ22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N0B02 port1 port2
C1 port1 port2 5.10e-14
L2 port1 1 2.30e-9
R2 1 port2 2.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.50e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 37.0
.ENDS LQP02TQ2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N0C02 port1 port2
C1 port1 port2 5.10e-14
L2 port1 1 2.30e-9
R2 1 port2 2.00e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.50e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.20e-8
R6 4 port2 37.0
.ENDS LQP02TQ2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N1B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 2.42e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.70e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 38.0
.ENDS LQP02TQ2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N1C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 2.42e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.70e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 38.0
.ENDS LQP02TQ2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N2B02 port1 port2
C1 port1 port2 4.25e-14
L2 port1 1 2.55e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.80e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP02TQ2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N2C02 port1 port2
C1 port1 port2 4.25e-14
L2 port1 1 2.55e-9
R2 1 port2 1.95e-1
R3 port1 port2 5.00e+3
L4 port1 2 4.80e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP02TQ2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N3B02 port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 2.67e-9
R2 1 port2 1.75e-1
R3 port1 port2 5.00e+3
L4 port1 2 5.20e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP02TQ2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N3C02 port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 2.67e-9
R2 1 port2 1.75e-1
R3 port1 port2 5.00e+3
L4 port1 2 5.20e-8
R4 2 port2 300
L5 port1 3 4.00e-7
R5 3 port2 400
L6 port1 4 3.00e-8
R6 4 port2 40.0
.ENDS LQP02TQ2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N4B02 port1 port2
C1 port1 port2 3.95e-14
L2 port1 1 2.65e-9
R2 1 port2 2.75e-1
R3 port1 port2 5.00e+3
L4 port1 2 5.50e-8
R4 2 port2 300
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N4C02 port1 port2
C1 port1 port2 3.95e-14
L2 port1 1 2.65e-9
R2 1 port2 2.75e-1
R3 port1 port2 5.00e+3
L4 port1 2 5.50e-8
R4 2 port2 300
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N5B02 port1 port2
C1 port1 port2 4.20e-14
L2 port1 1 2.77e-9
R2 1 port2 2.20e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 240
.ENDS LQP02TQ2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N5C02 port1 port2
C1 port1 port2 4.20e-14
L2 port1 1 2.77e-9
R2 1 port2 2.20e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 240
.ENDS LQP02TQ2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N6B02 port1 port2
C1 port1 port2 4.40e-14
L2 port1 1 2.89e-9
R2 1 port2 2.70e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 240
.ENDS LQP02TQ2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N6C02 port1 port2
C1 port1 port2 4.40e-14
L2 port1 1 2.89e-9
R2 1 port2 2.70e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 240
.ENDS LQP02TQ2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N7B02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 3.00e-9
R2 1 port2 3.10e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N7C02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 3.00e-9
R2 1 port2 3.10e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N8B02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 3.10e-9
R2 1 port2 2.80e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N8C02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 3.10e-9
R2 1 port2 2.80e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 250
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N9B02 port1 port2
C1 port1 port2 5.85e-14
L2 port1 1 3.17e-9
R2 1 port2 2.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 7.90e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ2N9C02 port1 port2
C1 port1 port2 5.85e-14
L2 port1 1 3.17e-9
R2 1 port2 2.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 7.90e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N0B02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 3.30e-9
R2 1 port2 3.10e-1
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N0C02 port1 port2
C1 port1 port2 5.50e-14
L2 port1 1 3.30e-9
R2 1 port2 3.10e-1
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N1B02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 3.40e-9
R2 1 port2 3.10e-1
R3 port1 port2 7.00e+3
L4 port1 2 8.20e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N1C02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 3.40e-9
R2 1 port2 3.10e-1
R3 port1 port2 7.00e+3
L4 port1 2 8.20e-8
R4 2 port2 600
L5 port1 3 5.50e-7
R5 3 port2 1.20e+3
L6 port1 4 8.00e-8
R6 4 port2 200
.ENDS LQP02TQ3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N2B02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 3.53e-9
R2 1 port2 3.40e-1
R3 port1 port2 8.00e+3
L4 port1 2 6.20e-8
R4 2 port2 450
L5 port1 3 3.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 150
.ENDS LQP02TQ3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N2C02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 3.53e-9
R2 1 port2 3.40e-1
R3 port1 port2 8.00e+3
L4 port1 2 6.20e-8
R4 2 port2 450
L5 port1 3 3.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 150
.ENDS LQP02TQ3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N3B02 port1 port2
C1 port1 port2 4.65e-14
L2 port1 1 3.65e-9
R2 1 port2 5.37e-1
R3 port1 port2 8.00e+3
L4 port1 2 6.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N3C02 port1 port2
C1 port1 port2 4.65e-14
L2 port1 1 3.65e-9
R2 1 port2 5.37e-1
R3 port1 port2 8.00e+3
L4 port1 2 6.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N4B02 port1 port2
C1 port1 port2 4.65e-14
L2 port1 1 3.78e-9
R2 1 port2 4.40e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.40e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 8.50e-8
R6 4 port2 100
.ENDS LQP02TQ3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N4C02 port1 port2
C1 port1 port2 4.65e-14
L2 port1 1 3.78e-9
R2 1 port2 4.40e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.40e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 8.50e-8
R6 4 port2 100
.ENDS LQP02TQ3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N5B02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 3.90e-9
R2 1 port2 4.60e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.70e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 8.50e-8
R6 4 port2 100
.ENDS LQP02TQ3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N5C02 port1 port2
C1 port1 port2 4.85e-14
L2 port1 1 3.90e-9
R2 1 port2 4.60e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.70e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 8.50e-8
R6 4 port2 100
.ENDS LQP02TQ3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N6B02 port1 port2
C1 port1 port2 5.05e-14
L2 port1 1 4.00e-9
R2 1 port2 5.87e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.90e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N6C02 port1 port2
C1 port1 port2 5.05e-14
L2 port1 1 4.00e-9
R2 1 port2 5.87e-1
R3 port1 port2 9.00e+3
L4 port1 2 6.90e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N7B02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 4.10e-9
R2 1 port2 4.70e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.30e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 120
.ENDS LQP02TQ3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N7C02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 4.10e-9
R2 1 port2 4.70e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.30e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 120
.ENDS LQP02TQ3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N8B02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 4.22e-9
R2 1 port2 4.80e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N8C02 port1 port2
C1 port1 port2 5.35e-14
L2 port1 1 4.22e-9
R2 1 port2 4.80e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N9B02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 4.35e-9
R2 1 port2 5.20e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 90.0
.ENDS LQP02TQ3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ3N9C02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 4.35e-9
R2 1 port2 5.20e-1
R3 port1 port2 9.00e+3
L4 port1 2 7.50e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 90.0
.ENDS LQP02TQ3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N0B02 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 4.46e-9
R2 1 port2 4.90e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.00e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N0C02 port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 4.46e-9
R2 1 port2 4.90e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.00e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 100
.ENDS LQP02TQ4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N1B02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 4.57e-9
R2 1 port2 4.90e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.10e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N1C02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 4.57e-9
R2 1 port2 4.90e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.10e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N2B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 4.70e-9
R2 1 port2 4.80e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.20e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N2C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 4.70e-9
R2 1 port2 4.80e-1
R3 port1 port2 9.00e+3
L4 port1 2 8.20e-8
R4 2 port2 500
L5 port1 3 4.50e-7
R5 3 port2 800
L6 port1 4 1.00e-7
R6 4 port2 110
.ENDS LQP02TQ4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N3H02 port1 port2
C1 port1 port2 4.73e-14
L2 port1 1 4.85e-9
R2 1 port2 6.10e-1
R3 port1 port2 1.00e+4
L4 port1 2 8.00e-8
R4 2 port2 500
L5 port1 3 5.00e-7
R5 3 port2 900
L6 port1 4 1.00e-7
R6 4 port2 50.0
.ENDS LQP02TQ4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N3J02 port1 port2
C1 port1 port2 4.73e-14
L2 port1 1 4.85e-9
R2 1 port2 6.10e-1
R3 port1 port2 1.00e+4
L4 port1 2 8.00e-8
R4 2 port2 500
L5 port1 3 5.00e-7
R5 3 port2 900
L6 port1 4 1.00e-7
R6 4 port2 50.0
.ENDS LQP02TQ4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N7H02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 5.32e-9
R2 1 port2 4.90e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.00e-7
R4 2 port2 500
L5 port1 3 3.20e-7
R5 3 port2 800
L6 port1 4 9.50e-8
R6 4 port2 90.0
.ENDS LQP02TQ4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ4N7J02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 5.32e-9
R2 1 port2 4.90e-1
R3 port1 port2 8.00e+3
L4 port1 2 1.00e-7
R4 2 port2 500
L5 port1 3 3.20e-7
R5 3 port2 800
L6 port1 4 9.50e-8
R6 4 port2 90.0
.ENDS LQP02TQ4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ5N1H02 port1 port2
C1 port1 port2 5.60e-14
L2 port1 1 5.68e-9
R2 1 port2 6.50e-1
R3 port1 port2 1.00e+4
L4 port1 2 1.00e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 700
L6 port1 4 1.70e-7
R6 4 port2 120
.ENDS LQP02TQ5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ5N1J02 port1 port2
C1 port1 port2 5.60e-14
L2 port1 1 5.68e-9
R2 1 port2 6.50e-1
R3 port1 port2 1.00e+4
L4 port1 2 1.00e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 700
L6 port1 4 1.70e-7
R6 4 port2 120
.ENDS LQP02TQ5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ5N6H02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 6.30e-9
R2 1 port2 6.60e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.00e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 500
L6 port1 4 1.80e-7
R6 4 port2 100
.ENDS LQP02TQ5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ5N6J02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 6.30e-9
R2 1 port2 6.60e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.00e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 500
L6 port1 4 1.80e-7
R6 4 port2 100
.ENDS LQP02TQ5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ6N2H02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 7.00e-9
R2 1 port2 7.40e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.10e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 100
.ENDS LQP02TQ6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ6N2J02 port1 port2
C1 port1 port2 5.15e-14
L2 port1 1 7.00e-9
R2 1 port2 7.40e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.10e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 100
.ENDS LQP02TQ6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ6N8H02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 7.71e-9
R2 1 port2 8.20e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.20e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 70.0
.ENDS LQP02TQ6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ6N8J02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 7.71e-9
R2 1 port2 8.20e-1
R3 port1 port2 1.10e+4
L4 port1 2 1.20e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 70.0
.ENDS LQP02TQ6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ7N5H02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 8.60e-9
R2 1 port2 7.80e-1
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 60.0
.ENDS LQP02TQ7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ7N5J02 port1 port2
C1 port1 port2 4.90e-14
L2 port1 1 8.60e-9
R2 1 port2 7.80e-1
R3 port1 port2 1.20e+4
L4 port1 2 1.20e-7
R4 2 port2 550
L5 port1 3 3.20e-7
R5 3 port2 320
L6 port1 4 1.80e-7
R6 4 port2 60.0
.ENDS LQP02TQ7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ8N2H02 port1 port2
C1 port1 port2 4.50e-14
L2 port1 1 9.37e-9
R2 1 port2 7.80e-1
R3 port1 port2 1.60e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 1.60e-7
R6 4 port2 60.0
.ENDS LQP02TQ8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ8N2J02 port1 port2
C1 port1 port2 4.50e-14
L2 port1 1 9.37e-9
R2 1 port2 7.80e-1
R3 port1 port2 1.60e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 1.60e-7
R6 4 port2 60.0
.ENDS LQP02TQ8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ9N1H02 port1 port2
C1 port1 port2 5.45e-14
L2 port1 1 1.05e-8
R2 1 port2 1.00
R3 port1 port2 1.80e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 1.70e-7
R6 4 port2 60.0
.ENDS LQP02TQ9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP02TQ9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP02TQ9N1J02 port1 port2
C1 port1 port2 5.45e-14
L2 port1 1 1.05e-8
R2 1 port2 1.00
R3 port1 port2 1.80e+4
L4 port1 2 1.65e-7
R4 2 port2 920
L5 port1 3 3.40e-7
R5 3 port2 380
L6 port1 4 1.70e-7
R6 4 port2 60.0
.ENDS LQP02TQ9N1J02
*----------------------------------------------------------------------
