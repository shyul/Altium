*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN10NG8Z
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN10NG8Z port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.96e-7
R4 2 port2 97.8
L5 port1 3 6.01e-7
R5 3 port2 1.35e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN10NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN10NJ8Z
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN10NJ8Z port1 port2
C1 port1 port2 6.21e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.96e-7
R4 2 port2 97.8
L5 port1 3 6.01e-7
R5 3 port2 1.35e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN10NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN11NG8Z
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN11NG8Z port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 1.12e-8
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.48e-7
R4 2 port2 65.5
L5 port1 3 6.13e-7
R5 3 port2 1.30e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN11NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN11NJ8Z
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN11NJ8Z port1 port2
C1 port1 port2 6.65e-14
L2 port1 1 1.12e-8
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.48e-7
R4 2 port2 65.5
L5 port1 3 6.13e-7
R5 3 port2 1.30e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN11NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN12NG8Z
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN12NG8Z port1 port2
C1 port1 port2 4.39e-14
L2 port1 1 1.20e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.98e-7
R4 2 port2 119
L5 port1 3 8.48e-7
R5 3 port2 3.46e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN12NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN12NJ8Z
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN12NJ8Z port1 port2
C1 port1 port2 4.39e-14
L2 port1 1 1.20e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.98e-7
R4 2 port2 119
L5 port1 3 8.48e-7
R5 3 port2 3.46e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN12NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN13NG8Z
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN13NG8Z port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 1.32e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.33e-7
R4 2 port2 45.2
L5 port1 3 5.84e-7
R5 3 port2 1.19e+3
L6 port1 4 2.47e-6
C6 4 5 6.62e-17
R6 5 port2 281
.ENDS LQW18AN13NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN13NJ8Z
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN13NJ8Z port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 1.32e-8
R2 1 port2 5.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.33e-7
R4 2 port2 45.2
L5 port1 3 5.84e-7
R5 3 port2 1.19e+3
L6 port1 4 2.47e-6
C6 4 5 6.62e-17
R6 5 port2 281
.ENDS LQW18AN13NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN15NG8Z
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN15NG8Z port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 1.51e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.87e-7
R4 2 port2 98.7
L5 port1 3 7.74e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN15NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN15NJ8Z
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN15NJ8Z port1 port2
C1 port1 port2 1.83e-14
L2 port1 1 1.51e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.87e-7
R4 2 port2 98.7
L5 port1 3 7.74e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN15NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN16NG8Z
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN16NG8Z port1 port2
C1 port1 port2 3.74e-14
L2 port1 1 1.62e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.34e-7
R4 2 port2 98.7
L5 port1 3 7.56e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 1.15e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.59e-15
R7 7 port2 365
.ENDS LQW18AN16NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN16NJ8Z
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN16NJ8Z port1 port2
C1 port1 port2 3.74e-14
L2 port1 1 1.62e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.34e-7
R4 2 port2 98.7
L5 port1 3 7.56e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 1.15e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.59e-15
R7 7 port2 365
.ENDS LQW18AN16NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN17NG8Z
* Property : L = 17[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN17NG8Z port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.74e-8
R2 1 port2 6.64e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.14e-7
R4 2 port2 98.7
L5 port1 3 7.39e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 8.53e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.18e-15
R7 7 port2 365
.ENDS LQW18AN17NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN17NJ8Z
* Property : L = 17[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN17NJ8Z port1 port2
C1 port1 port2 5.41e-14
L2 port1 1 1.74e-8
R2 1 port2 6.64e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.14e-7
R4 2 port2 98.7
L5 port1 3 7.39e-7
R5 3 port2 1.11e+3
L6 port1 4 2.47e-6
C6 4 5 8.53e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.18e-15
R7 7 port2 365
.ENDS LQW18AN17NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN18NG8Z
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN18NG8Z port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 1.82e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.49e-7
R4 2 port2 128
L5 port1 3 1.09e-6
R5 3 port2 2.10e+3
L6 port1 4 2.47e-6
C6 4 5 1.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.29e-15
R7 7 port2 365
.ENDS LQW18AN18NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN18NJ8Z
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN18NJ8Z port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 1.82e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.49e-7
R4 2 port2 128
L5 port1 3 1.09e-6
R5 3 port2 2.10e+3
L6 port1 4 2.47e-6
C6 4 5 1.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.29e-15
R7 7 port2 365
.ENDS LQW18AN18NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN19NG8Z
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN19NG8Z port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.95e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.51e-7
R4 2 port2 49.5
L5 port1 3 7.84e-7
R5 3 port2 897
L6 port1 4 2.47e-6
C6 4 5 1.05e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 365
.ENDS LQW18AN19NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN19NJ8Z
* Property : L = 19[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN19NJ8Z port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.95e-8
R2 1 port2 6.20e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.51e-7
R4 2 port2 49.5
L5 port1 3 7.84e-7
R5 3 port2 897
L6 port1 4 2.47e-6
C6 4 5 1.05e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 365
.ENDS LQW18AN19NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN22NG8Z
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN22NG8Z port1 port2
C1 port1 port2 4.82e-14
L2 port1 1 2.29e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.43e-7
R4 2 port2 71.1
L5 port1 3 1.04e-6
R5 3 port2 1.52e+3
L6 port1 4 2.47e-6
C6 4 5 1.55e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN22NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN22NJ8Z
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN22NJ8Z port1 port2
C1 port1 port2 4.82e-14
L2 port1 1 2.29e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.43e-7
R4 2 port2 71.1
L5 port1 3 1.04e-6
R5 3 port2 1.52e+3
L6 port1 4 2.47e-6
C6 4 5 1.55e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN22NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN23NG8Z
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN23NG8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.40e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.41e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN23NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN23NJ8Z
* Property : L = 23[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN23NJ8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.40e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.41e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.45e-15
R7 7 port2 365
.ENDS LQW18AN23NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN24NG8Z
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN24NG8Z port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.51e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.10e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.44e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.55e-15
R7 7 port2 365
.ENDS LQW18AN24NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN24NJ8Z
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN24NJ8Z port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 2.51e-8
R2 1 port2 7.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.10e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.44e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.55e-15
R7 7 port2 365
.ENDS LQW18AN24NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN25NG8Z
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN25NG8Z port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 2.63e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.23e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.04e-15
R7 7 port2 365
.ENDS LQW18AN25NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN25NJ8Z
* Property : L = 25[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN25NJ8Z port1 port2
C1 port1 port2 4.10e-14
L2 port1 1 2.63e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.37e-7
R4 2 port2 79.6
L5 port1 3 1.23e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.04e-15
R7 7 port2 365
.ENDS LQW18AN25NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN27NG8Z
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN27NG8Z port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 2.75e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.35e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN27NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN27NJ8Z
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN27NJ8Z port1 port2
C1 port1 port2 5.04e-14
L2 port1 1 2.75e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.58e-7
R4 2 port2 79.6
L5 port1 3 1.35e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN27NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN28NG8Z
* Property : L = 28[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN28NG8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.95e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.80e-7
R4 2 port2 79.6
L5 port1 3 1.26e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN28NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN28NJ8Z
* Property : L = 28[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN28NJ8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 2.95e-8
R2 1 port2 8.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.80e-7
R4 2 port2 79.6
L5 port1 3 1.26e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN28NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN2N2C8Z
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN2N2C8Z port1 port2
C1 port1 port2 6.09e-14
L2 port1 1 1.94e-9
R2 1 port2 1.50e-2
R3 port1 port2 2.28e+4
L4 port1 2 4.10e-8
R4 2 port2 9.71
L5 port1 3 4.91e-8
R5 3 port2 180
.ENDS LQW18AN2N2C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN2N4C8Z
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN2N4C8Z port1 port2
C1 port1 port2 5.95e-14
L2 port1 1 2.03e-9
R2 1 port2 2.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 6.19e-8
R4 2 port2 54.9
L5 port1 3 7.07e-8
R5 3 port2 323
.ENDS LQW18AN2N4C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN30NG8Z
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN30NG8Z port1 port2
C1 port1 port2 6.64e-14
L2 port1 1 3.16e-8
R2 1 port2 1.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.45e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN30NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN30NJ8Z
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN30NJ8Z port1 port2
C1 port1 port2 6.64e-14
L2 port1 1 3.16e-8
R2 1 port2 1.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.45e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.28e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.24e-15
R7 7 port2 365
.ENDS LQW18AN30NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN31NG8Z
* Property : L = 31[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN31NG8Z port1 port2
C1 port1 port2 4.09e-14
L2 port1 1 3.23e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.78e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.57e-15
R7 7 port2 365
.ENDS LQW18AN31NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN31NJ8Z
* Property : L = 31[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN31NJ8Z port1 port2
C1 port1 port2 4.09e-14
L2 port1 1 3.23e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.02e-7
R4 2 port2 79.6
L5 port1 3 1.78e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.13e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.57e-15
R7 7 port2 365
.ENDS LQW18AN31NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN33NG8Z
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN33NG8Z port1 port2
C1 port1 port2 4.49e-14
L2 port1 1 3.46e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.68e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.51e-15
R7 7 port2 365
.ENDS LQW18AN33NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN33NJ8Z
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN33NJ8Z port1 port2
C1 port1 port2 4.49e-14
L2 port1 1 3.46e-8
R2 1 port2 9.10e-2
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.68e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.51e-15
R7 7 port2 365
.ENDS LQW18AN33NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN34NG8Z
* Property : L = 34[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN34NG8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 3.54e-8
R2 1 port2 1.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.03e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.09e-15
R7 7 port2 365
.ENDS LQW18AN34NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN34NJ8Z
* Property : L = 34[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN34NJ8Z port1 port2
C1 port1 port2 5.16e-14
L2 port1 1 3.54e-8
R2 1 port2 1.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.50e-7
R4 2 port2 79.6
L5 port1 3 1.63e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.03e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.09e-15
R7 7 port2 365
.ENDS LQW18AN34NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN36NG8Z
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN36NG8Z port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 3.79e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN36NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN36NJ8Z
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN36NJ8Z port1 port2
C1 port1 port2 5.65e-14
L2 port1 1 3.79e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN36NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN37NG8Z
* Property : L = 37[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN37NG8Z port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 3.88e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.89e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.18e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN37NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN37NJ8Z
* Property : L = 37[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN37NJ8Z port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 3.88e-8
R2 1 port2 1.60e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.89e-7
R4 2 port2 79.6
L5 port1 3 1.71e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.18e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.29e-15
R7 7 port2 183
.ENDS LQW18AN37NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN39NG8Z
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN39NG8Z port1 port2
C1 port1 port2 3.10e-14
L2 port1 1 4.16e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 5.23e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 183
.ENDS LQW18AN39NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN39NJ8Z
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN39NJ8Z port1 port2
C1 port1 port2 3.10e-14
L2 port1 1 4.16e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.31e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 5.23e-17
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.07e-15
R7 7 port2 183
.ENDS LQW18AN39NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N0C8Z
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N0C8Z port1 port2
C1 port1 port2 4.51e-14
L2 port1 1 2.62e-9
R2 1 port2 1.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 5.43e-8
R4 2 port2 234
L5 port1 3 1.26e-7
R5 3 port2 125
.ENDS LQW18AN3N0C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9B8Z
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9B8Z port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9C8Z
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9C8Z port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN3N9G8Z
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN3N9G8Z port1 port2
C1 port1 port2 3.05e-14
L2 port1 1 3.62e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 53.3
L5 port1 3 1.91e-7
R5 3 port2 831
.ENDS LQW18AN3N9G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN41NG8Z
* Property : L = 41[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN41NG8Z port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 4.36e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.17e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.08e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.95e-15
R7 7 port2 183
.ENDS LQW18AN41NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN41NJ8Z
* Property : L = 41[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN41NJ8Z port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 4.36e-8
R2 1 port2 1.30e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.17e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.08e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.95e-15
R7 7 port2 183
.ENDS LQW18AN41NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN43NG8Z
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN43NG8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 4.56e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.92e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.62e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.75e-15
R7 7 port2 183
.ENDS LQW18AN43NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN43NJ8Z
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN43NJ8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 4.56e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.92e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.62e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.75e-15
R7 7 port2 183
.ENDS LQW18AN43NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN44NG8Z
* Property : L = 44[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN44NG8Z port1 port2
C1 port1 port2 5.03e-14
L2 port1 1 4.67e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.61e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.88e-15
R7 7 port2 183
.ENDS LQW18AN44NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN44NJ8Z
* Property : L = 44[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN44NJ8Z port1 port2
C1 port1 port2 5.03e-14
L2 port1 1 4.67e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.28e+4
L4 port1 2 6.61e-7
R4 2 port2 79.6
L5 port1 3 1.92e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.88e-15
R7 7 port2 183
.ENDS LQW18AN44NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN47NG8Z
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN47NG8Z port1 port2
C1 port1 port2 4.48e-14
L2 port1 1 5.00e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.08e-7
R4 2 port2 79.6
L5 port1 3 2.06e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.74e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.71e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN47NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN47NJ8Z
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN47NJ8Z port1 port2
C1 port1 port2 4.48e-14
L2 port1 1 5.00e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.08e-7
R4 2 port2 79.6
L5 port1 3 2.06e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 2.74e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.71e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN47NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN48NG8Z
* Property : L = 48[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN48NG8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 5.12e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.01e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.56e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN48NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN48NJ8Z
* Property : L = 48[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN48NJ8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 5.12e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.01e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.56e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.23e-16
R8 9 port2 578
.ENDS LQW18AN48NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1B8Z
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1B8Z port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1C8Z
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1C8Z port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N1G8Z
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N1G8Z port1 port2
C1 port1 port2 2.42e-14
L2 port1 1 3.79e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 8.81e-8
R4 2 port2 49.7
L5 port1 3 1.91e-7
R5 3 port2 794
.ENDS LQW18AN4N1G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2B8Z
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2B8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2C8Z
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2C8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N2G8Z
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N2G8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 3.97e-9
R2 1 port2 2.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.37e-7
R4 2 port2 61.6
L5 port1 3 1.67e-7
R5 3 port2 600
.ENDS LQW18AN4N2G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3B8Z
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3B8Z port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3C8Z
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3C8Z port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N3G8Z
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N3G8Z port1 port2
C1 port1 port2 2.72e-14
L2 port1 1 4.06e-9
R2 1 port2 3.00e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 196
L5 port1 3 3.59e-7
R5 3 port2 1.78e+3
.ENDS LQW18AN4N3G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7B8Z
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7B8Z port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7C8Z
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7C8Z port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N7G8Z
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N7G8Z port1 port2
C1 port1 port2 3.12e-14
L2 port1 1 4.45e-9
R2 1 port2 4.50e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 175
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N7G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9B8Z
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9B8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9B8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9C8Z
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9C8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN4N9G8Z
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN4N9G8Z port1 port2
C1 port1 port2 3.19e-14
L2 port1 1 4.55e-9
R2 1 port2 6.70e-2
R3 port1 port2 2.39e+4
L4 port1 2 1.48e-7
R4 2 port2 220
L5 port1 3 3.59e-7
R5 3 port2 2.34e+3
.ENDS LQW18AN4N9G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN51NG8Z
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN51NG8Z port1 port2
C1 port1 port2 4.69e-14
L2 port1 1 5.36e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.00e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.67e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.28e-16
R8 9 port2 578
.ENDS LQW18AN51NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN51NJ8Z
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN51NJ8Z port1 port2
C1 port1 port2 4.69e-14
L2 port1 1 5.36e-8
R2 1 port2 1.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 7.41e-7
R4 2 port2 79.6
L5 port1 3 2.21e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.00e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.67e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.28e-16
R8 9 port2 578
.ENDS LQW18AN51NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN52NG8Z
* Property : L = 52[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN52NG8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 5.61e-8
R2 1 port2 2.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 1.97e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.52e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.80e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.33e-16
R8 9 port2 578
.ENDS LQW18AN52NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN52NJ8Z
* Property : L = 52[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN52NJ8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 5.61e-8
R2 1 port2 2.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 1.97e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.52e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 3.80e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.33e-16
R8 9 port2 578
.ENDS LQW18AN52NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN56NG8Z
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN56NG8Z port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 6.01e-8
R2 1 port2 2.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 2.54e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.78e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.89e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.44e-16
R8 9 port2 578
.ENDS LQW18AN56NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN56NJ8Z
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN56NJ8Z port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 6.01e-8
R2 1 port2 2.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.31e-7
R4 2 port2 79.6
L5 port1 3 2.54e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.78e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.89e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.44e-16
R8 9 port2 578
.ENDS LQW18AN56NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN58NG8Z
* Property : L = 58[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN58NG8Z port1 port2
C1 port1 port2 4.38e-14
L2 port1 1 6.29e-8
R2 1 port2 2.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.90e-7
R4 2 port2 79.6
L5 port1 3 2.11e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.96e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.46e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.74e-16
R8 9 port2 578
.ENDS LQW18AN58NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN58NJ8Z
* Property : L = 58[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN58NJ8Z port1 port2
C1 port1 port2 4.38e-14
L2 port1 1 6.29e-8
R2 1 port2 2.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 8.90e-7
R4 2 port2 79.6
L5 port1 3 2.11e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 3.96e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 4.46e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 2.74e-16
R8 9 port2 578
.ENDS LQW18AN58NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN5N6C8Z
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN5N6C8Z port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 5.47e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.01e-7
R4 2 port2 142
L5 port1 3 3.67e-7
R5 3 port2 1.41e+3
.ENDS LQW18AN5N6C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN5N6G8Z
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN5N6G8Z port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 5.47e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.01e-7
R4 2 port2 142
L5 port1 3 3.67e-7
R5 3 port2 1.41e+3
.ENDS LQW18AN5N6G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN68NG8Z
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN68NG8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 7.39e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.02e-6
R4 2 port2 79.6
L5 port1 3 2.79e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.54e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.00e-16
R8 9 port2 578
.ENDS LQW18AN68NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN68NJ8Z
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN68NJ8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 7.39e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.02e-6
R4 2 port2 79.6
L5 port1 3 2.79e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.54e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.00e-16
R8 9 port2 578
.ENDS LQW18AN68NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN69NG8Z
* Property : L = 69[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN69NG8Z port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 7.56e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 9.74e-7
R4 2 port2 79.6
L5 port1 3 2.43e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.73e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.99e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 1.47e-16
R8 9 port2 578
.ENDS LQW18AN69NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN69NJ8Z
* Property : L = 69[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN69NJ8Z port1 port2
C1 port1 port2 4.08e-14
L2 port1 1 7.56e-8
R2 1 port2 3.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 9.74e-7
R4 2 port2 79.6
L5 port1 3 2.43e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 1.73e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.99e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 1.47e-16
R8 9 port2 578
.ENDS LQW18AN69NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N0C8Z
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N0C8Z port1 port2
C1 port1 port2 1.64e-14
L2 port1 1 5.60e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 215
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N0C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N0G8Z
* Property : L = 6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N0G8Z port1 port2
C1 port1 port2 1.64e-14
L2 port1 1 5.60e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 215
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N0G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N5C8Z
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N5C8Z port1 port2
C1 port1 port2 2.98e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.76e-7
R4 2 port2 152
L5 port1 3 3.16e-7
R5 3 port2 1.25e+3
L6 port1 4 2.62e-7
C6 4 5 5.14e-16
R6 5 port2 600
L7 port1 6 1.95e-7
C7 6 7 3.90e-16
R7 7 port2 222
.ENDS LQW18AN6N5C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N5G8Z
* Property : L = 6.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N5G8Z port1 port2
C1 port1 port2 2.98e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.76e-7
R4 2 port2 152
L5 port1 3 3.16e-7
R5 3 port2 1.25e+3
L6 port1 4 2.62e-7
C6 4 5 5.14e-16
R6 5 port2 600
L7 port1 6 1.95e-7
C7 6 7 3.90e-16
R7 7 port2 222
.ENDS LQW18AN6N5G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N8C8Z
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N8C8Z port1 port2
C1 port1 port2 3.93e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 156
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N8C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN6N8G8Z
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN6N8G8Z port1 port2
C1 port1 port2 3.93e-14
L2 port1 1 6.43e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.59e-7
R4 2 port2 156
L5 port1 3 4.02e-7
R5 3 port2 1.17e+3
.ENDS LQW18AN6N8G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN72NG8Z
* Property : L = 72[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN72NG8Z port1 port2
C1 port1 port2 3.90e-14
L2 port1 1 7.92e-8
R2 1 port2 3.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.17e-6
R4 2 port2 79.6
L5 port1 3 2.99e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.65e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.75e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.07e-16
R8 9 port2 578
.ENDS LQW18AN72NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN72NJ8Z
* Property : L = 72[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN72NJ8Z port1 port2
C1 port1 port2 3.90e-14
L2 port1 1 7.92e-8
R2 1 port2 3.90e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.17e-6
R4 2 port2 79.6
L5 port1 3 2.99e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.65e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.75e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.07e-16
R8 9 port2 578
.ENDS LQW18AN72NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN73NG8Z
* Property : L = 73[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN73NG8Z port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.20e-6
R4 2 port2 79.6
L5 port1 3 2.49e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.40e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.61e-16
R8 9 port2 578
.ENDS LQW18AN73NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN73NJ8Z
* Property : L = 73[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN73NJ8Z port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.20e-6
R4 2 port2 79.6
L5 port1 3 2.49e-6
R5 3 port2 1.59e+3
L6 port1 4 2.47e-6
C6 4 5 4.87e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.40e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.61e-16
R8 9 port2 578
.ENDS LQW18AN73NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN75NG8Z
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN75NG8Z port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.84e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.95e-16
R8 9 port2 578
.ENDS LQW18AN75NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN75NJ8Z
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN75NJ8Z port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 7.92e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.84e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.22e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.30e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 3.95e-16
R8 9 port2 578
.ENDS LQW18AN75NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN78NG8Z
* Property : L = 78[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN78NG8Z port1 port2
C1 port1 port2 3.39e-14
L2 port1 1 8.10e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.03e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.72e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.91e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.86e-16
R8 9 port2 578
.ENDS LQW18AN78NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN78NJ8Z
* Property : L = 78[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN78NJ8Z port1 port2
C1 port1 port2 3.39e-14
L2 port1 1 8.10e-8
R2 1 port2 3.40e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.49e-6
R4 2 port2 255
L5 port1 3 4.03e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.72e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.91e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.86e-16
R8 9 port2 578
.ENDS LQW18AN78NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N2C8Z
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N2C8Z port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 7.05e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.89e-7
R4 2 port2 168
L5 port1 3 4.66e-7
R5 3 port2 1.40e+3
.ENDS LQW18AN7N2C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N2G8Z
* Property : L = 7.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N2G8Z port1 port2
C1 port1 port2 4.72e-14
L2 port1 1 7.05e-9
R2 1 port2 3.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.89e-7
R4 2 port2 168
L5 port1 3 4.66e-7
R5 3 port2 1.40e+3
.ENDS LQW18AN7N2G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N5C8Z
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N5C8Z port1 port2
C1 port1 port2 3.84e-14
L2 port1 1 7.38e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.83e-7
R4 2 port2 50.6
L5 port1 3 3.25e-7
R5 3 port2 802
.ENDS LQW18AN7N5C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN7N5G8Z
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN7N5G8Z port1 port2
C1 port1 port2 3.84e-14
L2 port1 1 7.38e-9
R2 1 port2 4.00e-2
R3 port1 port2 2.28e+4
L4 port1 2 1.83e-7
R4 2 port2 50.6
L5 port1 3 3.25e-7
R5 3 port2 802
.ENDS LQW18AN7N5G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN82NG8Z
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN82NG8Z port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.49e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.71e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.05e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN82NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN82NJ8Z
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN82NJ8Z port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.49e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.71e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.05e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN82NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN83NG8Z
* Property : L = 83[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN83NG8Z port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.69e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.87e-6
R4 2 port2 255
L5 port1 3 3.39e-6
R5 3 port2 2.38e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.67e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN83NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN83NJ8Z
* Property : L = 83[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN83NJ8Z port1 port2
C1 port1 port2 3.64e-14
L2 port1 1 8.69e-8
R2 1 port2 4.10e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.87e-6
R4 2 port2 255
L5 port1 3 3.39e-6
R5 3 port2 2.38e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 6.60e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.67e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN83NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N2C8Z
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N2C8Z port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 8.09e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.38e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N2C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N2G8Z
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N2G8Z port1 port2
C1 port1 port2 2.48e-14
L2 port1 1 8.09e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.38e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N2G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N4C8Z
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N4C8Z port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 8.40e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.27e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N4C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N4G8Z
* Property : L = 8.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N4G8Z port1 port2
C1 port1 port2 1.97e-14
L2 port1 1 8.40e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.27e-7
R4 2 port2 78.0
L5 port1 3 4.26e-7
R5 3 port2 1.24e+3
.ENDS LQW18AN8N4G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N7C8Z
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N7C8Z port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 8.50e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.77e-7
R4 2 port2 118
L5 port1 3 4.72e-7
R5 3 port2 1.06e+3
.ENDS LQW18AN8N7C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN8N7G8Z
* Property : L = 8.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN8N7G8Z port1 port2
C1 port1 port2 2.06e-14
L2 port1 1 8.50e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.77e-7
R4 2 port2 118
L5 port1 3 4.72e-7
R5 3 port2 1.06e+3
.ENDS LQW18AN8N7G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN91NG8Z
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN91NG8Z port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 9.53e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.11e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.85e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.15e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN91NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN91NJ8Z
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN91NJ8Z port1 port2
C1 port1 port2 3.32e-14
L2 port1 1 9.53e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.28e+4
L4 port1 2 1.79e-6
R4 2 port2 255
L5 port1 3 4.62e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.85e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.11e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.85e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.15e-16
R9 11 port2 2.98e+3
.ENDS LQW18AN91NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN94NG8Z
* Property : L = 94[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN94NG8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 9.75e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.25e-6
R4 2 port2 255
L5 port1 3 4.02e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.75e-15
R7 7 port2 183
L8 port1 8 1.53e-7
C8 8 9 1.23e-15
R8 9 port2 793
L9 port1 10 7.12e-7
C9 10 11 1.25e-16
R9 11 port2 3.80e+3
.ENDS LQW18AN94NG8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN94NJ8Z
* Property : L = 94[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN94NJ8Z port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 9.75e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.25e-6
R4 2 port2 255
L5 port1 3 4.02e-6
R5 3 port2 2.87e+3
L6 port1 4 2.47e-6
C6 4 5 5.99e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 7.75e-15
R7 7 port2 183
L8 port1 8 1.53e-7
C8 8 9 1.23e-15
R8 9 port2 793
L9 port1 10 7.12e-7
C9 10 11 1.25e-16
R9 11 port2 3.80e+3
.ENDS LQW18AN94NJ8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N1C8Z
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N1C8Z port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.90e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.79e-7
R4 2 port2 123
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.71e-6
C6 4 5 4.91e-17
R6 5 port2 2.68e+3
.ENDS LQW18AN9N1C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N1G8Z
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N1G8Z port1 port2
C1 port1 port2 2.59e-14
L2 port1 1 8.90e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.79e-7
R4 2 port2 123
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.71e-6
C6 4 5 4.91e-17
R6 5 port2 2.68e+3
.ENDS LQW18AN9N1G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N5C8Z
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N5C8Z port1 port2
C1 port1 port2 3.49e-14
L2 port1 1 9.32e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.41e-7
R4 2 port2 115
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN9N5C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N5G8Z
* Property : L = 9.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N5G8Z port1 port2
C1 port1 port2 3.49e-14
L2 port1 1 9.32e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 3.41e-7
R4 2 port2 115
L5 port1 3 5.82e-7
R5 3 port2 1.51e+3
L6 port1 4 2.47e-6
C6 4 5 4.91e-17
R6 5 port2 281
.ENDS LQW18AN9N5G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N9C8Z
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N9C8Z port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.07e-7
R4 2 port2 63.4
L5 port1 3 5.48e-7
R5 3 port2 1.97e+3
L6 port1 4 2.47e-6
C6 4 5 3.72e-17
R6 5 port2 281
.ENDS LQW18AN9N9C8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18AN9N9G8Z
* Property : L = 9.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18AN9N9G8Z port1 port2
C1 port1 port2 6.07e-14
L2 port1 1 9.99e-9
R2 1 port2 4.30e-2
R3 port1 port2 2.28e+4
L4 port1 2 2.07e-7
R4 2 port2 63.4
L5 port1 3 5.48e-7
R5 3 port2 1.97e+3
L6 port1 4 2.47e-6
C6 4 5 3.72e-17
R6 5 port2 281
.ENDS LQW18AN9N9G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR10G8Z
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR10G8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 1.02e-7
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.09e-6
R4 2 port2 373
L5 port1 3 9.54e-6
R5 3 port2 9.45e+3
L6 port1 4 2.47e-6
C6 4 5 7.89e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 8.70e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.65e-15
R10 13 port2 405
.ENDS LQW18ANR10G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR10J8Z
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR10J8Z port1 port2
C1 port1 port2 4.18e-14
L2 port1 1 1.02e-7
R2 1 port2 5.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.09e-6
R4 2 port2 373
L5 port1 3 9.54e-6
R5 3 port2 9.45e+3
L6 port1 4 2.47e-6
C6 4 5 7.89e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 8.70e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 6.41e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.65e-15
R10 13 port2 405
.ENDS LQW18ANR10J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR11G8Z
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR11G8Z port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 1.14e-7
R2 1 port2 5.80e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.83e-6
R4 2 port2 818
L5 port1 3 1.90e-5
R5 3 port2 8.08e+3
L6 port1 4 2.47e-6
C6 4 5 8.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.76e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 7.36e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.92e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.89e-15
R10 13 port2 405
.ENDS LQW18ANR11G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR11J8Z
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR11J8Z port1 port2
C1 port1 port2 4.28e-14
L2 port1 1 1.14e-7
R2 1 port2 5.80e-1
R3 port1 port2 2.28e+4
L4 port1 2 2.83e-6
R4 2 port2 818
L5 port1 3 1.90e-5
R5 3 port2 8.08e+3
L6 port1 4 2.47e-6
C6 4 5 8.45e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 9.76e-15
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 7.36e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.92e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.89e-15
R10 13 port2 405
.ENDS LQW18ANR11J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR12G8Z
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR12G8Z port1 port2
C1 port1 port2 3.48e-14
L2 port1 1 1.25e-7
R2 1 port2 6.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.10e-6
R4 2 port2 818
L5 port1 3 1.73e-5
R5 3 port2 7.20e+3
L6 port1 4 2.47e-6
C6 4 5 9.48e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.17e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 4.75e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.61e-15
R10 13 port2 405
.ENDS LQW18ANR12G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR12J8Z
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR12J8Z port1 port2
C1 port1 port2 3.48e-14
L2 port1 1 1.25e-7
R2 1 port2 6.00e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.10e-6
R4 2 port2 818
L5 port1 3 1.73e-5
R5 3 port2 7.20e+3
L6 port1 4 2.47e-6
C6 4 5 9.48e-16
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 1.17e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 4.75e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.79e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.61e-15
R10 13 port2 405
.ENDS LQW18ANR12J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR15G8Z
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR15G8Z port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-7
R2 1 port2 7.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.91e-6
R4 2 port2 1.19e+3
L5 port1 3 9.25e-5
R5 3 port2 1.67e+4
L6 port1 4 2.47e-6
C6 4 5 1.17e-15
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.08e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.25e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.83e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR15G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR15J8Z
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR15J8Z port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.50e-7
R2 1 port2 7.20e-1
R3 port1 port2 2.28e+4
L4 port1 2 3.91e-6
R4 2 port2 1.19e+3
L5 port1 3 9.25e-5
R5 3 port2 1.67e+4
L6 port1 4 2.47e-6
C6 4 5 1.17e-15
R6 5 port2 281
L7 port1 6 8.43e-8
C7 6 7 2.08e-14
R7 7 port2 183
L8 port1 8 4.65e-7
C8 8 9 8.25e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.83e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR15J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR18G8Z
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR18G8Z port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 1.85e-7
R2 1 port2 1.37
R3 port1 port2 2.28e+4
L4 port1 2 5.01e-6
R4 2 port2 962
L5 port1 3 4.81e-4
R5 3 port2 6.84e+3
L6 port1 4 2.47e-6
C6 4 5 1.20e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.32e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 9.69e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.96e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR18G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR18J8Z
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR18J8Z port1 port2
C1 port1 port2 4.17e-14
L2 port1 1 1.85e-7
R2 1 port2 1.37
R3 port1 port2 2.28e+4
L4 port1 2 5.01e-6
R4 2 port2 962
L5 port1 3 4.81e-4
R5 3 port2 6.84e+3
L6 port1 4 2.47e-6
C6 4 5 1.20e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.32e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 9.69e-16
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 1.96e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.50e-15
R10 13 port2 405
.ENDS LQW18ANR18J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR20G8Z
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR20G8Z port1 port2
C1 port1 port2 3.80e-14
L2 port1 1 2.03e-7
R2 1 port2 1.45
R3 port1 port2 2.28e+4
L4 port1 2 5.78e-6
R4 2 port2 1.19e+3
L5 port1 3 2.77e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.09e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.20e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR20G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR20J8Z
* Property : L = 200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR20J8Z port1 port2
C1 port1 port2 3.80e-14
L2 port1 1 2.03e-7
R2 1 port2 1.45
R3 port1 port2 2.28e+4
L4 port1 2 5.78e-6
R4 2 port2 1.19e+3
L5 port1 3 2.77e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.09e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.20e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR20J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR21G8Z
* Property : L = 210[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR21G8Z port1 port2
C1 port1 port2 4.07e-14
L2 port1 1 2.13e-7
R2 1 port2 1.65
R3 port1 port2 2.28e+4
L4 port1 2 6.64e-6
R4 2 port2 1.19e+3
L5 port1 3 2.15e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.36e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.17e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.30e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR21G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR21J8Z
* Property : L = 210[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR21J8Z port1 port2
C1 port1 port2 4.07e-14
L2 port1 1 2.13e-7
R2 1 port2 1.65
R3 port1 port2 2.28e+4
L4 port1 2 6.64e-6
R4 2 port2 1.19e+3
L5 port1 3 2.15e-4
R5 3 port2 7.88e+3
L6 port1 4 2.47e-6
C6 4 5 1.51e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.36e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.17e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.30e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.68e-15
R10 13 port2 405
.ENDS LQW18ANR21J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR22G8Z
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR22G8Z port1 port2
C1 port1 port2 3.98e-14
L2 port1 1 2.28e-7
R2 1 port2 1.73
R3 port1 port2 2.28e+4
L4 port1 2 6.75e-6
R4 2 port2 1.36e+3
L5 port1 3 2.88e-4
R5 3 port2 1.45e+4
L6 port1 4 2.47e-6
C6 4 5 1.69e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.30e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.14e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.41e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.76e-15
R10 13 port2 405
.ENDS LQW18ANR22G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR22J8Z
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR22J8Z port1 port2
C1 port1 port2 3.98e-14
L2 port1 1 2.28e-7
R2 1 port2 1.73
R3 port1 port2 2.28e+4
L4 port1 2 6.75e-6
R4 2 port2 1.36e+3
L5 port1 3 2.88e-4
R5 3 port2 1.45e+4
L6 port1 4 2.47e-6
C6 4 5 1.69e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.30e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.14e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 2.41e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 1.76e-15
R10 13 port2 405
.ENDS LQW18ANR22J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR25G8Z
* Property : L = 250[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR25G8Z port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 2.56e-7
R2 1 port2 1.90
R3 port1 port2 2.28e+4
L4 port1 2 7.28e-6
R4 2 port2 1.19e+3
L5 port1 3 7.21e-5
R5 3 port2 1.33e+3
L6 port1 4 2.47e-6
C6 4 5 8.47e-16
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.40e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 3.25e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 2.17e-15
R10 13 port2 405
.ENDS LQW18ANR25G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR25J8Z
* Property : L = 250[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR25J8Z port1 port2
C1 port1 port2 2.63e-14
L2 port1 1 2.56e-7
R2 1 port2 1.90
R3 port1 port2 2.28e+4
L4 port1 2 7.28e-6
R4 2 port2 1.19e+3
L5 port1 3 7.21e-5
R5 3 port2 1.33e+3
L6 port1 4 2.47e-6
C6 4 5 8.47e-16
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.16e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 1.40e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 3.25e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 2.17e-15
R10 13 port2 405
.ENDS LQW18ANR25J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR27G8Z
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR27G8Z port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.74e-7
R2 1 port2 1.92
R3 port1 port2 2.28e+4
L4 port1 2 9.69e-6
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.80e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.32e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 6.64e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.75e-15
R10 13 port2 405
.ENDS LQW18ANR27G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR27J8Z
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR27J8Z port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 2.74e-7
R2 1 port2 1.92
R3 port1 port2 2.28e+4
L4 port1 2 9.69e-6
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 1.80e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.32e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 6.64e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.75e-15
R10 13 port2 405
.ENDS LQW18ANR27J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR30G8Z
* Property : L = 300[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR30G8Z port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 3.07e-7
R2 1 port2 2.60
R3 port1 port2 2.28e+4
L4 port1 2 1.31e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.02e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR30G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR30J8Z
* Property : L = 300[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR30J8Z port1 port2
C1 port1 port2 2.40e-14
L2 port1 1 3.07e-7
R2 1 port2 2.60
R3 port1 port2 2.28e+4
L4 port1 2 1.31e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 2.56e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.02e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR30J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR33G8Z
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR33G8Z port1 port2
C1 port1 port2 2.51e-14
L2 port1 1 3.37e-7
R2 1 port2 3.20
R3 port1 port2 2.28e+4
L4 port1 2 1.94e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 3.15e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR33G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR33J8Z
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR33J8Z port1 port2
C1 port1 port2 2.51e-14
L2 port1 1 3.37e-7
R2 1 port2 3.20
R3 port1 port2 2.28e+4
L4 port1 2 1.94e-5
R4 2 port2 1.74e+3
L5 port1 3 2.13e-4
R5 3 port2 2.10e+4
L6 port1 4 2.47e-6
C6 4 5 3.15e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.29e-15
R10 13 port2 405
.ENDS LQW18ANR33J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR36G8Z
* Property : L = 360[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR36G8Z port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 3.61e-7
R2 1 port2 3.31
R3 port1 port2 2.28e+4
L4 port1 2 1.99e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 3.38e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.53e-15
R10 13 port2 405
.ENDS LQW18ANR36G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR36J8Z
* Property : L = 360[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR36J8Z port1 port2
C1 port1 port2 2.57e-14
L2 port1 1 3.61e-7
R2 1 port2 3.31
R3 port1 port2 2.28e+4
L4 port1 2 1.99e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 3.38e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.43e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.12e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 4.39e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 3.53e-15
R10 13 port2 405
.ENDS LQW18ANR36J8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR39G8Z
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR39G8Z port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 3.96e-7
R2 1 port2 3.52
R3 port1 port2 2.28e+4
L4 port1 2 2.04e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 1.48e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.02e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.67e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 5.66e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.24e-15
R10 13 port2 405
.ENDS LQW18ANR39G8Z
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18ANR39J8Z
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18ANR39J8Z port1 port2
C1 port1 port2 2.09e-14
L2 port1 1 3.96e-7
R2 1 port2 3.52
R3 port1 port2 2.28e+4
L4 port1 2 2.04e-5
R4 2 port2 1.74e+3
L5 port1 3 2.71e-2
R5 3 port2 2.39e+4
L6 port1 4 2.47e-6
C6 4 5 1.48e-15
R6 5 port2 281
L7 port1 6 1.12e-6
C7 6 7 2.02e-15
R7 7 port2 3.44e+3
L8 port1 8 4.65e-7
C8 8 9 2.67e-15
R8 9 port2 578
L9 port1 10 9.46e-7
C9 10 11 5.66e-16
R9 11 port2 2.98e+3
L10 port1 12 7.59e-8
C10 12 13 4.24e-15
R10 13 port2 405
.ENDS LQW18ANR39J8Z
*----------------------------------------------------------------------
