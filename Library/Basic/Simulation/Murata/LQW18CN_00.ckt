*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CN15NJ00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CN15NJ00 port1 port2
C1 port1 port2 9.30e-15
L2 port1 1 1.49e-8
R2 1 port2 7.33e-2
R3 port1 port2 132
L4 port1 2 2.70e-7
R4 2 port2 94.9
.ENDS LQW18CN15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CN33NJ00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CN33NJ00 port1 port2
C1 port1 port2 7.22e-15
L2 port1 1 3.19e-8
R2 1 port2 1.69e-1
R3 port1 port2 233
L4 port1 2 1.06e-6
R4 2 port2 267
.ENDS LQW18CN33NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CN4N9D00
* Property : L = 4.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CN4N9D00 port1 port2
C1 port1 port2 2.84e-14
L2 port1 1 5.00e-9
R2 1 port2 2.02e-2
R3 port1 port2 87.0
L4 port1 2 1.23e-7
R4 2 port2 30.9
L5 port1 3 1.45e-7
R5 3 port2 356
L6 port1 4 2.39e-8
R6 4 port2 143
.ENDS LQW18CN4N9D00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CN55NJ00
* Property : L = 55[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CN55NJ00 port1 port2
C1 port1 port2 3.62e-14
L2 port1 1 5.41e-8
R2 1 port2 2.61e-1
R3 port1 port2 387
L4 port1 2 1.06e-6
R4 2 port2 267
.ENDS LQW18CN55NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CN85NJ00
* Property : L = 85[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CN85NJ00 port1 port2
C1 port1 port2 4.95e-14
L2 port1 1 8.40e-8
R2 1 port2 4.17e-1
R3 port1 port2 577
L4 port1 2 1.83e-6
R4 2 port2 416
.ENDS LQW18CN85NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR10K00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR10K00 port1 port2
C1 port1 port2 5.89e-14
L2 port1 1 9.19e-8
R2 1 port2 4.36e-1
R3 port1 port2 672
L4 port1 2 1.84e-6
R4 2 port2 463
.ENDS LQW18CNR10K00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR12J00
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR12J00 port1 port2
C1 port1 port2 5.23e-14
L2 port1 1 1.18e-7
R2 1 port2 5.74e-1
R3 port1 port2 821
L4 port1 2 2.35e-6
R4 2 port2 678
.ENDS LQW18CNR12J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR16J00
* Property : L = 160[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR16J00 port1 port2
C1 port1 port2 5.56e-14
L2 port1 1 1.60e-7
R2 1 port2 8.06e-1
R3 port1 port2 1.14e+3
L4 port1 2 3.04e-6
R4 2 port2 763
.ENDS LQW18CNR16J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR21J00
* Property : L = 210[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR21J00 port1 port2
C1 port1 port2 4.81e-14
L2 port1 1 2.05e-7
R2 1 port2 1.02
R3 port1 port2 1.37e+3
L4 port1 2 4.39e-6
R4 2 port2 1.10e+3
.ENDS LQW18CNR21J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR27J00
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR27J00 port1 port2
C1 port1 port2 5.60e-14
L2 port1 1 2.74e-7
R2 1 port2 1.31
R3 port1 port2 1.95e+3
L4 port1 2 4.56e-6
R4 2 port2 1.15e+3
.ENDS LQW18CNR27J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR33J00
* Property : L = 330[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR33J00 port1 port2
C1 port1 port2 4.58e-14
L2 port1 1 3.29e-7
R2 1 port2 1.55
R3 port1 port2 2.33e+3
L4 port1 2 6.28e-6
R4 2 port2 1.58e+3
.ENDS LQW18CNR33J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR39J00
* Property : L = 390[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR39J00 port1 port2
C1 port1 port2 4.39e-14
L2 port1 1 3.87e-7
R2 1 port2 1.92
R3 port1 port2 2.57e+3
L4 port1 2 7.15e-6
R4 2 port2 1.80e+3
.ENDS LQW18CNR39J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR47J00
* Property : L = 470[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR47J00 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 4.71e-7
R2 1 port2 2.25
R3 port1 port2 3.09e+3
L4 port1 2 8.81e-6
R4 2 port2 2.21e+3
.ENDS LQW18CNR47J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR56J00
* Property : L = 560[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR56J00 port1 port2
C1 port1 port2 4.58e-14
L2 port1 1 5.65e-7
R2 1 port2 2.76
R3 port1 port2 3.71e+3
L4 port1 2 1.05e-5
R4 2 port2 2.63e+3
.ENDS LQW18CNR56J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW18CNR65J00
* Property : L = 650[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW18CNR65J00 port1 port2
C1 port1 port2 4.63e-14
L2 port1 1 6.49e-7
R2 1 port2 2.78
R3 port1 port2 4.39e+3
L4 port1 2 1.32e-5
R4 2 port2 3.32e+3
.ENDS LQW18CNR65J00
*----------------------------------------------------------------------
