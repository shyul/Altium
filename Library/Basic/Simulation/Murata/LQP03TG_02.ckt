*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N1B02
* Property : L = 0.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N1B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 2.70e-10
R2 1 port2 8.00e-3
R3 port1 port2 1.00e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N2B02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N2B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N2C02
* Property : L = 0.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N2C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 3.70e-10
R2 1 port2 1.10e-2
R3 port1 port2 1.00e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N3B02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N3B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N3C02
* Property : L = 0.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N3C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 4.80e-10
R2 1 port2 2.10e-2
R3 port1 port2 1.10e+3
L4 port1 2 1.60e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N4B02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N4B02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N4C02
* Property : L = 0.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N4C02 port1 port2
C1 port1 port2 1.00e-15
L2 port1 1 5.90e-10
R2 1 port2 5.30e-2
R3 port1 port2 1.20e+3
L4 port1 2 1.40e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N5B02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N5B02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N5C02
* Property : L = 0.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N5C02 port1 port2
C1 port1 port2 1.00e-14
L2 port1 1 7.00e-10
R2 1 port2 4.30e-2
R3 port1 port2 1.30e+3
L4 port1 2 1.80e-8
R4 2 port2 75.0
L5 port1 3 2.00e-7
R5 3 port2 2.00e+3
L6 port1 4 4.40e-8
R6 4 port2 35.0
L7 port1 5 5.00e-9
C7 5 6 7.60e-15
R7 6 port2 1.00e-1
.ENDS LQP03TG0N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N6B02 port1 port2
C1 port1 port2 2.50e-14
L2 port1 1 8.20e-10
R2 1 port2 5.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 8.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N6C02 port1 port2
C1 port1 port2 2.50e-14
L2 port1 1 8.20e-10
R2 1 port2 5.00e-2
R3 port1 port2 3.00e+3
L4 port1 2 5.00e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 8.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N7B02 port1 port2
C1 port1 port2 2.50e-14
L2 port1 1 9.40e-10
R2 1 port2 5.00e-2
R3 port1 port2 3.20e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 9.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N7C02 port1 port2
C1 port1 port2 2.50e-14
L2 port1 1 9.40e-10
R2 1 port2 5.00e-2
R3 port1 port2 3.20e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 9.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N8B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.07e-9
R2 1 port2 6.00e-2
R3 port1 port2 4.00e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 9.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N8C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.07e-9
R2 1 port2 6.00e-2
R3 port1 port2 4.00e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 9.00e-9
R6 4 port2 11.0
.ENDS LQP03TG0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N9B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.17e-9
R2 1 port2 9.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 1.10e-8
R6 4 port2 11.0
.ENDS LQP03TG0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG0N9C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.17e-9
R2 1 port2 9.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 5.50e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 1.10e-8
R6 4 port2 11.0
.ENDS LQP03TG0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG10NH02 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 1.10e-8
R2 1 port2 9.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 80.0
.ENDS LQP03TG10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG10NJ02 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 1.10e-8
R2 1 port2 9.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 80.0
.ENDS LQP03TG10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG11NH02 port1 port2
C1 port1 port2 4.14e-14
L2 port1 1 1.80e-8
R2 1 port2 1.55
R3 port1 port2 1.42e+4
L4 port1 2 1.73e-7
R4 2 port2 610
L5 port1 3 1.68e-7
R5 3 port2 60.4
L6 port1 4 3.90e-8
R6 4 port2 3.79
L7 port1 5 1.05e-9
C7 5 6 5.58e-14
R7 6 port2 13.3
.ENDS LQP03TG11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG11NJ02 port1 port2
C1 port1 port2 4.14e-14
L2 port1 1 1.80e-8
R2 1 port2 1.55
R3 port1 port2 1.42e+4
L4 port1 2 1.73e-7
R4 2 port2 610
L5 port1 3 1.68e-7
R5 3 port2 60.4
L6 port1 4 3.90e-8
R6 4 port2 3.79
L7 port1 5 1.05e-9
C7 5 6 5.58e-14
R7 6 port2 13.3
.ENDS LQP03TG11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG12NH02 port1 port2
C1 port1 port2 1.14e-13
L2 port1 1 1.33e-8
R2 1 port2 1.10
R3 port1 port2 7.00e+3
L4 port1 2 3.50e-7
R4 2 port2 1.00e+3
L5 port1 3 4.20e-7
R5 3 port2 1.00e+3
L6 port1 4 1.90e-7
R6 4 port2 60.0
.ENDS LQP03TG12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG12NJ02 port1 port2
C1 port1 port2 1.14e-13
L2 port1 1 1.33e-8
R2 1 port2 1.10
R3 port1 port2 7.00e+3
L4 port1 2 3.50e-7
R4 2 port2 1.00e+3
L5 port1 3 4.20e-7
R5 3 port2 1.00e+3
L6 port1 4 1.90e-7
R6 4 port2 60.0
.ENDS LQP03TG12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG13NH02 port1 port2
C1 port1 port2 9.24e-16
L2 port1 1 1.44e-8
R2 1 port2 1.07
R3 port1 port2 1.30e+4
L4 port1 2 3.30e-7
R4 2 port2 1.60e+3
L5 port1 3 3.67e-7
R5 3 port2 693
L6 port1 4 1.55e-7
R6 4 port2 56.1
L7 port1 5 5.96e-10
C7 5 6 1.24e-13
R7 6 port2 3.75
.ENDS LQP03TG13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG13NJ02 port1 port2
C1 port1 port2 9.24e-16
L2 port1 1 1.44e-8
R2 1 port2 1.07
R3 port1 port2 1.30e+4
L4 port1 2 3.30e-7
R4 2 port2 1.60e+3
L5 port1 3 3.67e-7
R5 3 port2 693
L6 port1 4 1.55e-7
R6 4 port2 56.1
L7 port1 5 5.96e-10
C7 5 6 1.24e-13
R7 6 port2 3.75
.ENDS LQP03TG13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG15NH02 port1 port2
C1 port1 port2 1.28e-13
L2 port1 1 1.67e-8
R2 1 port2 1.22
R3 port1 port2 7.80e+3
L4 port1 2 3.50e-7
R4 2 port2 1.00e+3
L5 port1 3 4.50e-7
R5 3 port2 1.00e+3
L6 port1 4 2.14e-7
R6 4 port2 85.0
L7 port1 5 1.60e-8
C7 5 6 4.60e-15
R7 6 port2 105
.ENDS LQP03TG15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG15NJ02 port1 port2
C1 port1 port2 1.28e-13
L2 port1 1 1.67e-8
R2 1 port2 1.22
R3 port1 port2 7.80e+3
L4 port1 2 3.50e-7
R4 2 port2 1.00e+3
L5 port1 3 4.50e-7
R5 3 port2 1.00e+3
L6 port1 4 2.14e-7
R6 4 port2 85.0
L7 port1 5 1.60e-8
C7 5 6 4.60e-15
R7 6 port2 105
.ENDS LQP03TG15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG16NH02 port1 port2
C1 port1 port2 1.64e-15
L2 port1 1 1.81e-8
R2 1 port2 1.23
R3 port1 port2 1.18e+4
L4 port1 2 3.38e-7
R4 2 port2 1.36e+3
L5 port1 3 2.91e-7
R5 3 port2 347
L6 port1 4 2.52e-7
R6 4 port2 56.1
L7 port1 5 6.10e-10
C7 5 6 1.33e-13
R7 6 port2 2.48
.ENDS LQP03TG16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG16NJ02 port1 port2
C1 port1 port2 1.64e-15
L2 port1 1 1.81e-8
R2 1 port2 1.23
R3 port1 port2 1.18e+4
L4 port1 2 3.38e-7
R4 2 port2 1.36e+3
L5 port1 3 2.91e-7
R5 3 port2 347
L6 port1 4 2.52e-7
R6 4 port2 56.1
L7 port1 5 6.10e-10
C7 5 6 1.33e-13
R7 6 port2 2.48
.ENDS LQP03TG16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG18NH02 port1 port2
C1 port1 port2 1.33e-13
L2 port1 1 2.04e-8
R2 1 port2 1.45
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.00e+3
L5 port1 3 5.00e-7
R5 3 port2 1.00e+3
L6 port1 4 2.15e-7
R6 4 port2 70.0
L7 port1 5 1.70e-8
C7 5 6 5.55e-15
R7 6 port2 100
.ENDS LQP03TG18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG18NJ02 port1 port2
C1 port1 port2 1.33e-13
L2 port1 1 2.04e-8
R2 1 port2 1.45
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.00e+3
L5 port1 3 5.00e-7
R5 3 port2 1.00e+3
L6 port1 4 2.15e-7
R6 4 port2 70.0
L7 port1 5 1.70e-8
C7 5 6 5.55e-15
R7 6 port2 100
.ENDS LQP03TG18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N0B02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.29e-9
R2 1 port2 9.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 1.10e-8
R6 4 port2 11.0
.ENDS LQP03TG1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N0C02 port1 port2
C1 port1 port2 3.00e-14
L2 port1 1 1.29e-9
R2 1 port2 9.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 1.00e+3
L5 port1 3 1.00e-7
R5 3 port2 300
L6 port1 4 1.10e-8
R6 4 port2 11.0
.ENDS LQP03TG1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N1B02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.54e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 5.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 6.70e-9
R6 4 port2 4.50
.ENDS LQP03TG1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N1C02 port1 port2
C1 port1 port2 4.00e-14
L2 port1 1 1.54e-9
R2 1 port2 6.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 5.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 6.70e-9
R6 4 port2 4.50
.ENDS LQP03TG1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N2B02 port1 port2
C1 port1 port2 5.90e-14
L2 port1 1 1.64e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 7.50e-9
R6 4 port2 5.50
.ENDS LQP03TG1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N2C02 port1 port2
C1 port1 port2 5.90e-14
L2 port1 1 1.64e-9
R2 1 port2 7.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 7.50e-9
R6 4 port2 5.50
.ENDS LQP03TG1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N3B02 port1 port2
C1 port1 port2 5.45e-14
L2 port1 1 1.72e-9
R2 1 port2 8.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 9.00e-9
R6 4 port2 5.50
.ENDS LQP03TG1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N3C02 port1 port2
C1 port1 port2 5.45e-14
L2 port1 1 1.72e-9
R2 1 port2 8.00e-2
R3 port1 port2 3.50e+3
L4 port1 2 6.00e-8
R4 2 port2 600
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 9.00e-9
R6 4 port2 5.50
.ENDS LQP03TG1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N4B02 port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 1.80e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 900
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.10e-8
R6 4 port2 8.00
.ENDS LQP03TG1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N4C02 port1 port2
C1 port1 port2 5.26e-14
L2 port1 1 1.80e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 900
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.10e-8
R6 4 port2 8.00
.ENDS LQP03TG1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N5B02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 1.90e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.30e-8
R6 4 port2 8.00
.ENDS LQP03TG1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N5C02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 1.90e-9
R2 1 port2 1.00e-1
R3 port1 port2 4.50e+3
L4 port1 2 6.50e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.30e-8
R6 4 port2 8.00
.ENDS LQP03TG1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N6B02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 2.01e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 7.00e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.40e-8
R6 4 port2 9.00
.ENDS LQP03TG1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N6C02 port1 port2
C1 port1 port2 5.70e-14
L2 port1 1 2.01e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 7.00e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.40e-8
R6 4 port2 9.00
.ENDS LQP03TG1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N7B02 port1 port2
C1 port1 port2 5.17e-14
L2 port1 1 2.12e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 7.00e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.50e-8
R6 4 port2 9.00
.ENDS LQP03TG1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N7C02 port1 port2
C1 port1 port2 5.17e-14
L2 port1 1 2.12e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 7.00e-8
R4 2 port2 800
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.50e-8
R6 4 port2 9.00
.ENDS LQP03TG1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N8B02 port1 port2
C1 port1 port2 5.84e-14
L2 port1 1 2.22e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 8.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.60e-8
R6 4 port2 10.0
.ENDS LQP03TG1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N8C02 port1 port2
C1 port1 port2 5.84e-14
L2 port1 1 2.22e-9
R2 1 port2 1.10e-1
R3 port1 port2 5.00e+3
L4 port1 2 8.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.60e-8
R6 4 port2 10.0
.ENDS LQP03TG1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N9B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.34e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.00e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.70e-8
R6 4 port2 13.0
.ENDS LQP03TG1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG1N9C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 2.34e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.00e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.70e-8
R6 4 port2 13.0
.ENDS LQP03TG1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG20NH02 port1 port2
C1 port1 port2 1.53e-14
L2 port1 1 2.18e-8
R2 1 port2 1.62
R3 port1 port2 1.03e+4
L4 port1 2 4.55e-7
R4 2 port2 1.80e+3
L5 port1 3 2.66e-7
R5 3 port2 310
L6 port1 4 5.51e-7
R6 4 port2 14.1
L7 port1 5 7.33e-10
C7 5 6 1.27e-13
R7 6 port2 2.78
.ENDS LQP03TG20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG20NJ02 port1 port2
C1 port1 port2 1.53e-14
L2 port1 1 2.18e-8
R2 1 port2 1.62
R3 port1 port2 1.03e+4
L4 port1 2 4.55e-7
R4 2 port2 1.80e+3
L5 port1 3 2.66e-7
R5 3 port2 310
L6 port1 4 5.51e-7
R6 4 port2 14.1
L7 port1 5 7.33e-10
C7 5 6 1.27e-13
R7 6 port2 2.78
.ENDS LQP03TG20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG22NH02 port1 port2
C1 port1 port2 1.40e-13
L2 port1 1 2.49e-8
R2 1 port2 2.05
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.00e+3
L5 port1 3 5.00e-7
R5 3 port2 1.00e+3
L6 port1 4 2.80e-7
R6 4 port2 80.0
L7 port1 5 2.35e-8
C7 5 6 5.75e-15
R7 6 port2 160
.ENDS LQP03TG22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG22NJ02 port1 port2
C1 port1 port2 1.40e-13
L2 port1 1 2.49e-8
R2 1 port2 2.05
R3 port1 port2 7.00e+3
L4 port1 2 4.00e-7
R4 2 port2 1.00e+3
L5 port1 3 5.00e-7
R5 3 port2 1.00e+3
L6 port1 4 2.80e-7
R6 4 port2 80.0
L7 port1 5 2.35e-8
C7 5 6 5.75e-15
R7 6 port2 160
.ENDS LQP03TG22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG24NH02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG24NH02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 2.68e-8
R2 1 port2 1.66
R3 port1 port2 1.06e+4
L4 port1 2 3.62e-7
R4 2 port2 1.36e+3
L5 port1 3 2.85e-7
R5 3 port2 310
L6 port1 4 7.10e-7
R6 4 port2 126
L7 port1 5 9.64e-10
C7 5 6 1.33e-13
R7 6 port2 5.98
.ENDS LQP03TG24NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG24NJ02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG24NJ02 port1 port2
C1 port1 port2 5.44e-14
L2 port1 1 2.68e-8
R2 1 port2 1.66
R3 port1 port2 1.06e+4
L4 port1 2 3.62e-7
R4 2 port2 1.36e+3
L5 port1 3 2.85e-7
R5 3 port2 310
L6 port1 4 7.10e-7
R6 4 port2 126
L7 port1 5 9.64e-10
C7 5 6 1.33e-13
R7 6 port2 5.98
.ENDS LQP03TG24NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG27NH02 port1 port2
C1 port1 port2 6.87e-14
L2 port1 1 2.85e-8
R2 1 port2 2.85
R3 port1 port2 3.61e+4
L4 port1 2 4.63e-7
R4 2 port2 239
L5 port1 3 3.38e-7
R5 3 port2 1.62e+3
L6 port1 4 4.92e-7
R6 4 port2 495
L7 port1 5 6.16e-9
C7 5 6 3.00e-14
R7 6 port2 24.8
L8 port1 7 1.08e-9
C8 7 8 1.34e-13
R8 8 port2 4.37
L9 port1 9 7.92e-10
C9 9 10 5.05e-14
R9 10 port2 5.76
.ENDS LQP03TG27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG27NJ02 port1 port2
C1 port1 port2 6.87e-14
L2 port1 1 2.85e-8
R2 1 port2 2.85
R3 port1 port2 3.61e+4
L4 port1 2 4.63e-7
R4 2 port2 239
L5 port1 3 3.38e-7
R5 3 port2 1.62e+3
L6 port1 4 4.92e-7
R6 4 port2 495
L7 port1 5 6.16e-9
C7 5 6 3.00e-14
R7 6 port2 24.8
L8 port1 7 1.08e-9
C8 7 8 1.34e-13
R8 8 port2 4.37
L9 port1 9 7.92e-10
C9 9 10 5.05e-14
R9 10 port2 5.76
.ENDS LQP03TG27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N0B02 port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 2.44e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 12.0
.ENDS LQP03TG2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N0C02 port1 port2
C1 port1 port2 5.52e-14
L2 port1 1 2.44e-9
R2 1 port2 1.30e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 12.0
.ENDS LQP03TG2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N1B02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.55e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 15.0
.ENDS LQP03TG2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N1C02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 2.55e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 9.50e-8
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 15.0
.ENDS LQP03TG2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N2B02 port1 port2
C1 port1 port2 5.47e-14
L2 port1 1 2.68e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 15.0
.ENDS LQP03TG2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N2C02 port1 port2
C1 port1 port2 5.47e-14
L2 port1 1 2.68e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 1.80e-8
R6 4 port2 15.0
.ENDS LQP03TG2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N3B02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 2.77e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.00e-8
R6 4 port2 16.0
.ENDS LQP03TG2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N3C02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 2.77e-9
R2 1 port2 1.20e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.10e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.00e-8
R6 4 port2 16.0
.ENDS LQP03TG2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N4B02 port1 port2
C1 port1 port2 5.46e-14
L2 port1 1 2.87e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.20e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.30e-8
R6 4 port2 19.0
.ENDS LQP03TG2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N4C02 port1 port2
C1 port1 port2 5.46e-14
L2 port1 1 2.87e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.20e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.30e-8
R6 4 port2 19.0
.ENDS LQP03TG2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N5B02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.98e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.30e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.40e-8
R6 4 port2 23.0
.ENDS LQP03TG2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N5C02 port1 port2
C1 port1 port2 5.20e-14
L2 port1 1 2.98e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.30e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.40e-8
R6 4 port2 23.0
.ENDS LQP03TG2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N6B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 3.08e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.20e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.40e-8
R6 4 port2 23.0
.ENDS LQP03TG2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N6C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 3.08e-9
R2 1 port2 1.40e-1
R3 port1 port2 5.00e+3
L4 port1 2 1.20e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.40e-8
R6 4 port2 23.0
.ENDS LQP03TG2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N7B02 port1 port2
C1 port1 port2 5.33e-14
L2 port1 1 3.20e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.00e+3
L4 port1 2 1.60e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.60e-8
R6 4 port2 20.0
.ENDS LQP03TG2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N7C02 port1 port2
C1 port1 port2 5.33e-14
L2 port1 1 3.20e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.00e+3
L4 port1 2 1.60e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.60e-8
R6 4 port2 20.0
.ENDS LQP03TG2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N8B02 port1 port2
C1 port1 port2 5.95e-14
L2 port1 1 3.30e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.20e+3
L4 port1 2 1.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.70e-8
R6 4 port2 23.0
.ENDS LQP03TG2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N8C02 port1 port2
C1 port1 port2 5.95e-14
L2 port1 1 3.30e-9
R2 1 port2 1.40e-1
R3 port1 port2 4.20e+3
L4 port1 2 1.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.70e-8
R6 4 port2 23.0
.ENDS LQP03TG2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N9B02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 3.40e-9
R2 1 port2 1.60e-1
R3 port1 port2 4.50e+3
L4 port1 2 1.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.90e-8
R6 4 port2 25.0
.ENDS LQP03TG2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG2N9C02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 3.40e-9
R2 1 port2 1.60e-1
R3 port1 port2 4.50e+3
L4 port1 2 1.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 600
L6 port1 4 2.90e-8
R6 4 port2 25.0
.ENDS LQP03TG2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG33NJ02 port1 port2
C1 port1 port2 4.65e-14
L2 port1 1 3.61e-8
R2 1 port2 2.51
R3 port1 port2 3.61e+4
L4 port1 2 1.97e-6
R4 2 port2 953
L5 port1 3 4.35e-7
R5 3 port2 2.08e+3
L6 port1 4 4.81e-7
R6 4 port2 484
L7 port1 5 1.10e-7
C7 5 6 5.34e-15
R7 6 port2 248
L8 port1 7 1.60e-9
C8 7 8 1.20e-13
R8 8 port2 5.62
L9 port1 9 4.88e-9
C9 9 10 1.42e-14
R9 10 port2 74.2
.ENDS LQP03TG33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG39NJ02 port1 port2
C1 port1 port2 4.34e-14
L2 port1 1 4.45e-8
R2 1 port2 2.94
R3 port1 port2 3.14e+4
L4 port1 2 5.19e-7
R4 2 port2 86.9
L5 port1 3 5.48e-7
R5 3 port2 2.45e+3
L6 port1 4 5.65e-7
R6 4 port2 507
L7 port1 5 1.32e-8
C7 5 6 2.03e-14
R7 6 port2 44.2
L8 port1 7 4.31e-8
C8 7 8 4.25e-15
R8 8 port2 105
L9 port1 9 1.11e-9
C9 9 10 7.79e-14
R9 10 port2 4.45
L10 port1 11 1.86e-9
C10 11 12 3.41e-14
R10 12 port2 12.9
.ENDS LQP03TG39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N0B02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 3.45e-9
R2 1 port2 1.90e-1
R3 port1 port2 4.50e+3
L4 port1 2 1.30e-7
R4 2 port2 650
L5 port1 3 1.60e-7
R5 3 port2 600
L6 port1 4 3.80e-8
R6 4 port2 34.0
.ENDS LQP03TG3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N0C02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 3.45e-9
R2 1 port2 1.90e-1
R3 port1 port2 4.50e+3
L4 port1 2 1.30e-7
R4 2 port2 650
L5 port1 3 1.60e-7
R5 3 port2 600
L6 port1 4 3.80e-8
R6 4 port2 34.0
.ENDS LQP03TG3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N1B02 port1 port2
C1 port1 port2 5.75e-14
L2 port1 1 3.52e-9
R2 1 port2 2.00e-1
R3 port1 port2 7.40e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.25e-7
R5 3 port2 1.60e+3
L6 port1 4 3.40e-8
R6 4 port2 48.0
.ENDS LQP03TG3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N1C02 port1 port2
C1 port1 port2 5.75e-14
L2 port1 1 3.52e-9
R2 1 port2 2.00e-1
R3 port1 port2 7.40e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.25e-7
R5 3 port2 1.60e+3
L6 port1 4 3.40e-8
R6 4 port2 48.0
.ENDS LQP03TG3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N2B02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.63e-9
R2 1 port2 2.10e-1
R3 port1 port2 6.50e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.10e+3
L6 port1 4 3.70e-8
R6 4 port2 48.0
.ENDS LQP03TG3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N2C02 port1 port2
C1 port1 port2 5.83e-14
L2 port1 1 3.63e-9
R2 1 port2 2.10e-1
R3 port1 port2 6.50e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.10e+3
L6 port1 4 3.70e-8
R6 4 port2 48.0
.ENDS LQP03TG3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N3B02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 3.75e-9
R2 1 port2 2.10e-1
R3 port1 port2 6.00e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.10e+3
L6 port1 4 3.70e-8
R6 4 port2 44.0
.ENDS LQP03TG3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N3C02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 3.75e-9
R2 1 port2 2.10e-1
R3 port1 port2 6.00e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.20e-7
R5 3 port2 1.10e+3
L6 port1 4 3.70e-8
R6 4 port2 44.0
.ENDS LQP03TG3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N4B02 port1 port2
C1 port1 port2 6.95e-14
L2 port1 1 3.81e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.30e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.35e-7
R5 3 port2 1.10e+3
L6 port1 4 4.20e-8
R6 4 port2 60.0
.ENDS LQP03TG3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N4C02 port1 port2
C1 port1 port2 6.95e-14
L2 port1 1 3.81e-9
R2 1 port2 2.20e-1
R3 port1 port2 6.30e+3
L4 port1 2 5.00e-6
R4 2 port2 1.50e+3
L5 port1 3 1.35e-7
R5 3 port2 1.10e+3
L6 port1 4 4.20e-8
R6 4 port2 60.0
.ENDS LQP03TG3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N5B02 port1 port2
C1 port1 port2 7.24e-14
L2 port1 1 4.00e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 900
L6 port1 4 3.80e-8
R6 4 port2 40.0
.ENDS LQP03TG3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N5C02 port1 port2
C1 port1 port2 7.24e-14
L2 port1 1 4.00e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 900
L6 port1 4 3.80e-8
R6 4 port2 40.0
.ENDS LQP03TG3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N6B02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 4.10e-9
R2 1 port2 2.15e-1
R3 port1 port2 6.00e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 1.05e+3
L6 port1 4 4.00e-8
R6 4 port2 40.0
.ENDS LQP03TG3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N6C02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 4.10e-9
R2 1 port2 2.15e-1
R3 port1 port2 6.00e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 1.05e+3
L6 port1 4 4.00e-8
R6 4 port2 40.0
.ENDS LQP03TG3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N7B02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 4.25e-9
R2 1 port2 2.15e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 1.05e+3
L6 port1 4 3.70e-8
R6 4 port2 39.0
.ENDS LQP03TG3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N7C02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 4.25e-9
R2 1 port2 2.15e-1
R3 port1 port2 6.50e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.25e-7
R5 3 port2 1.05e+3
L6 port1 4 3.70e-8
R6 4 port2 39.0
.ENDS LQP03TG3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N8B02 port1 port2
C1 port1 port2 9.05e-14
L2 port1 1 4.35e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-7
R5 3 port2 1.05e+3
L6 port1 4 3.90e-8
R6 4 port2 40.0
.ENDS LQP03TG3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N8C02 port1 port2
C1 port1 port2 9.05e-14
L2 port1 1 4.35e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-7
R5 3 port2 1.05e+3
L6 port1 4 3.90e-8
R6 4 port2 40.0
.ENDS LQP03TG3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N9B02 port1 port2
C1 port1 port2 9.95e-14
L2 port1 1 4.45e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-7
R5 3 port2 1.05e+3
L6 port1 4 4.10e-8
R6 4 port2 45.0
.ENDS LQP03TG3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG3N9C02 port1 port2
C1 port1 port2 9.95e-14
L2 port1 1 4.45e-9
R2 1 port2 2.15e-1
R3 port1 port2 5.60e+3
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.40e-7
R5 3 port2 1.05e+3
L6 port1 4 4.10e-8
R6 4 port2 45.0
.ENDS LQP03TG3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG47NJ02 port1 port2
C1 port1 port2 4.76e-15
L2 port1 1 5.35e-8
R2 1 port2 3.01
R3 port1 port2 3.14e+4
L4 port1 2 5.19e-7
R4 2 port2 86.9
L5 port1 3 6.74e-7
R5 3 port2 2.68e+3
L6 port1 4 8.55e-7
R6 4 port2 767
L7 port1 5 3.63e-8
C7 5 6 9.71e-15
R7 6 port2 106
L8 port1 7 7.15e-9
C8 7 8 1.94e-14
R8 8 port2 20.0
L9 port1 9 7.86e-10
C9 9 10 1.15e-13
R9 10 port2 4.66
L10 port1 11 9.09e-10
C10 11 12 4.20e-14
R10 12 port2 7.09e-1
.ENDS LQP03TG47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG4N3H02 port1 port2
C1 port1 port2 9.27e-14
L2 port1 1 4.80e-9
R2 1 port2 3.70e-1
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.20e-7
R5 3 port2 1.05e+3
L6 port1 4 5.70e-8
R6 4 port2 65.0
.ENDS LQP03TG4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG4N3J02 port1 port2
C1 port1 port2 9.27e-14
L2 port1 1 4.80e-9
R2 1 port2 3.70e-1
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-6
R4 2 port2 1.20e+3
L5 port1 3 1.20e-7
R5 3 port2 1.05e+3
L6 port1 4 5.70e-8
R6 4 port2 65.0
.ENDS LQP03TG4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG4N7H02 port1 port2
C1 port1 port2 8.95e-14
L2 port1 1 5.15e-9
R2 1 port2 4.30e-1
R3 port1 port2 9.00e+3
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 1.30e-7
R5 3 port2 1.05e+3
L6 port1 4 8.00e-8
R6 4 port2 90.0
.ENDS LQP03TG4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG4N7J02 port1 port2
C1 port1 port2 8.95e-14
L2 port1 1 5.15e-9
R2 1 port2 4.30e-1
R3 port1 port2 9.00e+3
L4 port1 2 1.20e-6
R4 2 port2 1.20e+3
L5 port1 3 1.30e-7
R5 3 port2 1.05e+3
L6 port1 4 8.00e-8
R6 4 port2 90.0
.ENDS LQP03TG4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG56NJ02 port1 port2
C1 port1 port2 2.80e-15
L2 port1 1 6.74e-8
R2 1 port2 3.07
R3 port1 port2 3.07e+4
L4 port1 2 7.27e-7
R4 2 port2 359
L5 port1 3 5.33e-7
R5 3 port2 50.8
L6 port1 4 5.78e-7
R6 4 port2 1.75e+3
L7 port1 5 4.07e-8
C7 5 6 1.09e-14
R7 6 port2 106
L8 port1 7 2.70e-8
C8 7 8 8.41e-15
R8 8 port2 91.2
L9 port1 9 7.51e-10
C9 9 10 1.45e-13
R9 10 port2 4.06
L10 port1 11 1.02e-9
C10 11 12 4.71e-14
R10 12 port2 4.37e-1
.ENDS LQP03TG56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG5N1H02 port1 port2
C1 port1 port2 8.28e-14
L2 port1 1 5.65e-9
R2 1 port2 3.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.00e-6
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 1.05e+3
L6 port1 4 7.00e-8
R6 4 port2 90.0
.ENDS LQP03TG5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG5N1J02 port1 port2
C1 port1 port2 8.28e-14
L2 port1 1 5.65e-9
R2 1 port2 3.80e-1
R3 port1 port2 7.00e+3
L4 port1 2 1.00e-6
R4 2 port2 1.20e+3
L5 port1 3 1.50e-7
R5 3 port2 1.05e+3
L6 port1 4 7.00e-8
R6 4 port2 90.0
.ENDS LQP03TG5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG5N6H02 port1 port2
C1 port1 port2 7.95e-14
L2 port1 1 6.10e-9
R2 1 port2 5.50e-1
R3 port1 port2 7.00e+3
L4 port1 2 6.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.70e-7
R5 3 port2 1.08e+3
L6 port1 4 1.05e-7
R6 4 port2 125
.ENDS LQP03TG5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG5N6J02 port1 port2
C1 port1 port2 7.95e-14
L2 port1 1 6.10e-9
R2 1 port2 5.50e-1
R3 port1 port2 7.00e+3
L4 port1 2 6.80e-7
R4 2 port2 1.20e+3
L5 port1 3 1.70e-7
R5 3 port2 1.08e+3
L6 port1 4 1.05e-7
R6 4 port2 125
.ENDS LQP03TG5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG68NJ02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG68NJ02 port1 port2
C1 port1 port2 7.39e-14
L2 port1 1 7.33e-8
R2 1 port2 3.71
R3 port1 port2 2.93e+4
L4 port1 2 7.34e-7
R4 2 port2 2.24e+3
L5 port1 3 1.13e-6
R5 3 port2 370
L6 port1 4 2.19e-6
R6 4 port2 2.16e+3
L7 port1 5 2.10e-8
C7 5 6 2.51e-14
R7 6 port2 53.5
L8 port1 7 4.16e-9
C8 7 8 4.74e-14
R8 8 port2 16.5
L9 port1 9 1.42e-9
C9 9 10 5.74e-14
R9 10 port2 7.33
.ENDS LQP03TG68NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG6N2H02 port1 port2
C1 port1 port2 7.62e-14
L2 port1 1 6.70e-9
R2 1 port2 6.30e-1
R3 port1 port2 8.50e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 1.70e-7
R5 3 port2 1.08e+3
L6 port1 4 1.40e-7
R6 4 port2 120
.ENDS LQP03TG6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG6N2J02 port1 port2
C1 port1 port2 7.62e-14
L2 port1 1 6.70e-9
R2 1 port2 6.30e-1
R3 port1 port2 8.50e+3
L4 port1 2 5.00e-7
R4 2 port2 1.20e+3
L5 port1 3 1.70e-7
R5 3 port2 1.08e+3
L6 port1 4 1.40e-7
R6 4 port2 120
.ENDS LQP03TG6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG6N8H02 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 7.40e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.60e+3
L4 port1 2 4.20e-7
R4 2 port2 1.20e+3
L5 port1 3 2.50e-7
R5 3 port2 1.08e+3
L6 port1 4 1.30e-7
R6 4 port2 110
.ENDS LQP03TG6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG6N8J02 port1 port2
C1 port1 port2 9.60e-14
L2 port1 1 7.40e-9
R2 1 port2 6.20e-1
R3 port1 port2 5.60e+3
L4 port1 2 4.20e-7
R4 2 port2 1.20e+3
L5 port1 3 2.50e-7
R5 3 port2 1.08e+3
L6 port1 4 1.30e-7
R6 4 port2 110
.ENDS LQP03TG6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG7N5H02 port1 port2
C1 port1 port2 1.09e-13
L2 port1 1 8.15e-9
R2 1 port2 7.40e-1
R3 port1 port2 5.50e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.43e-7
R6 4 port2 120
.ENDS LQP03TG7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG7N5J02 port1 port2
C1 port1 port2 1.09e-13
L2 port1 1 8.15e-9
R2 1 port2 7.40e-1
R3 port1 port2 5.50e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.43e-7
R6 4 port2 120
.ENDS LQP03TG7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG82NJ02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG82NJ02 port1 port2
C1 port1 port2 3.53e-14
L2 port1 1 8.79e-8
R2 1 port2 4.46
R3 port1 port2 4.04e+4
L4 port1 2 7.56e-7
R4 2 port2 2.28e+3
L5 port1 3 1.21e-6
R5 3 port2 683
L6 port1 4 3.59e-6
R6 4 port2 790
L7 port1 5 3.83e-8
C7 5 6 1.74e-14
R7 6 port2 86.7
L8 port1 7 6.34e-5
C8 7 8 6.37e-17
R8 8 port2 5.51e+4
L9 port1 9 5.62e-9
C9 9 10 2.79e-14
R9 10 port2 45.4
L10 port1 11 6.62e-10
C10 11 12 1.28e-13
R10 12 port2 2.99
.ENDS LQP03TG82NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG8N2H02 port1 port2
C1 port1 port2 8.05e-14
L2 port1 1 8.93e-9
R2 1 port2 8.80e-1
R3 port1 port2 6.80e+3
L4 port1 2 2.50e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 88.0
.ENDS LQP03TG8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG8N2J02 port1 port2
C1 port1 port2 8.05e-14
L2 port1 1 8.93e-9
R2 1 port2 8.80e-1
R3 port1 port2 6.80e+3
L4 port1 2 2.50e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 88.0
.ENDS LQP03TG8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG9N1H02 port1 port2
C1 port1 port2 1.04e-13
L2 port1 1 9.95e-9
R2 1 port2 9.80e-1
R3 port1 port2 6.00e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 90.0
.ENDS LQP03TG9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TG9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TG9N1J02 port1 port2
C1 port1 port2 1.04e-13
L2 port1 1 9.95e-9
R2 1 port2 9.80e-1
R3 port1 port2 6.00e+3
L4 port1 2 3.00e-7
R4 2 port2 1.20e+3
L5 port1 3 4.00e-7
R5 3 port2 1.08e+3
L6 port1 4 1.58e-7
R6 4 port2 90.0
.ENDS LQP03TG9N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TGR10J02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TGR10J02 port1 port2
C1 port1 port2 5.27e-14
L2 port1 1 1.06e-7
R2 1 port2 4.69
R3 port1 port2 3.07e+4
L4 port1 2 1.06e-6
R4 2 port2 3.20e+3
L5 port1 3 2.10e-6
R5 3 port2 2.54e+3
L6 port1 4 1.88e-6
R6 4 port2 695
L7 port1 5 8.08e-8
C7 5 6 1.16e-14
R7 6 port2 184
L8 port1 7 4.13e-8
C8 7 8 5.06e-15
R8 8 port2 224
L9 port1 9 9.92e-10
C9 9 10 1.16e-13
R9 10 port2 4.85
L10 port1 11 2.38e-9
C10 11 12 2.58e-14
R10 12 port2 11.7
.ENDS LQP03TGR10J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03TGR12J02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03TGR12J02 port1 port2
C1 port1 port2 2.20e-15
L2 port1 1 1.28e-7
R2 1 port2 5.38
R3 port1 port2 2.67e+4
L4 port1 2 1.13e-6
R4 2 port2 2.55e+3
L5 port1 3 1.22e-6
R5 3 port2 358
L6 port1 4 8.22e-6
R6 4 port2 738
L7 port1 5 7.37e-8
C7 5 6 1.46e-14
R7 6 port2 157
L8 port1 7 1.30e-6
C8 7 8 2.21e-15
R8 8 port2 1.68e+3
L9 port1 9 3.21e-8
C9 9 10 9.41e-15
R9 10 port2 91.3
L10 port1 11 1.04e-9
C10 11 12 9.17e-14
R10 12 port2 4.85
L11 port1 13 4.15e-10
C11 13 14 1.02e-13
R11 14 port2 4.14
.ENDS LQP03TGR12J02
*----------------------------------------------------------------------
