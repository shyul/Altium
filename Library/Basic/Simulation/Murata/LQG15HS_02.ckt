*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS10NG02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS10NG02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 1.35e-8
R2 1 port2 1.83e-1
R3 port1 port2 1.33e+4
L4 port1 2 2.28e-7
R4 2 port2 866
L5 port1 3 1.02e-7
R5 3 port2 53.2
L6 port1 4 5.64e-8
R6 4 port2 3.91
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.05e-9
C8 7 8 8.82e-14
R8 8 port2 2.34
L9 port1 9 1.07e-7
C9 9 10 1.21e-15
R9 10 port2 102
L10 port1 11 3.06e-9
C10 11 12 2.10e-14
R10 12 port2 19.2
.ENDS LQG15HS10NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS10NH02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 1.35e-8
R2 1 port2 1.83e-1
R3 port1 port2 1.33e+4
L4 port1 2 2.28e-7
R4 2 port2 866
L5 port1 3 1.02e-7
R5 3 port2 53.2
L6 port1 4 5.64e-8
R6 4 port2 3.91
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.05e-9
C8 7 8 8.82e-14
R8 8 port2 2.34
L9 port1 9 1.07e-7
C9 9 10 1.21e-15
R9 10 port2 102
L10 port1 11 3.06e-9
C10 11 12 2.10e-14
R10 12 port2 19.2
.ENDS LQG15HS10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS10NJ02 port1 port2
C1 port1 port2 4.80e-14
L2 port1 1 1.35e-8
R2 1 port2 1.83e-1
R3 port1 port2 1.33e+4
L4 port1 2 2.28e-7
R4 2 port2 866
L5 port1 3 1.02e-7
R5 3 port2 53.2
L6 port1 4 5.64e-8
R6 4 port2 3.91
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.05e-9
C8 7 8 8.82e-14
R8 8 port2 2.34
L9 port1 9 1.07e-7
C9 9 10 1.21e-15
R9 10 port2 102
L10 port1 11 3.06e-9
C10 11 12 2.10e-14
R10 12 port2 19.2
.ENDS LQG15HS10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS12NG02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS12NG02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.52e-8
R2 1 port2 1.78e-1
R3 port1 port2 1.01e+4
L4 port1 2 2.62e-7
R4 2 port2 827
L5 port1 3 1.28e-7
R5 3 port2 64.0
L6 port1 4 7.78e-8
R6 4 port2 6.05
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.15e-9
C8 7 8 1.01e-13
R8 8 port2 3.02
L9 port1 9 8.72e-9
C9 9 10 1.56e-14
R9 10 port2 8.12
L10 port1 11 9.04e-10
C10 11 12 7.45e-14
R10 12 port2 3.49
.ENDS LQG15HS12NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS12NH02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.52e-8
R2 1 port2 1.78e-1
R3 port1 port2 1.01e+4
L4 port1 2 2.62e-7
R4 2 port2 827
L5 port1 3 1.28e-7
R5 3 port2 64.0
L6 port1 4 7.78e-8
R6 4 port2 6.05
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.15e-9
C8 7 8 1.01e-13
R8 8 port2 3.02
L9 port1 9 8.72e-9
C9 9 10 1.56e-14
R9 10 port2 8.12
L10 port1 11 9.04e-10
C10 11 12 7.45e-14
R10 12 port2 3.49
.ENDS LQG15HS12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS12NJ02 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 1.52e-8
R2 1 port2 1.78e-1
R3 port1 port2 1.01e+4
L4 port1 2 2.62e-7
R4 2 port2 827
L5 port1 3 1.28e-7
R5 3 port2 64.0
L6 port1 4 7.78e-8
R6 4 port2 6.05
L7 port1 5 1.43e-7
C7 5 6 1.73e-15
R7 6 port2 152
L8 port1 7 1.15e-9
C8 7 8 1.01e-13
R8 8 port2 3.02
L9 port1 9 8.72e-9
C9 9 10 1.56e-14
R9 10 port2 8.12
L10 port1 11 9.04e-10
C10 11 12 7.45e-14
R10 12 port2 3.49
.ENDS LQG15HS12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS15NG02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS15NG02 port1 port2
C1 port1 port2 4.79e-15
L2 port1 1 1.90e-8
R2 1 port2 2.09e-1
R3 port1 port2 1.33e+4
L4 port1 2 3.08e-7
R4 2 port2 950
L5 port1 3 1.57e-7
R5 3 port2 78.7
L6 port1 4 1.03e-7
R6 4 port2 7.98
L7 port1 5 1.35e-9
C7 5 6 1.05e-13
R7 6 port2 6.16
L8 port1 7 8.63e-10
C8 7 8 8.55e-14
R8 8 port2 9.39e-1
.ENDS LQG15HS15NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS15NH02 port1 port2
C1 port1 port2 4.79e-15
L2 port1 1 1.90e-8
R2 1 port2 2.09e-1
R3 port1 port2 1.33e+4
L4 port1 2 3.08e-7
R4 2 port2 950
L5 port1 3 1.57e-7
R5 3 port2 78.7
L6 port1 4 1.03e-7
R6 4 port2 7.98
L7 port1 5 1.35e-9
C7 5 6 1.05e-13
R7 6 port2 6.16
L8 port1 7 8.63e-10
C8 7 8 8.55e-14
R8 8 port2 9.39e-1
.ENDS LQG15HS15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS15NJ02 port1 port2
C1 port1 port2 4.79e-15
L2 port1 1 1.90e-8
R2 1 port2 2.09e-1
R3 port1 port2 1.33e+4
L4 port1 2 3.08e-7
R4 2 port2 950
L5 port1 3 1.57e-7
R5 3 port2 78.7
L6 port1 4 1.03e-7
R6 4 port2 7.98
L7 port1 5 1.35e-9
C7 5 6 1.05e-13
R7 6 port2 6.16
L8 port1 7 8.63e-10
C8 7 8 8.55e-14
R8 8 port2 9.39e-1
.ENDS LQG15HS15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS18NG02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS18NG02 port1 port2
C1 port1 port2 8.52e-15
L2 port1 1 2.28e-8
R2 1 port2 2.40e-1
R3 port1 port2 1.46e+4
L4 port1 2 3.88e-7
R4 2 port2 1.25e+3
L5 port1 3 1.77e-7
R5 3 port2 88.3
L6 port1 4 1.18e-7
R6 4 port2 9.16
L7 port1 5 5.13e-9
C7 5 6 3.34e-14
R7 6 port2 11.7
L8 port1 7 4.85e-10
C8 7 8 1.45e-13
R8 8 port2 1.10
.ENDS LQG15HS18NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS18NH02 port1 port2
C1 port1 port2 8.52e-15
L2 port1 1 2.28e-8
R2 1 port2 2.40e-1
R3 port1 port2 1.46e+4
L4 port1 2 3.88e-7
R4 2 port2 1.25e+3
L5 port1 3 1.77e-7
R5 3 port2 88.3
L6 port1 4 1.18e-7
R6 4 port2 9.16
L7 port1 5 5.13e-9
C7 5 6 3.34e-14
R7 6 port2 11.7
L8 port1 7 4.85e-10
C8 7 8 1.45e-13
R8 8 port2 1.10
.ENDS LQG15HS18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS18NJ02 port1 port2
C1 port1 port2 8.52e-15
L2 port1 1 2.28e-8
R2 1 port2 2.40e-1
R3 port1 port2 1.46e+4
L4 port1 2 3.88e-7
R4 2 port2 1.25e+3
L5 port1 3 1.77e-7
R5 3 port2 88.3
L6 port1 4 1.18e-7
R6 4 port2 9.16
L7 port1 5 5.13e-9
C7 5 6 3.34e-14
R7 6 port2 11.7
L8 port1 7 4.85e-10
C8 7 8 1.45e-13
R8 8 port2 1.10
.ENDS LQG15HS18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N0B02 port1 port2
C1 port1 port2 7.26e-15
L2 port1 1 1.38e-9
R2 1 port2 1.97e-2
R3 port1 port2 3.50e+3
L4 port1 2 3.78e-8
R4 2 port2 114
L5 port1 3 1.34e-8
R5 3 port2 4.96
L6 port1 4 1.26e-7
R6 4 port2 23.3
L7 port1 5 7.81e-10
C7 5 6 8.23e-14
R7 6 port2 6.03e-1
.ENDS LQG15HS1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N0C02 port1 port2
C1 port1 port2 7.26e-15
L2 port1 1 1.38e-9
R2 1 port2 1.97e-2
R3 port1 port2 3.50e+3
L4 port1 2 3.78e-8
R4 2 port2 114
L5 port1 3 1.34e-8
R5 3 port2 4.96
L6 port1 4 1.26e-7
R6 4 port2 23.3
L7 port1 5 7.81e-10
C7 5 6 8.23e-14
R7 6 port2 6.03e-1
.ENDS LQG15HS1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N0S02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N0S02 port1 port2
C1 port1 port2 7.26e-15
L2 port1 1 1.38e-9
R2 1 port2 1.97e-2
R3 port1 port2 3.50e+3
L4 port1 2 3.78e-8
R4 2 port2 114
L5 port1 3 1.34e-8
R5 3 port2 4.96
L6 port1 4 1.26e-7
R6 4 port2 23.3
L7 port1 5 7.81e-10
C7 5 6 8.23e-14
R7 6 port2 6.03e-1
.ENDS LQG15HS1N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N1B02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.55e-9
R2 1 port2 1.93e-2
R3 port1 port2 3.58e+3
L4 port1 2 4.89e-8
R4 2 port2 177
L5 port1 3 2.85e-8
R5 3 port2 20.7
L6 port1 4 1.51e-8
R6 4 port2 2.50
L7 port1 5 3.74e-8
C7 5 6 3.43e-15
R7 6 port2 97.8
L8 port1 7 7.35e-10
C8 7 8 1.10e-13
R8 8 port2 5.54e-1
.ENDS LQG15HS1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N1C02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.55e-9
R2 1 port2 1.93e-2
R3 port1 port2 3.58e+3
L4 port1 2 4.89e-8
R4 2 port2 177
L5 port1 3 2.85e-8
R5 3 port2 20.7
L6 port1 4 1.51e-8
R6 4 port2 2.50
L7 port1 5 3.74e-8
C7 5 6 3.43e-15
R7 6 port2 97.8
L8 port1 7 7.35e-10
C8 7 8 1.10e-13
R8 8 port2 5.54e-1
.ENDS LQG15HS1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N1S02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N1S02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.55e-9
R2 1 port2 1.93e-2
R3 port1 port2 3.58e+3
L4 port1 2 4.89e-8
R4 2 port2 177
L5 port1 3 2.85e-8
R5 3 port2 20.7
L6 port1 4 1.51e-8
R6 4 port2 2.50
L7 port1 5 3.74e-8
C7 5 6 3.43e-15
R7 6 port2 97.8
L8 port1 7 7.35e-10
C8 7 8 1.10e-13
R8 8 port2 5.54e-1
.ENDS LQG15HS1N1S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N2B02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.65e-9
R2 1 port2 2.16e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.56e-8
R4 2 port2 155
L5 port1 3 2.85e-8
R5 3 port2 16.4
L6 port1 4 1.70e-8
R6 4 port2 2.80
L7 port1 5 3.74e-8
C7 5 6 3.59e-15
R7 6 port2 30.2
L8 port1 7 7.69e-10
C8 7 8 1.45e-13
R8 8 port2 8.20e-1
.ENDS LQG15HS1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N2C02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.65e-9
R2 1 port2 2.16e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.56e-8
R4 2 port2 155
L5 port1 3 2.85e-8
R5 3 port2 16.4
L6 port1 4 1.70e-8
R6 4 port2 2.80
L7 port1 5 3.74e-8
C7 5 6 3.59e-15
R7 6 port2 30.2
L8 port1 7 7.69e-10
C8 7 8 1.45e-13
R8 8 port2 8.20e-1
.ENDS LQG15HS1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N2S02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N2S02 port1 port2
C1 port1 port2 6.18e-17
L2 port1 1 1.65e-9
R2 1 port2 2.16e-2
R3 port1 port2 3.50e+3
L4 port1 2 4.56e-8
R4 2 port2 155
L5 port1 3 2.85e-8
R5 3 port2 16.4
L6 port1 4 1.70e-8
R6 4 port2 2.80
L7 port1 5 3.74e-8
C7 5 6 3.59e-15
R7 6 port2 30.2
L8 port1 7 7.69e-10
C8 7 8 1.45e-13
R8 8 port2 8.20e-1
.ENDS LQG15HS1N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N3B02 port1 port2
C1 port1 port2 6.93e-15
L2 port1 1 1.69e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.12e-8
R4 2 port2 138
L5 port1 3 3.49e-8
R5 3 port2 13.3
L6 port1 4 2.38e-8
R6 4 port2 6.31
L7 port1 5 5.41e-8
C7 5 6 2.37e-15
R7 6 port2 44.7
L8 port1 7 7.69e-10
C8 7 8 2.19e-13
R8 8 port2 5.94e-1
.ENDS LQG15HS1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N3C02 port1 port2
C1 port1 port2 6.93e-15
L2 port1 1 1.69e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.12e-8
R4 2 port2 138
L5 port1 3 3.49e-8
R5 3 port2 13.3
L6 port1 4 2.38e-8
R6 4 port2 6.31
L7 port1 5 5.41e-8
C7 5 6 2.37e-15
R7 6 port2 44.7
L8 port1 7 7.69e-10
C8 7 8 2.19e-13
R8 8 port2 5.94e-1
.ENDS LQG15HS1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N3S02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N3S02 port1 port2
C1 port1 port2 6.93e-15
L2 port1 1 1.69e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.12e-8
R4 2 port2 138
L5 port1 3 3.49e-8
R5 3 port2 13.3
L6 port1 4 2.38e-8
R6 4 port2 6.31
L7 port1 5 5.41e-8
C7 5 6 2.37e-15
R7 6 port2 44.7
L8 port1 7 7.69e-10
C8 7 8 2.19e-13
R8 8 port2 5.94e-1
.ENDS LQG15HS1N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N5B02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.01e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.41e-8
R4 2 port2 144
L5 port1 3 2.05e-8
R5 3 port2 7.85
L6 port1 4 2.17e-8
R6 4 port2 3.09
L7 port1 5 1.76e-7
C7 5 6 7.36e-16
R7 6 port2 145
L8 port1 7 6.08e-10
C8 7 8 1.15e-13
R8 8 port2 4.30e-1
.ENDS LQG15HS1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N5C02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.01e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.41e-8
R4 2 port2 144
L5 port1 3 2.05e-8
R5 3 port2 7.85
L6 port1 4 2.17e-8
R6 4 port2 3.09
L7 port1 5 1.76e-7
C7 5 6 7.36e-16
R7 6 port2 145
L8 port1 7 6.08e-10
C8 7 8 1.15e-13
R8 8 port2 4.30e-1
.ENDS LQG15HS1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N5S02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N5S02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.01e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.41e-8
R4 2 port2 144
L5 port1 3 2.05e-8
R5 3 port2 7.85
L6 port1 4 2.17e-8
R6 4 port2 3.09
L7 port1 5 1.76e-7
C7 5 6 7.36e-16
R7 6 port2 145
L8 port1 7 6.08e-10
C8 7 8 1.15e-13
R8 8 port2 4.30e-1
.ENDS LQG15HS1N5S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N6B02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.09e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.62e-8
R4 2 port2 141
L5 port1 3 1.45e-8
R5 3 port2 4.73
L6 port1 4 7.37e-8
R6 4 port2 5.01
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 79.4
L8 port1 7 6.87e-10
C8 7 8 1.36e-13
R8 8 port2 5.06e-1
.ENDS LQG15HS1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N6C02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.09e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.62e-8
R4 2 port2 141
L5 port1 3 1.45e-8
R5 3 port2 4.73
L6 port1 4 7.37e-8
R6 4 port2 5.01
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 79.4
L8 port1 7 6.87e-10
C8 7 8 1.36e-13
R8 8 port2 5.06e-1
.ENDS LQG15HS1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N6S02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N6S02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.09e-9
R2 1 port2 2.48e-2
R3 port1 port2 4.21e+3
L4 port1 2 4.62e-8
R4 2 port2 141
L5 port1 3 1.45e-8
R5 3 port2 4.73
L6 port1 4 7.37e-8
R6 4 port2 5.01
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 79.4
L8 port1 7 6.87e-10
C8 7 8 1.36e-13
R8 8 port2 5.06e-1
.ENDS LQG15HS1N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N8B02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.82e-9
R2 1 port2 5.30e-2
R3 port1 port2 5.18e+3
L4 port1 2 4.21e-8
R4 2 port2 129
L5 port1 3 1.13e-8
R5 3 port2 3.93
L6 port1 4 2.12e-8
R6 4 port2 1.45
L7 port1 5 3.52e-8
C7 5 6 3.70e-15
R7 6 port2 28.8
L8 port1 7 6.14e-10
C8 7 8 1.75e-13
R8 8 port2 6.22e-1
.ENDS LQG15HS1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N8C02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.82e-9
R2 1 port2 5.30e-2
R3 port1 port2 5.18e+3
L4 port1 2 4.21e-8
R4 2 port2 129
L5 port1 3 1.13e-8
R5 3 port2 3.93
L6 port1 4 2.12e-8
R6 4 port2 1.45
L7 port1 5 3.52e-8
C7 5 6 3.70e-15
R7 6 port2 28.8
L8 port1 7 6.14e-10
C8 7 8 1.75e-13
R8 8 port2 6.22e-1
.ENDS LQG15HS1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS1N8S02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS1N8S02 port1 port2
C1 port1 port2 4.38e-16
L2 port1 1 2.82e-9
R2 1 port2 5.30e-2
R3 port1 port2 5.18e+3
L4 port1 2 4.21e-8
R4 2 port2 129
L5 port1 3 1.13e-8
R5 3 port2 3.93
L6 port1 4 2.12e-8
R6 4 port2 1.45
L7 port1 5 3.52e-8
C7 5 6 3.70e-15
R7 6 port2 28.8
L8 port1 7 6.14e-10
C8 7 8 1.75e-13
R8 8 port2 6.22e-1
.ENDS LQG15HS1N8S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS22NG02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS22NG02 port1 port2
C1 port1 port2 4.27e-14
L2 port1 1 2.81e-8
R2 1 port2 2.69e-1
R3 port1 port2 1.64e+4
L4 port1 2 4.45e-7
R4 2 port2 1.44e+3
L5 port1 3 2.12e-7
R5 3 port2 106
L6 port1 4 1.35e-7
R6 4 port2 11.3
L7 port1 5 8.72e-9
C7 5 6 2.47e-14
R7 6 port2 17.8
L8 port1 7 6.55e-10
C8 7 8 1.24e-13
R8 8 port2 1.30
L9 port1 9 1.94e-8
C9 9 10 6.62e-15
R9 10 port2 68.7
.ENDS LQG15HS22NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS22NH02 port1 port2
C1 port1 port2 4.27e-14
L2 port1 1 2.81e-8
R2 1 port2 2.69e-1
R3 port1 port2 1.64e+4
L4 port1 2 4.45e-7
R4 2 port2 1.44e+3
L5 port1 3 2.12e-7
R5 3 port2 106
L6 port1 4 1.35e-7
R6 4 port2 11.3
L7 port1 5 8.72e-9
C7 5 6 2.47e-14
R7 6 port2 17.8
L8 port1 7 6.55e-10
C8 7 8 1.24e-13
R8 8 port2 1.30
L9 port1 9 1.94e-8
C9 9 10 6.62e-15
R9 10 port2 68.7
.ENDS LQG15HS22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS22NJ02 port1 port2
C1 port1 port2 4.27e-14
L2 port1 1 2.81e-8
R2 1 port2 2.69e-1
R3 port1 port2 1.64e+4
L4 port1 2 4.45e-7
R4 2 port2 1.44e+3
L5 port1 3 2.12e-7
R5 3 port2 106
L6 port1 4 1.35e-7
R6 4 port2 11.3
L7 port1 5 8.72e-9
C7 5 6 2.47e-14
R7 6 port2 17.8
L8 port1 7 6.55e-10
C8 7 8 1.24e-13
R8 8 port2 1.30
L9 port1 9 1.94e-8
C9 9 10 6.62e-15
R9 10 port2 68.7
.ENDS LQG15HS22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS27NG02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS27NG02 port1 port2
C1 port1 port2 5.02e-15
L2 port1 1 3.54e-8
R2 1 port2 3.09e-1
R3 port1 port2 1.93e+4
L4 port1 2 4.88e-7
R4 2 port2 1.51e+3
L5 port1 3 2.79e-7
R5 3 port2 140
L6 port1 4 1.55e-7
R6 4 port2 14.2
L7 port1 5 2.04e-8
C7 5 6 1.45e-14
R7 6 port2 35.5
L8 port1 7 9.47e-10
C8 7 8 9.85e-14
R8 8 port2 1.75
L9 port1 9 1.41e-8
C9 9 10 9.14e-15
R9 10 port2 49.8
L10 port1 11 6.42e-10
C10 11 12 1.00e-13
R10 12 port2 3.26
.ENDS LQG15HS27NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS27NH02 port1 port2
C1 port1 port2 5.02e-15
L2 port1 1 3.54e-8
R2 1 port2 3.09e-1
R3 port1 port2 1.93e+4
L4 port1 2 4.88e-7
R4 2 port2 1.51e+3
L5 port1 3 2.79e-7
R5 3 port2 140
L6 port1 4 1.55e-7
R6 4 port2 14.2
L7 port1 5 2.04e-8
C7 5 6 1.45e-14
R7 6 port2 35.5
L8 port1 7 9.47e-10
C8 7 8 9.85e-14
R8 8 port2 1.75
L9 port1 9 1.41e-8
C9 9 10 9.14e-15
R9 10 port2 49.8
L10 port1 11 6.42e-10
C10 11 12 1.00e-13
R10 12 port2 3.26
.ENDS LQG15HS27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS27NJ02 port1 port2
C1 port1 port2 5.02e-15
L2 port1 1 3.54e-8
R2 1 port2 3.09e-1
R3 port1 port2 1.93e+4
L4 port1 2 4.88e-7
R4 2 port2 1.51e+3
L5 port1 3 2.79e-7
R5 3 port2 140
L6 port1 4 1.55e-7
R6 4 port2 14.2
L7 port1 5 2.04e-8
C7 5 6 1.45e-14
R7 6 port2 35.5
L8 port1 7 9.47e-10
C8 7 8 9.85e-14
R8 8 port2 1.75
L9 port1 9 1.41e-8
C9 9 10 9.14e-15
R9 10 port2 49.8
L10 port1 11 6.42e-10
C10 11 12 1.00e-13
R10 12 port2 3.26
.ENDS LQG15HS27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N0B02 port1 port2
C1 port1 port2 3.81e-16
L2 port1 1 2.63e-9
R2 1 port2 2.78e-2
R3 port1 port2 6.67e+3
L4 port1 2 5.68e-8
R4 2 port2 199
L5 port1 3 2.05e-8
R5 3 port2 7.16
L6 port1 4 7.89e-8
R6 4 port2 7.59
L7 port1 5 7.52e-9
C7 5 6 1.65e-14
R7 6 port2 10.7
L8 port1 7 7.39e-10
C8 7 8 1.84e-13
R8 8 port2 2.84
L9 port1 9 4.47e-9
C9 9 10 1.40e-14
R9 10 port2 11.6
.ENDS LQG15HS2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N0C02 port1 port2
C1 port1 port2 3.81e-16
L2 port1 1 2.63e-9
R2 1 port2 2.78e-2
R3 port1 port2 6.67e+3
L4 port1 2 5.68e-8
R4 2 port2 199
L5 port1 3 2.05e-8
R5 3 port2 7.16
L6 port1 4 7.89e-8
R6 4 port2 7.59
L7 port1 5 7.52e-9
C7 5 6 1.65e-14
R7 6 port2 10.7
L8 port1 7 7.39e-10
C8 7 8 1.84e-13
R8 8 port2 2.84
L9 port1 9 4.47e-9
C9 9 10 1.40e-14
R9 10 port2 11.6
.ENDS LQG15HS2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N0S02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N0S02 port1 port2
C1 port1 port2 3.81e-16
L2 port1 1 2.63e-9
R2 1 port2 2.78e-2
R3 port1 port2 6.67e+3
L4 port1 2 5.68e-8
R4 2 port2 199
L5 port1 3 2.05e-8
R5 3 port2 7.16
L6 port1 4 7.89e-8
R6 4 port2 7.59
L7 port1 5 7.52e-9
C7 5 6 1.65e-14
R7 6 port2 10.7
L8 port1 7 7.39e-10
C8 7 8 1.84e-13
R8 8 port2 2.84
L9 port1 9 4.47e-9
C9 9 10 1.40e-14
R9 10 port2 11.6
.ENDS LQG15HS2N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N2B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 2.99e-9
R2 1 port2 5.18e-2
R3 port1 port2 7.48e+3
L4 port1 2 5.43e-8
R4 2 port2 195
L5 port1 3 1.75e-8
R5 3 port2 6.09
L6 port1 4 2.61e-8
R6 4 port2 2.51
L7 port1 5 9.04e-9
C7 5 6 1.37e-14
R7 6 port2 10.2
L8 port1 7 6.89e-10
C8 7 8 1.97e-13
R8 8 port2 2.53
L9 port1 9 4.93e-9
C9 9 10 1.22e-14
R9 10 port2 13.0
.ENDS LQG15HS2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N2C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 2.99e-9
R2 1 port2 5.18e-2
R3 port1 port2 7.48e+3
L4 port1 2 5.43e-8
R4 2 port2 195
L5 port1 3 1.75e-8
R5 3 port2 6.09
L6 port1 4 2.61e-8
R6 4 port2 2.51
L7 port1 5 9.04e-9
C7 5 6 1.37e-14
R7 6 port2 10.2
L8 port1 7 6.89e-10
C8 7 8 1.97e-13
R8 8 port2 2.53
L9 port1 9 4.93e-9
C9 9 10 1.22e-14
R9 10 port2 13.0
.ENDS LQG15HS2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N2S02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N2S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 2.99e-9
R2 1 port2 5.18e-2
R3 port1 port2 7.48e+3
L4 port1 2 5.43e-8
R4 2 port2 195
L5 port1 3 1.75e-8
R5 3 port2 6.09
L6 port1 4 2.61e-8
R6 4 port2 2.51
L7 port1 5 9.04e-9
C7 5 6 1.37e-14
R7 6 port2 10.2
L8 port1 7 6.89e-10
C8 7 8 1.97e-13
R8 8 port2 2.53
L9 port1 9 4.93e-9
C9 9 10 1.22e-14
R9 10 port2 13.0
.ENDS LQG15HS2N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N4B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.18e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.08e+3
L4 port1 2 5.95e-8
R4 2 port2 186
L5 port1 3 2.77e-8
R5 3 port2 9.66
L6 port1 4 3.78e-8
R6 4 port2 3.63
L7 port1 5 4.53e-7
C7 5 6 2.87e-16
R7 6 port2 501
L8 port1 7 6.67e-10
C8 7 8 7.05e-14
R8 8 port2 4.16
.ENDS LQG15HS2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N4C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.18e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.08e+3
L4 port1 2 5.95e-8
R4 2 port2 186
L5 port1 3 2.77e-8
R5 3 port2 9.66
L6 port1 4 3.78e-8
R6 4 port2 3.63
L7 port1 5 4.53e-7
C7 5 6 2.87e-16
R7 6 port2 501
L8 port1 7 6.67e-10
C8 7 8 7.05e-14
R8 8 port2 4.16
.ENDS LQG15HS2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N4S02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N4S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.18e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.08e+3
L4 port1 2 5.95e-8
R4 2 port2 186
L5 port1 3 2.77e-8
R5 3 port2 9.66
L6 port1 4 3.78e-8
R6 4 port2 3.63
L7 port1 5 4.53e-7
C7 5 6 2.87e-16
R7 6 port2 501
L8 port1 7 6.67e-10
C8 7 8 7.05e-14
R8 8 port2 4.16
.ENDS LQG15HS2N4S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N7B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.49e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.82e+3
L4 port1 2 5.95e-8
R4 2 port2 174
L5 port1 3 3.65e-8
R5 3 port2 12.7
L6 port1 4 3.69e-8
R6 4 port2 3.55
L7 port1 5 1.84e-7
C7 5 6 7.05e-16
R7 6 port2 204
L8 port1 7 6.31e-10
C8 7 8 8.95e-14
R8 8 port2 3.59
.ENDS LQG15HS2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N7C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.49e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.82e+3
L4 port1 2 5.95e-8
R4 2 port2 174
L5 port1 3 3.65e-8
R5 3 port2 12.7
L6 port1 4 3.69e-8
R6 4 port2 3.55
L7 port1 5 1.84e-7
C7 5 6 7.05e-16
R7 6 port2 204
L8 port1 7 6.31e-10
C8 7 8 8.95e-14
R8 8 port2 3.59
.ENDS LQG15HS2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS2N7S02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS2N7S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.49e-9
R2 1 port2 6.83e-2
R3 port1 port2 6.82e+3
L4 port1 2 5.95e-8
R4 2 port2 174
L5 port1 3 3.65e-8
R5 3 port2 12.7
L6 port1 4 3.69e-8
R6 4 port2 3.55
L7 port1 5 1.84e-7
C7 5 6 7.05e-16
R7 6 port2 204
L8 port1 7 6.31e-10
C8 7 8 8.95e-14
R8 8 port2 3.59
.ENDS LQG15HS2N7S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS33NG02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS33NG02 port1 port2
C1 port1 port2 2.89e-15
L2 port1 1 4.25e-8
R2 1 port2 3.89e-1
R3 port1 port2 2.66e+4
L4 port1 2 5.73e-7
R4 2 port2 1.65e+3
L5 port1 3 3.60e-7
R5 3 port2 180
L6 port1 4 1.95e-7
R6 4 port2 19.6
L7 port1 5 2.46e-8
C7 5 6 1.75e-14
R7 6 port2 35.5
L8 port1 7 4.04e-10
C8 7 8 1.83e-13
R8 8 port2 2.59e-1
L9 port1 9 5.10e-9
C9 9 10 2.40e-14
R9 10 port2 18.5
L10 port1 11 1.27e-6
C10 11 12 8.81e-16
R10 12 port2 757
.ENDS LQG15HS33NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS33NH02 port1 port2
C1 port1 port2 2.89e-15
L2 port1 1 4.25e-8
R2 1 port2 3.89e-1
R3 port1 port2 2.66e+4
L4 port1 2 5.73e-7
R4 2 port2 1.65e+3
L5 port1 3 3.60e-7
R5 3 port2 180
L6 port1 4 1.95e-7
R6 4 port2 19.6
L7 port1 5 2.46e-8
C7 5 6 1.75e-14
R7 6 port2 35.5
L8 port1 7 4.04e-10
C8 7 8 1.83e-13
R8 8 port2 2.59e-1
L9 port1 9 5.10e-9
C9 9 10 2.40e-14
R9 10 port2 18.5
L10 port1 11 1.27e-6
C10 11 12 8.81e-16
R10 12 port2 757
.ENDS LQG15HS33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS33NJ02 port1 port2
C1 port1 port2 2.89e-15
L2 port1 1 4.25e-8
R2 1 port2 3.89e-1
R3 port1 port2 2.66e+4
L4 port1 2 5.73e-7
R4 2 port2 1.65e+3
L5 port1 3 3.60e-7
R5 3 port2 180
L6 port1 4 1.95e-7
R6 4 port2 19.6
L7 port1 5 2.46e-8
C7 5 6 1.75e-14
R7 6 port2 35.5
L8 port1 7 4.04e-10
C8 7 8 1.83e-13
R8 8 port2 2.59e-1
L9 port1 9 5.10e-9
C9 9 10 2.40e-14
R9 10 port2 18.5
L10 port1 11 1.27e-6
C10 11 12 8.81e-16
R10 12 port2 757
.ENDS LQG15HS33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS39NG02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS39NG02 port1 port2
C1 port1 port2 3.63e-14
L2 port1 1 4.95e-8
R2 1 port2 4.57e-1
R3 port1 port2 3.12e+4
L4 port1 2 6.58e-7
R4 2 port2 1.90e+3
L5 port1 3 4.23e-7
R5 3 port2 207
L6 port1 4 2.51e-7
R6 4 port2 25.3
L7 port1 5 4.37e-8
C7 5 6 1.13e-14
R7 6 port2 58.9
L8 port1 7 5.45e-10
C8 7 8 1.42e-13
R8 8 port2 1.30
L9 port1 9 5.60e-9
C9 9 10 2.76e-14
R9 10 port2 18.1
L10 port1 11 7.60e-6
C10 11 12 1.69e-16
R10 12 port2 6.63e+3
.ENDS LQG15HS39NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS39NH02 port1 port2
C1 port1 port2 3.63e-14
L2 port1 1 4.95e-8
R2 1 port2 4.57e-1
R3 port1 port2 3.12e+4
L4 port1 2 6.58e-7
R4 2 port2 1.90e+3
L5 port1 3 4.23e-7
R5 3 port2 207
L6 port1 4 2.51e-7
R6 4 port2 25.3
L7 port1 5 4.37e-8
C7 5 6 1.13e-14
R7 6 port2 58.9
L8 port1 7 5.45e-10
C8 7 8 1.42e-13
R8 8 port2 1.30
L9 port1 9 5.60e-9
C9 9 10 2.76e-14
R9 10 port2 18.1
L10 port1 11 7.60e-6
C10 11 12 1.69e-16
R10 12 port2 6.63e+3
.ENDS LQG15HS39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS39NJ02 port1 port2
C1 port1 port2 3.63e-14
L2 port1 1 4.95e-8
R2 1 port2 4.57e-1
R3 port1 port2 3.12e+4
L4 port1 2 6.58e-7
R4 2 port2 1.90e+3
L5 port1 3 4.23e-7
R5 3 port2 207
L6 port1 4 2.51e-7
R6 4 port2 25.3
L7 port1 5 4.37e-8
C7 5 6 1.13e-14
R7 6 port2 58.9
L8 port1 7 5.45e-10
C8 7 8 1.42e-13
R8 8 port2 1.30
L9 port1 9 5.60e-9
C9 9 10 2.76e-14
R9 10 port2 18.1
L10 port1 11 7.60e-6
C10 11 12 1.69e-16
R10 12 port2 6.63e+3
.ENDS LQG15HS39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N0B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.81e-9
R2 1 port2 6.83e-2
R3 port1 port2 7.31e+3
L4 port1 2 8.41e-8
R4 2 port2 295
L5 port1 3 3.25e-8
R5 3 port2 14.0
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 1.64e-7
C7 5 6 7.91e-16
R7 6 port2 182
L8 port1 7 6.03e-10
C8 7 8 9.82e-14
R8 8 port2 3.35
.ENDS LQG15HS3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N0C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.81e-9
R2 1 port2 6.83e-2
R3 port1 port2 7.31e+3
L4 port1 2 8.41e-8
R4 2 port2 295
L5 port1 3 3.25e-8
R5 3 port2 14.0
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 1.64e-7
C7 5 6 7.91e-16
R7 6 port2 182
L8 port1 7 6.03e-10
C8 7 8 9.82e-14
R8 8 port2 3.35
.ENDS LQG15HS3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N0S02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N0S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 3.81e-9
R2 1 port2 6.83e-2
R3 port1 port2 7.31e+3
L4 port1 2 8.41e-8
R4 2 port2 295
L5 port1 3 3.25e-8
R5 3 port2 14.0
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 1.64e-7
C7 5 6 7.91e-16
R7 6 port2 182
L8 port1 7 6.03e-10
C8 7 8 9.82e-14
R8 8 port2 3.35
.ENDS LQG15HS3N0S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N3B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.48e-9
R2 1 port2 9.87e-2
R3 port1 port2 9.21e+3
L4 port1 2 3.67e-8
R4 2 port2 112
L5 port1 3 4.49e-8
R5 3 port2 22.6
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 5.57e-8
C7 5 6 2.33e-15
R7 6 port2 120
L8 port1 7 5.98e-10
C8 7 8 1.34e-13
R8 8 port2 9.03e-1
.ENDS LQG15HS3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N3C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.48e-9
R2 1 port2 9.87e-2
R3 port1 port2 9.21e+3
L4 port1 2 3.67e-8
R4 2 port2 112
L5 port1 3 4.49e-8
R5 3 port2 22.6
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 5.57e-8
C7 5 6 2.33e-15
R7 6 port2 120
L8 port1 7 5.98e-10
C8 7 8 1.34e-13
R8 8 port2 9.03e-1
.ENDS LQG15HS3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N3S02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N3S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.48e-9
R2 1 port2 9.87e-2
R3 port1 port2 9.21e+3
L4 port1 2 3.67e-8
R4 2 port2 112
L5 port1 3 4.49e-8
R5 3 port2 22.6
L6 port1 4 3.87e-8
R6 4 port2 3.72
L7 port1 5 5.57e-8
C7 5 6 2.33e-15
R7 6 port2 120
L8 port1 7 5.98e-10
C8 7 8 1.34e-13
R8 8 port2 9.03e-1
.ENDS LQG15HS3N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N6B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.62e-9
R2 1 port2 9.87e-2
R3 port1 port2 6.98e+3
L4 port1 2 9.01e-8
R4 2 port2 295
L5 port1 3 4.29e-8
R5 3 port2 22.1
L6 port1 4 3.53e-8
R6 4 port2 3.39
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.84e-10
C8 7 8 8.29e-14
R8 8 port2 1.14
.ENDS LQG15HS3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N6C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.62e-9
R2 1 port2 9.87e-2
R3 port1 port2 6.98e+3
L4 port1 2 9.01e-8
R4 2 port2 295
L5 port1 3 4.29e-8
R5 3 port2 22.1
L6 port1 4 3.53e-8
R6 4 port2 3.39
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.84e-10
C8 7 8 8.29e-14
R8 8 port2 1.14
.ENDS LQG15HS3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N6S02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N6S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 4.62e-9
R2 1 port2 9.87e-2
R3 port1 port2 6.98e+3
L4 port1 2 9.01e-8
R4 2 port2 295
L5 port1 3 4.29e-8
R5 3 port2 22.1
L6 port1 4 3.53e-8
R6 4 port2 3.39
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.84e-10
C8 7 8 8.29e-14
R8 8 port2 1.14
.ENDS LQG15HS3N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N9B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.28e-9
R2 1 port2 9.65e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 280
L5 port1 3 3.96e-8
R5 3 port2 16.1
L6 port1 4 3.09e-8
R6 4 port2 2.25
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.63e-10
C8 7 8 9.42e-14
R8 8 port2 1.05
.ENDS LQG15HS3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N9C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.28e-9
R2 1 port2 9.65e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 280
L5 port1 3 3.96e-8
R5 3 port2 16.1
L6 port1 4 3.09e-8
R6 4 port2 2.25
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.63e-10
C8 7 8 9.42e-14
R8 8 port2 1.05
.ENDS LQG15HS3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS3N9S02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS3N9S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.28e-9
R2 1 port2 9.65e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 280
L5 port1 3 3.96e-8
R5 3 port2 16.1
L6 port1 4 3.09e-8
R6 4 port2 2.25
L7 port1 5 1.16e-7
C7 5 6 1.12e-15
R7 6 port2 251
L8 port1 7 5.63e-10
C8 7 8 9.42e-14
R8 8 port2 1.05
.ENDS LQG15HS3N9S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS47NG02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS47NG02 port1 port2
C1 port1 port2 4.68e-15
L2 port1 1 6.08e-8
R2 1 port2 5.01e-1
R3 port1 port2 3.12e+4
L4 port1 2 7.56e-7
R4 2 port2 2.18e+3
L5 port1 3 5.20e-7
R5 3 port2 254
L6 port1 4 2.76e-7
R6 4 port2 27.7
L7 port1 5 4.90e-8
C7 5 6 1.27e-14
R7 6 port2 58.9
L8 port1 7 4.75e-10
C8 7 8 1.97e-13
R8 8 port2 2.59
L9 port1 9 4.24e-9
C9 9 10 3.81e-14
R9 10 port2 20.3
L10 port1 11 7.10e-7
C10 11 12 2.50e-15
R10 12 port2 469
.ENDS LQG15HS47NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS47NH02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS47NH02 port1 port2
C1 port1 port2 4.68e-15
L2 port1 1 6.08e-8
R2 1 port2 5.01e-1
R3 port1 port2 3.12e+4
L4 port1 2 7.56e-7
R4 2 port2 2.18e+3
L5 port1 3 5.20e-7
R5 3 port2 254
L6 port1 4 2.76e-7
R6 4 port2 27.7
L7 port1 5 4.90e-8
C7 5 6 1.27e-14
R7 6 port2 58.9
L8 port1 7 4.75e-10
C8 7 8 1.97e-13
R8 8 port2 2.59
L9 port1 9 4.24e-9
C9 9 10 3.81e-14
R9 10 port2 20.3
L10 port1 11 7.10e-7
C10 11 12 2.50e-15
R10 12 port2 469
.ENDS LQG15HS47NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS47NJ02 port1 port2
C1 port1 port2 4.68e-15
L2 port1 1 6.08e-8
R2 1 port2 5.01e-1
R3 port1 port2 3.12e+4
L4 port1 2 7.56e-7
R4 2 port2 2.18e+3
L5 port1 3 5.20e-7
R5 3 port2 254
L6 port1 4 2.76e-7
R6 4 port2 27.7
L7 port1 5 4.90e-8
C7 5 6 1.27e-14
R7 6 port2 58.9
L8 port1 7 4.75e-10
C8 7 8 1.97e-13
R8 8 port2 2.59
L9 port1 9 4.24e-9
C9 9 10 3.81e-14
R9 10 port2 20.3
L10 port1 11 7.10e-7
C10 11 12 2.50e-15
R10 12 port2 469
.ENDS LQG15HS47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N3B02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N3B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.57e-9
R2 1 port2 7.84e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 274
L5 port1 3 3.53e-8
R5 3 port2 11.1
L6 port1 4 4.27e-8
R6 4 port2 2.83
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 6.25e-10
C8 7 8 1.15e-13
R8 8 port2 1.70
.ENDS LQG15HS4N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N3C02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N3C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.57e-9
R2 1 port2 7.84e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 274
L5 port1 3 3.53e-8
R5 3 port2 11.1
L6 port1 4 4.27e-8
R6 4 port2 2.83
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 6.25e-10
C8 7 8 1.15e-13
R8 8 port2 1.70
.ENDS LQG15HS4N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N3S02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N3S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.57e-9
R2 1 port2 7.84e-2
R3 port1 port2 7.15e+3
L4 port1 2 8.84e-8
R4 2 port2 274
L5 port1 3 3.53e-8
R5 3 port2 11.1
L6 port1 4 4.27e-8
R6 4 port2 2.83
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 6.25e-10
C8 7 8 1.15e-13
R8 8 port2 1.70
.ENDS LQG15HS4N3S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N7B02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N7B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.80e-9
R2 1 port2 9.00e-2
R3 port1 port2 8.59e+3
L4 port1 2 1.19e-7
R4 2 port2 444
L5 port1 3 4.76e-8
R5 3 port2 24.3
L6 port1 4 5.26e-8
R6 4 port2 4.39
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 2.68e-9
C8 7 8 3.25e-14
R8 8 port2 6.92
L9 port1 9 7.04e-10
C9 9 10 8.98e-14
R9 10 port2 2.57
.ENDS LQG15HS4N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N7C02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N7C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.80e-9
R2 1 port2 9.00e-2
R3 port1 port2 8.59e+3
L4 port1 2 1.19e-7
R4 2 port2 444
L5 port1 3 4.76e-8
R5 3 port2 24.3
L6 port1 4 5.26e-8
R6 4 port2 4.39
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 2.68e-9
C8 7 8 3.25e-14
R8 8 port2 6.92
L9 port1 9 7.04e-10
C9 9 10 8.98e-14
R9 10 port2 2.57
.ENDS LQG15HS4N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS4N7S02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS4N7S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 5.80e-9
R2 1 port2 9.00e-2
R3 port1 port2 8.59e+3
L4 port1 2 1.19e-7
R4 2 port2 444
L5 port1 3 4.76e-8
R5 3 port2 24.3
L6 port1 4 5.26e-8
R6 4 port2 4.39
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 2.68e-9
C8 7 8 3.25e-14
R8 8 port2 6.92
L9 port1 9 7.04e-10
C9 9 10 8.98e-14
R9 10 port2 2.57
.ENDS LQG15HS4N7S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS56NG02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS56NG02 port1 port2
C1 port1 port2 6.32e-15
L2 port1 1 7.48e-8
R2 1 port2 6.02e-1
R3 port1 port2 3.12e+4
L4 port1 2 9.51e-7
R4 2 port2 2.56e+3
L5 port1 3 6.55e-7
R5 3 port2 320
L6 port1 4 3.24e-7
R6 4 port2 32.6
L7 port1 5 6.61e-8
C7 5 6 1.18e-14
R7 6 port2 162
L8 port1 7 3.86e-10
C8 7 8 2.01e-13
R8 8 port2 1.46
L9 port1 9 3.15e-9
C9 9 10 3.56e-14
R9 10 port2 18.1
L10 port1 11 4.48e-8
C10 11 12 5.46e-15
R10 12 port2 79.7
.ENDS LQG15HS56NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS56NH02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS56NH02 port1 port2
C1 port1 port2 6.32e-15
L2 port1 1 7.48e-8
R2 1 port2 6.02e-1
R3 port1 port2 3.12e+4
L4 port1 2 9.51e-7
R4 2 port2 2.56e+3
L5 port1 3 6.55e-7
R5 3 port2 320
L6 port1 4 3.24e-7
R6 4 port2 32.6
L7 port1 5 6.61e-8
C7 5 6 1.18e-14
R7 6 port2 162
L8 port1 7 3.86e-10
C8 7 8 2.01e-13
R8 8 port2 1.46
L9 port1 9 3.15e-9
C9 9 10 3.56e-14
R9 10 port2 18.1
L10 port1 11 4.48e-8
C10 11 12 5.46e-15
R10 12 port2 79.7
.ENDS LQG15HS56NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS56NJ02 port1 port2
C1 port1 port2 6.32e-15
L2 port1 1 7.48e-8
R2 1 port2 6.02e-1
R3 port1 port2 3.12e+4
L4 port1 2 9.51e-7
R4 2 port2 2.56e+3
L5 port1 3 6.55e-7
R5 3 port2 320
L6 port1 4 3.24e-7
R6 4 port2 32.6
L7 port1 5 6.61e-8
C7 5 6 1.18e-14
R7 6 port2 162
L8 port1 7 3.86e-10
C8 7 8 2.01e-13
R8 8 port2 1.46
L9 port1 9 3.15e-9
C9 9 10 3.56e-14
R9 10 port2 18.1
L10 port1 11 4.48e-8
C10 11 12 5.46e-15
R10 12 port2 79.7
.ENDS LQG15HS56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N1B02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N1B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.34e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.37e-7
R4 2 port2 522
L5 port1 3 5.47e-8
R5 3 port2 27.9
L6 port1 4 5.14e-8
R6 4 port2 4.29
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 5.70e-9
C8 7 8 1.51e-14
R8 8 port2 16.6
L9 port1 9 6.08e-10
C9 9 10 1.17e-13
R9 10 port2 6.59e-1
.ENDS LQG15HS5N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N1C02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N1C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.34e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.37e-7
R4 2 port2 522
L5 port1 3 5.47e-8
R5 3 port2 27.9
L6 port1 4 5.14e-8
R6 4 port2 4.29
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 5.70e-9
C8 7 8 1.51e-14
R8 8 port2 16.6
L9 port1 9 6.08e-10
C9 9 10 1.17e-13
R9 10 port2 6.59e-1
.ENDS LQG15HS5N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N1S02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N1S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.34e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.37e-7
R4 2 port2 522
L5 port1 3 5.47e-8
R5 3 port2 27.9
L6 port1 4 5.14e-8
R6 4 port2 4.29
L7 port1 5 6.70e-8
C7 5 6 1.94e-15
R7 6 port2 126
L8 port1 7 5.70e-9
C8 7 8 1.51e-14
R8 8 port2 16.6
L9 port1 9 6.08e-10
C9 9 10 1.17e-13
R9 10 port2 6.59e-1
.ENDS LQG15HS5N1S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N6B02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N6B02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.95e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.02e+3
L4 port1 2 1.37e-7
R4 2 port2 465
L5 port1 3 6.57e-8
R5 3 port2 33.6
L6 port1 4 5.38e-8
R6 4 port2 4.49
L7 port1 5 4.53e-8
C7 5 6 2.87e-15
R7 6 port2 42.7
L8 port1 7 1.60e-9
C8 7 8 6.73e-14
R8 8 port2 4.47
L9 port1 9 8.18e-10
C9 9 10 9.95e-14
R9 10 port2 1.70
.ENDS LQG15HS5N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N6C02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N6C02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.95e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.02e+3
L4 port1 2 1.37e-7
R4 2 port2 465
L5 port1 3 6.57e-8
R5 3 port2 33.6
L6 port1 4 5.38e-8
R6 4 port2 4.49
L7 port1 5 4.53e-8
C7 5 6 2.87e-15
R7 6 port2 42.7
L8 port1 7 1.60e-9
C8 7 8 6.73e-14
R8 8 port2 4.47
L9 port1 9 8.18e-10
C9 9 10 9.95e-14
R9 10 port2 1.70
.ENDS LQG15HS5N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS5N6S02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS5N6S02 port1 port2
C1 port1 port2 3.64e-16
L2 port1 1 6.95e-9
R2 1 port2 1.03e-1
R3 port1 port2 8.02e+3
L4 port1 2 1.37e-7
R4 2 port2 465
L5 port1 3 6.57e-8
R5 3 port2 33.6
L6 port1 4 5.38e-8
R6 4 port2 4.49
L7 port1 5 4.53e-8
C7 5 6 2.87e-15
R7 6 port2 42.7
L8 port1 7 1.60e-9
C8 7 8 6.73e-14
R8 8 port2 4.47
L9 port1 9 8.18e-10
C9 9 10 9.95e-14
R9 10 port2 1.70
.ENDS LQG15HS5N6S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS68NG02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS68NG02 port1 port2
C1 port1 port2 1.26e-13
L2 port1 1 8.77e-8
R2 1 port2 6.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.07e-6
R4 2 port2 2.62e+3
L5 port1 3 7.70e-7
R5 3 port2 376
L6 port1 4 3.80e-7
R6 4 port2 38.3
L7 port1 5 7.25e-8
C7 5 6 1.36e-14
R7 6 port2 159
L8 port1 7 7.87e-10
C8 7 8 1.13e-13
R8 8 port2 2.78
L9 port1 9 5.47e-9
C9 9 10 2.70e-14
R9 10 port2 27.3
L10 port1 11 2.82e-8
C10 11 12 1.04e-14
R10 12 port2 91.5
L11 port1 13 1.84e-6
C11 13 14 1.45e-15
R11 14 port2 1.53e+3
.ENDS LQG15HS68NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS68NH02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS68NH02 port1 port2
C1 port1 port2 1.26e-13
L2 port1 1 8.77e-8
R2 1 port2 6.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.07e-6
R4 2 port2 2.62e+3
L5 port1 3 7.70e-7
R5 3 port2 376
L6 port1 4 3.80e-7
R6 4 port2 38.3
L7 port1 5 7.25e-8
C7 5 6 1.36e-14
R7 6 port2 159
L8 port1 7 7.87e-10
C8 7 8 1.13e-13
R8 8 port2 2.78
L9 port1 9 5.47e-9
C9 9 10 2.70e-14
R9 10 port2 27.3
L10 port1 11 2.82e-8
C10 11 12 1.04e-14
R10 12 port2 91.5
L11 port1 13 1.84e-6
C11 13 14 1.45e-15
R11 14 port2 1.53e+3
.ENDS LQG15HS68NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS68NJ02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS68NJ02 port1 port2
C1 port1 port2 1.26e-13
L2 port1 1 8.77e-8
R2 1 port2 6.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.07e-6
R4 2 port2 2.62e+3
L5 port1 3 7.70e-7
R5 3 port2 376
L6 port1 4 3.80e-7
R6 4 port2 38.3
L7 port1 5 7.25e-8
C7 5 6 1.36e-14
R7 6 port2 159
L8 port1 7 7.87e-10
C8 7 8 1.13e-13
R8 8 port2 2.78
L9 port1 9 5.47e-9
C9 9 10 2.70e-14
R9 10 port2 27.3
L10 port1 11 2.82e-8
C10 11 12 1.04e-14
R10 12 port2 91.5
L11 port1 13 1.84e-6
C11 13 14 1.45e-15
R11 14 port2 1.53e+3
.ENDS LQG15HS68NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N2B02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N2B02 port1 port2
C1 port1 port2 9.57e-17
L2 port1 1 8.36e-9
R2 1 port2 1.10e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.65e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 3.81e-8
R6 4 port2 3.25
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 91.3
L8 port1 7 6.87e-10
C8 7 8 1.15e-13
R8 8 port2 8.32e-1
L9 port1 9 1.08e-9
C9 9 10 2.62e-14
R9 10 port2 3.81
.ENDS LQG15HS6N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N2C02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N2C02 port1 port2
C1 port1 port2 9.57e-17
L2 port1 1 8.36e-9
R2 1 port2 1.10e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.65e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 3.81e-8
R6 4 port2 3.25
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 91.3
L8 port1 7 6.87e-10
C8 7 8 1.15e-13
R8 8 port2 8.32e-1
L9 port1 9 1.08e-9
C9 9 10 2.62e-14
R9 10 port2 3.81
.ENDS LQG15HS6N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N2S02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N2S02 port1 port2
C1 port1 port2 9.57e-17
L2 port1 1 8.36e-9
R2 1 port2 1.10e-1
R3 port1 port2 8.59e+3
L4 port1 2 1.65e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 3.81e-8
R6 4 port2 3.25
L7 port1 5 9.68e-8
C7 5 6 1.34e-15
R7 6 port2 91.3
L8 port1 7 6.87e-10
C8 7 8 1.15e-13
R8 8 port2 8.32e-1
L9 port1 9 1.08e-9
C9 9 10 2.62e-14
R9 10 port2 3.81
.ENDS LQG15HS6N2S02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N8G02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N8G02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.75e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.79e+3
L4 port1 2 1.73e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 4.37e-8
R6 4 port2 3.25
L7 port1 5 3.51e-8
C7 5 6 4.65e-15
R7 6 port2 45.8
L8 port1 7 6.41e-10
C8 7 8 1.18e-13
R8 8 port2 7.95e-1
L9 port1 9 7.71e-8
C9 9 10 1.59e-15
R9 10 port2 75.8
.ENDS LQG15HS6N8G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N8H02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.75e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.79e+3
L4 port1 2 1.73e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 4.37e-8
R6 4 port2 3.25
L7 port1 5 3.51e-8
C7 5 6 4.65e-15
R7 6 port2 45.8
L8 port1 7 6.41e-10
C8 7 8 1.18e-13
R8 8 port2 7.95e-1
L9 port1 9 7.71e-8
C9 9 10 1.59e-15
R9 10 port2 75.8
.ENDS LQG15HS6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS6N8J02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 8.75e-9
R2 1 port2 1.29e-1
R3 port1 port2 8.79e+3
L4 port1 2 1.73e-7
R4 2 port2 599
L5 port1 3 6.88e-8
R5 3 port2 36.0
L6 port1 4 4.37e-8
R6 4 port2 3.25
L7 port1 5 3.51e-8
C7 5 6 4.65e-15
R7 6 port2 45.8
L8 port1 7 6.41e-10
C8 7 8 1.18e-13
R8 8 port2 7.95e-1
L9 port1 9 7.71e-8
C9 9 10 1.59e-15
R9 10 port2 75.8
.ENDS LQG15HS6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS7N5G02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS7N5G02 port1 port2
C1 port1 port2 5.77e-14
L2 port1 1 1.05e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 1.85e-7
R4 2 port2 642
L5 port1 3 8.08e-8
R5 3 port2 42.3
L6 port1 4 3.64e-8
R6 4 port2 2.25
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 8.55e-10
C8 7 8 9.90e-14
R8 8 port2 1.00
L9 port1 9 8.13e-8
C9 9 10 1.60e-15
R9 10 port2 77.5
.ENDS LQG15HS7N5G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS7N5H02 port1 port2
C1 port1 port2 5.77e-14
L2 port1 1 1.05e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 1.85e-7
R4 2 port2 642
L5 port1 3 8.08e-8
R5 3 port2 42.3
L6 port1 4 3.64e-8
R6 4 port2 2.25
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 8.55e-10
C8 7 8 9.90e-14
R8 8 port2 1.00
L9 port1 9 8.13e-8
C9 9 10 1.60e-15
R9 10 port2 77.5
.ENDS LQG15HS7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS7N5J02 port1 port2
C1 port1 port2 5.77e-14
L2 port1 1 1.05e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 1.85e-7
R4 2 port2 642
L5 port1 3 8.08e-8
R5 3 port2 42.3
L6 port1 4 3.64e-8
R6 4 port2 2.25
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 8.55e-10
C8 7 8 9.90e-14
R8 8 port2 1.00
L9 port1 9 8.13e-8
C9 9 10 1.60e-15
R9 10 port2 77.5
.ENDS LQG15HS7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS82NG02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS82NG02 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 1.02e-7
R2 1 port2 8.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.34e-6
R4 2 port2 3.30e+3
L5 port1 3 8.44e-7
R5 3 port2 412
L6 port1 4 4.90e-7
R6 4 port2 49.3
L7 port1 5 7.42e-8
C7 5 6 1.67e-14
R7 6 port2 145
L8 port1 7 5.97e-10
C8 7 8 1.42e-13
R8 8 port2 2.16
L9 port1 9 1.47e-9
C9 9 10 7.26e-14
R9 10 port2 8.65
L10 port1 11 3.24e-8
C10 11 12 1.19e-14
R10 12 port2 91.5
L11 port1 13 1.04e-6
C11 13 14 3.26e-15
R11 14 port2 766
L12 port1 15 7.21e-9
C12 15 16 2.35e-14
R12 16 port2 33.6
.ENDS LQG15HS82NG02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS82NH02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS82NH02 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 1.02e-7
R2 1 port2 8.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.34e-6
R4 2 port2 3.30e+3
L5 port1 3 8.44e-7
R5 3 port2 412
L6 port1 4 4.90e-7
R6 4 port2 49.3
L7 port1 5 7.42e-8
C7 5 6 1.67e-14
R7 6 port2 145
L8 port1 7 5.97e-10
C8 7 8 1.42e-13
R8 8 port2 2.16
L9 port1 9 1.47e-9
C9 9 10 7.26e-14
R9 10 port2 8.65
L10 port1 11 3.24e-8
C10 11 12 1.19e-14
R10 12 port2 91.5
L11 port1 13 1.04e-6
C11 13 14 3.26e-15
R11 14 port2 766
L12 port1 15 7.21e-9
C12 15 16 2.35e-14
R12 16 port2 33.6
.ENDS LQG15HS82NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS82NJ02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS82NJ02 port1 port2
C1 port1 port2 5.38e-14
L2 port1 1 1.02e-7
R2 1 port2 8.91e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.34e-6
R4 2 port2 3.30e+3
L5 port1 3 8.44e-7
R5 3 port2 412
L6 port1 4 4.90e-7
R6 4 port2 49.3
L7 port1 5 7.42e-8
C7 5 6 1.67e-14
R7 6 port2 145
L8 port1 7 5.97e-10
C8 7 8 1.42e-13
R8 8 port2 2.16
L9 port1 9 1.47e-9
C9 9 10 7.26e-14
R9 10 port2 8.65
L10 port1 11 3.24e-8
C10 11 12 1.19e-14
R10 12 port2 91.5
L11 port1 13 1.04e-6
C11 13 14 3.26e-15
R11 14 port2 766
L12 port1 15 7.21e-9
C12 15 16 2.35e-14
R12 16 port2 33.6
.ENDS LQG15HS82NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS8N2G02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS8N2G02 port1 port2
C1 port1 port2 2.89e-14
L2 port1 1 1.13e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 2.03e-7
R4 2 port2 704
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.18e-8
R6 4 port2 2.58
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 6.19e-10
C8 7 8 1.50e-13
R8 8 port2 6.92e-1
L9 port1 9 3.47e-8
C9 9 10 3.75e-15
R9 10 port2 33.1
.ENDS LQG15HS8N2G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS8N2H02 port1 port2
C1 port1 port2 2.89e-14
L2 port1 1 1.13e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 2.03e-7
R4 2 port2 704
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.18e-8
R6 4 port2 2.58
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 6.19e-10
C8 7 8 1.50e-13
R8 8 port2 6.92e-1
L9 port1 9 3.47e-8
C9 9 10 3.75e-15
R9 10 port2 33.1
.ENDS LQG15HS8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS8N2J02 port1 port2
C1 port1 port2 2.89e-14
L2 port1 1 1.13e-8
R2 1 port2 1.29e-1
R3 port1 port2 9.64e+3
L4 port1 2 2.03e-7
R4 2 port2 704
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.18e-8
R6 4 port2 2.58
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 6.19e-10
C8 7 8 1.50e-13
R8 8 port2 6.92e-1
L9 port1 9 3.47e-8
C9 9 10 3.75e-15
R9 10 port2 33.1
.ENDS LQG15HS8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS9N1G02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS9N1G02 port1 port2
C1 port1 port2 8.15e-14
L2 port1 1 1.27e-8
R2 1 port2 1.52e-1
R3 port1 port2 1.03e+4
L4 port1 2 2.28e-7
R4 2 port2 790
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.27e-8
R6 4 port2 2.64
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 1.21e-9
C8 7 8 7.69e-14
R8 8 port2 1.35
L9 port1 9 3.39e-8
C9 9 10 3.84e-15
R9 10 port2 32.3
L10 port1 11 1.72e-8
C10 11 12 3.56e-15
R10 12 port2 32.6
.ENDS LQG15HS9N1G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS9N1H02 port1 port2
C1 port1 port2 8.15e-14
L2 port1 1 1.27e-8
R2 1 port2 1.52e-1
R3 port1 port2 1.03e+4
L4 port1 2 2.28e-7
R4 2 port2 790
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.27e-8
R6 4 port2 2.64
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 1.21e-9
C8 7 8 7.69e-14
R8 8 port2 1.35
L9 port1 9 3.39e-8
C9 9 10 3.84e-15
R9 10 port2 32.3
L10 port1 11 1.72e-8
C10 11 12 3.56e-15
R10 12 port2 32.6
.ENDS LQG15HS9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HS9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HS9N1J02 port1 port2
C1 port1 port2 8.15e-14
L2 port1 1 1.27e-8
R2 1 port2 1.52e-1
R3 port1 port2 1.03e+4
L4 port1 2 2.28e-7
R4 2 port2 790
L5 port1 3 8.46e-8
R5 3 port2 44.3
L6 port1 4 4.27e-8
R6 4 port2 2.64
L7 port1 5 7.18e-8
C7 5 6 2.28e-15
R7 6 port2 93.4
L8 port1 7 1.21e-9
C8 7 8 7.69e-14
R8 8 port2 1.35
L9 port1 9 3.39e-8
C9 9 10 3.84e-15
R9 10 port2 32.3
L10 port1 11 1.72e-8
C10 11 12 3.56e-15
R10 12 port2 32.6
.ENDS LQG15HS9N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR10G02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR10G02 port1 port2
C1 port1 port2 7.09e-14
L2 port1 1 1.29e-7
R2 1 port2 9.99e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.86e-6
R4 2 port2 4.35e+3
L5 port1 3 1.11e-6
R5 3 port2 544
L6 port1 4 5.89e-7
R6 4 port2 59.3
L7 port1 5 4.90e-8
C7 5 6 1.10e-14
R7 6 port2 145
L8 port1 7 5.70e-10
C8 7 8 1.71e-13
R8 8 port2 1.92
L9 port1 9 2.44e-8
C9 9 10 2.52e-15
R9 10 port2 189
L10 port1 11 8.53e-8
C10 11 12 3.29e-15
R10 12 port2 105
L11 port1 13 1.01e-7
C11 13 14 1.60e-14
R11 14 port2 171
L12 port1 15 3.22e-9
C12 15 16 4.17e-14
R12 16 port2 16.8
.ENDS LQG15HSR10G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR10H02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR10H02 port1 port2
C1 port1 port2 7.09e-14
L2 port1 1 1.29e-7
R2 1 port2 9.99e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.86e-6
R4 2 port2 4.35e+3
L5 port1 3 1.11e-6
R5 3 port2 544
L6 port1 4 5.89e-7
R6 4 port2 59.3
L7 port1 5 4.90e-8
C7 5 6 1.10e-14
R7 6 port2 145
L8 port1 7 5.70e-10
C8 7 8 1.71e-13
R8 8 port2 1.92
L9 port1 9 2.44e-8
C9 9 10 2.52e-15
R9 10 port2 189
L10 port1 11 8.53e-8
C10 11 12 3.29e-15
R10 12 port2 105
L11 port1 13 1.01e-7
C11 13 14 1.60e-14
R11 14 port2 171
L12 port1 15 3.22e-9
C12 15 16 4.17e-14
R12 16 port2 16.8
.ENDS LQG15HSR10H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR10J02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR10J02 port1 port2
C1 port1 port2 7.09e-14
L2 port1 1 1.29e-7
R2 1 port2 9.99e-1
R3 port1 port2 3.12e+4
L4 port1 2 1.86e-6
R4 2 port2 4.35e+3
L5 port1 3 1.11e-6
R5 3 port2 544
L6 port1 4 5.89e-7
R6 4 port2 59.3
L7 port1 5 4.90e-8
C7 5 6 1.10e-14
R7 6 port2 145
L8 port1 7 5.70e-10
C8 7 8 1.71e-13
R8 8 port2 1.92
L9 port1 9 2.44e-8
C9 9 10 2.52e-15
R9 10 port2 189
L10 port1 11 8.53e-8
C10 11 12 3.29e-15
R10 12 port2 105
L11 port1 13 1.01e-7
C11 13 14 1.60e-14
R11 14 port2 171
L12 port1 15 3.22e-9
C12 15 16 4.17e-14
R12 16 port2 16.8
.ENDS LQG15HSR10J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR12G02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR12G02 port1 port2
C1 port1 port2 9.13e-15
L2 port1 1 1.54e-7
R2 1 port2 1.29
R3 port1 port2 3.51e+4
L4 port1 2 2.18e-6
R4 2 port2 4.77e+3
L5 port1 3 1.17e-6
R5 3 port2 569
L6 port1 4 7.08e-7
R6 4 port2 71.3
L7 port1 5 5.25e-8
C7 5 6 1.18e-14
R7 6 port2 145
L8 port1 7 1.54e-9
C8 7 8 8.01e-14
R8 8 port2 4.61
L9 port1 9 2.62e-7
C9 9 10 2.70e-16
R9 10 port2 238
L10 port1 11 1.95e-8
C10 11 12 1.50e-14
R10 12 port2 74.3
L11 port1 13 1.08e-7
C11 13 14 1.87e-14
R11 14 port2 164
L12 port1 15 4.87e-9
C12 15 16 3.31e-14
R12 16 port2 15.4
L13 port1 17 4.25e-10
C13 17 18 2.40e-13
R13 18 port2 2.82
.ENDS LQG15HSR12G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR12H02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR12H02 port1 port2
C1 port1 port2 9.13e-15
L2 port1 1 1.54e-7
R2 1 port2 1.29
R3 port1 port2 3.51e+4
L4 port1 2 2.18e-6
R4 2 port2 4.77e+3
L5 port1 3 1.17e-6
R5 3 port2 569
L6 port1 4 7.08e-7
R6 4 port2 71.3
L7 port1 5 5.25e-8
C7 5 6 1.18e-14
R7 6 port2 145
L8 port1 7 1.54e-9
C8 7 8 8.01e-14
R8 8 port2 4.61
L9 port1 9 2.62e-7
C9 9 10 2.70e-16
R9 10 port2 238
L10 port1 11 1.95e-8
C10 11 12 1.50e-14
R10 12 port2 74.3
L11 port1 13 1.08e-7
C11 13 14 1.87e-14
R11 14 port2 164
L12 port1 15 4.87e-9
C12 15 16 3.31e-14
R12 16 port2 15.4
L13 port1 17 4.25e-10
C13 17 18 2.40e-13
R13 18 port2 2.82
.ENDS LQG15HSR12H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR12J02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR12J02 port1 port2
C1 port1 port2 9.13e-15
L2 port1 1 1.54e-7
R2 1 port2 1.29
R3 port1 port2 3.51e+4
L4 port1 2 2.18e-6
R4 2 port2 4.77e+3
L5 port1 3 1.17e-6
R5 3 port2 569
L6 port1 4 7.08e-7
R6 4 port2 71.3
L7 port1 5 5.25e-8
C7 5 6 1.18e-14
R7 6 port2 145
L8 port1 7 1.54e-9
C8 7 8 8.01e-14
R8 8 port2 4.61
L9 port1 9 2.62e-7
C9 9 10 2.70e-16
R9 10 port2 238
L10 port1 11 1.95e-8
C10 11 12 1.50e-14
R10 12 port2 74.3
L11 port1 13 1.08e-7
C11 13 14 1.87e-14
R11 14 port2 164
L12 port1 15 4.87e-9
C12 15 16 3.31e-14
R12 16 port2 15.4
L13 port1 17 4.25e-10
C13 17 18 2.40e-13
R13 18 port2 2.82
.ENDS LQG15HSR12J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR15G02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR15G02 port1 port2
C1 port1 port2 2.95e-15
L2 port1 1 1.76e-7
R2 1 port2 2.46
R3 port1 port2 3.68e+4
L4 port1 2 3.54e-6
R4 2 port2 7.56e+3
L5 port1 3 1.62e-6
R5 3 port2 785
L6 port1 4 1.32e-6
R6 4 port2 133
L7 port1 5 8.92e-8
C7 5 6 6.64e-15
R7 6 port2 252
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 142
L9 port1 9 1.49e-7
C9 9 10 1.29e-14
R9 10 port2 232
L10 port1 11 1.31e-8
C10 11 12 1.02e-14
R10 12 port2 34.5
L11 port1 13 3.88e-10
C11 13 14 2.19e-13
R11 14 port2 2.82
.ENDS LQG15HSR15G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR15H02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR15H02 port1 port2
C1 port1 port2 2.95e-15
L2 port1 1 1.76e-7
R2 1 port2 2.46
R3 port1 port2 3.68e+4
L4 port1 2 3.54e-6
R4 2 port2 7.56e+3
L5 port1 3 1.62e-6
R5 3 port2 785
L6 port1 4 1.32e-6
R6 4 port2 133
L7 port1 5 8.92e-8
C7 5 6 6.64e-15
R7 6 port2 252
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 142
L9 port1 9 1.49e-7
C9 9 10 1.29e-14
R9 10 port2 232
L10 port1 11 1.31e-8
C10 11 12 1.02e-14
R10 12 port2 34.5
L11 port1 13 3.88e-10
C11 13 14 2.19e-13
R11 14 port2 2.82
.ENDS LQG15HSR15H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR15J02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR15J02 port1 port2
C1 port1 port2 2.95e-15
L2 port1 1 1.76e-7
R2 1 port2 2.46
R3 port1 port2 3.68e+4
L4 port1 2 3.54e-6
R4 2 port2 7.56e+3
L5 port1 3 1.62e-6
R5 3 port2 785
L6 port1 4 1.32e-6
R6 4 port2 133
L7 port1 5 8.92e-8
C7 5 6 6.64e-15
R7 6 port2 252
L8 port1 7 3.72e-8
C8 7 8 7.87e-15
R8 8 port2 142
L9 port1 9 1.49e-7
C9 9 10 1.29e-14
R9 10 port2 232
L10 port1 11 1.31e-8
C10 11 12 1.02e-14
R10 12 port2 34.5
L11 port1 13 3.88e-10
C11 13 14 2.19e-13
R11 14 port2 2.82
.ENDS LQG15HSR15J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR18G02
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR18G02 port1 port2
C1 port1 port2 3.55e-14
L2 port1 1 2.13e-7
R2 1 port2 2.96
R3 port1 port2 3.68e+4
L4 port1 2 4.88e-6
R4 2 port2 9.52e+3
L5 port1 3 1.90e-6
R5 3 port2 923
L6 port1 4 1.45e-6
R6 4 port2 146
L7 port1 5 1.12e-7
C7 5 6 6.64e-15
R7 6 port2 283
L8 port1 7 9.55e-8
C8 7 8 3.86e-15
R8 8 port2 324
L9 port1 9 1.79e-7
C9 9 10 1.29e-14
R9 10 port2 254
L10 port1 11 9.07e-9
C10 11 12 1.41e-14
R10 12 port2 24.4
L11 port1 13 1.02e-9
C11 13 14 6.92e-14
R11 14 port2 2.04
L12 port1 15 6.32e-10
C12 15 16 1.40e-13
R12 16 port2 5.35
L13 port1 17 4.37e-8
C13 17 18 4.24e-15
R13 18 port2 203
.ENDS LQG15HSR18G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR18H02
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR18H02 port1 port2
C1 port1 port2 3.55e-14
L2 port1 1 2.13e-7
R2 1 port2 2.96
R3 port1 port2 3.68e+4
L4 port1 2 4.88e-6
R4 2 port2 9.52e+3
L5 port1 3 1.90e-6
R5 3 port2 923
L6 port1 4 1.45e-6
R6 4 port2 146
L7 port1 5 1.12e-7
C7 5 6 6.64e-15
R7 6 port2 283
L8 port1 7 9.55e-8
C8 7 8 3.86e-15
R8 8 port2 324
L9 port1 9 1.79e-7
C9 9 10 1.29e-14
R9 10 port2 254
L10 port1 11 9.07e-9
C10 11 12 1.41e-14
R10 12 port2 24.4
L11 port1 13 1.02e-9
C11 13 14 6.92e-14
R11 14 port2 2.04
L12 port1 15 6.32e-10
C12 15 16 1.40e-13
R12 16 port2 5.35
L13 port1 17 4.37e-8
C13 17 18 4.24e-15
R13 18 port2 203
.ENDS LQG15HSR18H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR18J02
* Property : L = 180[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR18J02 port1 port2
C1 port1 port2 3.55e-14
L2 port1 1 2.13e-7
R2 1 port2 2.96
R3 port1 port2 3.68e+4
L4 port1 2 4.88e-6
R4 2 port2 9.52e+3
L5 port1 3 1.90e-6
R5 3 port2 923
L6 port1 4 1.45e-6
R6 4 port2 146
L7 port1 5 1.12e-7
C7 5 6 6.64e-15
R7 6 port2 283
L8 port1 7 9.55e-8
C8 7 8 3.86e-15
R8 8 port2 324
L9 port1 9 1.79e-7
C9 9 10 1.29e-14
R9 10 port2 254
L10 port1 11 9.07e-9
C10 11 12 1.41e-14
R10 12 port2 24.4
L11 port1 13 1.02e-9
C11 13 14 6.92e-14
R11 14 port2 2.04
L12 port1 15 6.32e-10
C12 15 16 1.40e-13
R12 16 port2 5.35
L13 port1 17 4.37e-8
C13 17 18 4.24e-15
R13 18 port2 203
.ENDS LQG15HSR18J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR22G02
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR22G02 port1 port2
C1 port1 port2 1.12e-14
L2 port1 1 2.59e-7
R2 1 port2 3.39
R3 port1 port2 3.68e+4
L4 port1 2 6.29e-6
R4 2 port2 1.09e+4
L5 port1 3 2.18e-6
R5 3 port2 1.06e+3
L6 port1 4 1.78e-6
R6 4 port2 179
L7 port1 5 1.86e-7
C7 5 6 4.81e-15
R7 6 port2 428
L8 port1 7 1.32e-7
C8 7 8 3.21e-15
R8 8 port2 418
L9 port1 9 2.42e-7
C9 9 10 1.21e-14
R9 10 port2 305
L10 port1 11 8.66e-8
C10 11 12 2.82e-15
R10 12 port2 337
L11 port1 13 1.90e-9
C11 13 14 4.90e-14
R11 14 port2 5.01
L12 port1 15 6.32e-9
C12 15 16 1.94e-14
R12 16 port2 18.1
L13 port1 17 4.19e-10
C13 17 18 1.77e-13
R13 18 port2 4.34
.ENDS LQG15HSR22G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR22H02
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR22H02 port1 port2
C1 port1 port2 1.12e-14
L2 port1 1 2.59e-7
R2 1 port2 3.39
R3 port1 port2 3.68e+4
L4 port1 2 6.29e-6
R4 2 port2 1.09e+4
L5 port1 3 2.18e-6
R5 3 port2 1.06e+3
L6 port1 4 1.78e-6
R6 4 port2 179
L7 port1 5 1.86e-7
C7 5 6 4.81e-15
R7 6 port2 428
L8 port1 7 1.32e-7
C8 7 8 3.21e-15
R8 8 port2 418
L9 port1 9 2.42e-7
C9 9 10 1.21e-14
R9 10 port2 305
L10 port1 11 8.66e-8
C10 11 12 2.82e-15
R10 12 port2 337
L11 port1 13 1.90e-9
C11 13 14 4.90e-14
R11 14 port2 5.01
L12 port1 15 6.32e-9
C12 15 16 1.94e-14
R12 16 port2 18.1
L13 port1 17 4.19e-10
C13 17 18 1.77e-13
R13 18 port2 4.34
.ENDS LQG15HSR22H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR22J02
* Property : L = 220[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR22J02 port1 port2
C1 port1 port2 1.12e-14
L2 port1 1 2.59e-7
R2 1 port2 3.39
R3 port1 port2 3.68e+4
L4 port1 2 6.29e-6
R4 2 port2 1.09e+4
L5 port1 3 2.18e-6
R5 3 port2 1.06e+3
L6 port1 4 1.78e-6
R6 4 port2 179
L7 port1 5 1.86e-7
C7 5 6 4.81e-15
R7 6 port2 428
L8 port1 7 1.32e-7
C8 7 8 3.21e-15
R8 8 port2 418
L9 port1 9 2.42e-7
C9 9 10 1.21e-14
R9 10 port2 305
L10 port1 11 8.66e-8
C10 11 12 2.82e-15
R10 12 port2 337
L11 port1 13 1.90e-9
C11 13 14 4.90e-14
R11 14 port2 5.01
L12 port1 15 6.32e-9
C12 15 16 1.94e-14
R12 16 port2 18.1
L13 port1 17 4.19e-10
C13 17 18 1.77e-13
R13 18 port2 4.34
.ENDS LQG15HSR22J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR27G02
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR27G02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 3.26e-7
R2 1 port2 4.27
R3 port1 port2 3.68e+4
L4 port1 2 8.88e-6
R4 2 port2 1.38e+4
L5 port1 3 2.56e-6
R5 3 port2 1.24e+3
L6 port1 4 2.14e-6
R6 4 port2 215
L7 port1 5 2.04e-7
C7 5 6 6.05e-15
R7 6 port2 399
L8 port1 7 1.51e-7
C8 7 8 3.86e-15
R8 8 port2 408
L9 port1 9 2.06e-7
C9 9 10 1.87e-14
R9 10 port2 279
L10 port1 11 1.07e-7
C10 11 12 3.31e-15
R10 12 port2 345
L11 port1 13 7.73e-9
C11 13 14 1.74e-14
R11 14 port2 17.0
L12 port1 15 5.38e-8
C12 15 16 3.78e-15
R12 16 port2 315
L13 port1 17 3.74e-10
C13 17 18 2.50e-13
R13 18 port2 5.47e-1
.ENDS LQG15HSR27G02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR27H02
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR27H02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 3.26e-7
R2 1 port2 4.27
R3 port1 port2 3.68e+4
L4 port1 2 8.88e-6
R4 2 port2 1.38e+4
L5 port1 3 2.56e-6
R5 3 port2 1.24e+3
L6 port1 4 2.14e-6
R6 4 port2 215
L7 port1 5 2.04e-7
C7 5 6 6.05e-15
R7 6 port2 399
L8 port1 7 1.51e-7
C8 7 8 3.86e-15
R8 8 port2 408
L9 port1 9 2.06e-7
C9 9 10 1.87e-14
R9 10 port2 279
L10 port1 11 1.07e-7
C10 11 12 3.31e-15
R10 12 port2 345
L11 port1 13 7.73e-9
C11 13 14 1.74e-14
R11 14 port2 17.0
L12 port1 15 5.38e-8
C12 15 16 3.78e-15
R12 16 port2 315
L13 port1 17 3.74e-10
C13 17 18 2.50e-13
R13 18 port2 5.47e-1
.ENDS LQG15HSR27H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG15HSR27J02
* Property : L = 270[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG15HSR27J02 port1 port2
C1 port1 port2 2.24e-14
L2 port1 1 3.26e-7
R2 1 port2 4.27
R3 port1 port2 3.68e+4
L4 port1 2 8.88e-6
R4 2 port2 1.38e+4
L5 port1 3 2.56e-6
R5 3 port2 1.24e+3
L6 port1 4 2.14e-6
R6 4 port2 215
L7 port1 5 2.04e-7
C7 5 6 6.05e-15
R7 6 port2 399
L8 port1 7 1.51e-7
C8 7 8 3.86e-15
R8 8 port2 408
L9 port1 9 2.06e-7
C9 9 10 1.87e-14
R9 10 port2 279
L10 port1 11 1.07e-7
C10 11 12 3.31e-15
R10 12 port2 345
L11 port1 13 7.73e-9
C11 13 14 1.74e-14
R11 14 port2 17.0
L12 port1 15 5.38e-8
C12 15 16 3.78e-15
R12 16 port2 315
L13 port1 17 3.74e-10
C13 17 18 2.50e-13
R13 18 port2 5.47e-1
.ENDS LQG15HSR27J02
*----------------------------------------------------------------------
