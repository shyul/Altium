*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HN1R0J00
* Property : L = 1000[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HN1R0J00 port1 port2
C1 port1 port2 1.00e-13
L2 port1 1 1.05e-6
R2 1 port2 2.73
R3 port1 port2 9.89e+3
.ENDS LQW21HN1R0J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HN1R2J00
* Property : L = 1200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HN1R2J00 port1 port2
C1 port1 port2 7.91e-14
L2 port1 1 1.28e-6
R2 1 port2 3.25
R3 port1 port2 1.17e+4
.ENDS LQW21HN1R2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HN1R5J00
* Property : L = 1500[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HN1R5J00 port1 port2
C1 port1 port2 8.80e-14
L2 port1 1 1.63e-6
R2 1 port2 5.39
R3 port1 port2 1.58e+4
.ENDS LQW21HN1R5J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HN1R8J00
* Property : L = 1800[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HN1R8J00 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 1.88e-6
R2 1 port2 5.80
R3 port1 port2 2.31e+4
L4 port1 2 4.94e-7
C4 2 3 2.01e-14
R4 3 port2 996
L5 port1 4 2.95e-6
C5 4 5 1.01e-15
R5 5 port2 6.83e+3
.ENDS LQW21HN1R8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HN2R2J00
* Property : L = 2200[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HN2R2J00 port1 port2
C1 port1 port2 6.94e-14
L2 port1 1 2.21e-6
R2 1 port2 6.82
R3 port1 port2 2.78e+4
L4 port1 2 5.29e-7
C4 2 3 2.10e-14
R4 3 port2 2.08e+3
L5 port1 4 2.95e-6
C5 4 5 1.01e-15
R5 5 port2 8.21e+3
.ENDS LQW21HN2R2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HNR47J00
* Property : L = 470[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HNR47J00 port1 port2
C1 port1 port2 9.20e-14
L2 port1 1 4.79e-7
R2 1 port2 1.28
R3 port1 port2 4.93e+3
.ENDS LQW21HNR47J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HNR56J00
* Property : L = 560[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HNR56J00 port1 port2
C1 port1 port2 7.49e-14
L2 port1 1 5.85e-7
R2 1 port2 1.55
R3 port1 port2 5.71e+3
.ENDS LQW21HNR56J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HNR68J00
* Property : L = 680[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HNR68J00 port1 port2
C1 port1 port2 9.05e-14
L2 port1 1 7.05e-7
R2 1 port2 2.17
R3 port1 port2 7.13e+3
.ENDS LQW21HNR68J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQW21HNR82J00
* Property : L = 820[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQW21HNR82J00 port1 port2
C1 port1 port2 8.16e-14
L2 port1 1 8.62e-7
R2 1 port2 2.54
R3 port1 port2 8.31e+3
.ENDS LQW21HNR82J00
*----------------------------------------------------------------------
