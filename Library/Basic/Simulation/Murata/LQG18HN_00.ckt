*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN10NJ00
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN10NJ00 port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 1.07e-8
R2 1 port2 1.29e-1
R3 port1 port2 2.31e+4
L4 port1 2 3.16e-7
R4 2 port2 930
L5 port1 3 1.88e-7
R5 3 port2 90.3
L6 port1 4 1.00e-7
R6 4 port2 10.1
L7 port1 5 1.55e-8
C7 5 6 1.51e-14
R7 6 port2 19.1
L8 port1 7 1.21e-9
C8 7 8 1.22e-13
R8 8 port2 2.20
.ENDS LQG18HN10NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN12NJ00
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN12NJ00 port1 port2
C1 port1 port2 1.91e-14
L2 port1 1 1.30e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.06e+4
L4 port1 2 3.55e-7
R4 2 port2 810
L5 port1 3 2.26e-7
R5 3 port2 109
L6 port1 4 1.41e-7
R6 4 port2 14.2
L7 port1 5 2.57e-9
C7 5 6 2.51e-14
R7 6 port2 6.05
L8 port1 7 1.56e-9
C8 7 8 1.08e-13
R8 8 port2 2.65
.ENDS LQG18HN12NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN15NJ00
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN15NJ00 port1 port2
C1 port1 port2 2.76e-14
L2 port1 1 1.63e-8
R2 1 port2 1.70e-1
R3 port1 port2 2.37e+4
L4 port1 2 4.46e-7
R4 2 port2 1.07e+3
L5 port1 3 3.27e-7
R5 3 port2 161
L6 port1 4 1.29e-7
R6 4 port2 13.0
L7 port1 5 2.40e-9
C7 5 6 3.72e-14
R7 6 port2 4.80
L8 port1 7 1.46e-9
C8 7 8 1.33e-13
R8 8 port2 2.84
.ENDS LQG18HN15NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN18NJ00
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN18NJ00 port1 port2
C1 port1 port2 2.76e-14
L2 port1 1 2.01e-8
R2 1 port2 2.04e-1
R3 port1 port2 2.78e+4
L4 port1 2 5.49e-7
R4 2 port2 1.31e+3
L5 port1 3 3.84e-7
R5 3 port2 189
L6 port1 4 1.45e-7
R6 4 port2 14.6
L7 port1 5 1.29e-9
C7 5 6 8.32e-14
R7 6 port2 2.35
L8 port1 7 2.98e-9
C8 7 8 7.86e-14
R8 8 port2 5.28
.ENDS LQG18HN18NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN1N2S00
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN1N2S00 port1 port2
C1 port1 port2 6.94e-15
L2 port1 1 7.70e-10
R2 1 port2 1.17e-2
R3 port1 port2 1.84e+4
L4 port1 2 9.33e-8
R4 2 port2 379
L5 port1 3 6.67e-8
R5 3 port2 40.3
L6 port1 4 3.89e-6
R6 4 port2 461
L7 port1 5 3.27e-7
C7 5 6 3.75e-16
R7 6 port2 350
.ENDS LQG18HN1N2S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN1N5S00
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN1N5S00 port1 port2
C1 port1 port2 6.94e-15
L2 port1 1 9.69e-10
R2 1 port2 7.23e-3
R3 port1 port2 1.84e+4
L4 port1 2 9.33e-8
R4 2 port2 379
L5 port1 3 3.19e-8
R5 3 port2 15.3
L6 port1 4 4.47e-7
R6 4 port2 34.2
L7 port1 5 3.27e-7
C7 5 6 3.75e-16
R7 6 port2 350
.ENDS LQG18HN1N5S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN1N8S00
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN1N8S00 port1 port2
C1 port1 port2 6.94e-15
L2 port1 1 1.22e-9
R2 1 port2 2.45e-2
R3 port1 port2 1.84e+4
L4 port1 2 1.74e-7
R4 2 port2 706
L5 port1 3 4.21e-8
R5 3 port2 20.2
L6 port1 4 1.62e-5
R6 4 port2 1.63e+3
L7 port1 5 3.27e-7
C7 5 6 3.75e-16
R7 6 port2 350
.ENDS LQG18HN1N8S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN22NJ00
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN22NJ00 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 2.50e-8
R2 1 port2 3.09e-1
R3 port1 port2 2.72e+4
L4 port1 2 6.45e-7
R4 2 port2 1.51e+3
L5 port1 3 4.40e-7
R5 3 port2 217
L6 port1 4 1.95e-7
R6 4 port2 19.7
L7 port1 5 1.07e-9
C7 5 6 1.10e-13
R7 6 port2 1.87
L8 port1 7 4.69e-9
C8 7 8 1.44e-14
R8 8 port2 10.7
L9 port1 9 6.83e-9
C9 9 10 4.52e-14
R9 10 port2 8.37
L10 port1 11 1.10e-5
C10 11 12 6.71e-17
R10 12 port2 618
.ENDS LQG18HN22NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN27NJ00
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN27NJ00 port1 port2
C1 port1 port2 2.00e-14
L2 port1 1 3.01e-8
R2 1 port2 2.69e-1
R3 port1 port2 3.05e+4
L4 port1 2 9.11e-7
R4 2 port2 2.13e+3
L5 port1 3 5.42e-7
R5 3 port2 266
L6 port1 4 2.29e-7
R6 4 port2 23.1
L7 port1 5 1.52e-9
C7 5 6 9.34e-14
R7 6 port2 2.70
L8 port1 7 1.87e-9
C8 7 8 4.34e-14
R8 8 port2 3.88
L9 port1 9 9.43e-9
C9 9 10 4.12e-14
R9 10 port2 10.3
L10 port1 11 1.59e-5
C10 11 12 6.12e-17
R10 12 port2 1.95e+3
.ENDS LQG18HN27NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN2N2S00
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN2N2S00 port1 port2
C1 port1 port2 2.70e-14
L2 port1 1 1.85e-9
R2 1 port2 3.23e-2
R3 port1 port2 1.84e+4
L4 port1 2 1.02e-7
R4 2 port2 416
L5 port1 3 4.02e-8
R5 3 port2 19.3
L6 port1 4 5.13e-8
R6 4 port2 5.17
L7 port1 5 2.54e-9
C7 5 6 4.03e-14
R7 6 port2 4.29
.ENDS LQG18HN2N2S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN2N7S00
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN2N7S00 port1 port2
C1 port1 port2 1.26e-14
L2 port1 1 2.43e-9
R2 1 port2 5.00e-2
R3 port1 port2 2.42e+4
L4 port1 2 1.02e-7
R4 2 port2 456
L5 port1 3 4.30e-8
R5 3 port2 20.7
L6 port1 4 5.13e-8
R6 4 port2 5.17
L7 port1 5 2.02e-9
C7 5 6 3.20e-14
R7 6 port2 4.29
.ENDS LQG18HN2N7S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN33NJ00
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN33NJ00 port1 port2
C1 port1 port2 3.40e-14
L2 port1 1 3.70e-8
R2 1 port2 3.46e-1
R3 port1 port2 2.98e+4
L4 port1 2 1.23e-6
R4 2 port2 2.88e+3
L5 port1 3 5.94e-7
R5 3 port2 292
L6 port1 4 2.82e-7
R6 4 port2 28.4
L7 port1 5 2.04e-9
C7 5 6 7.95e-14
R7 6 port2 3.90
L8 port1 7 1.87e-9
C8 7 8 5.73e-14
R8 8 port2 3.38
L9 port1 9 1.49e-8
C9 9 10 3.43e-14
R9 10 port2 14.2
L10 port1 11 1.28e-8
C10 11 12 6.61e-15
R10 12 port2 21.7
L11 port1 13 6.94e-6
C11 13 14 1.85e-16
R11 14 port2 743
.ENDS LQG18HN33NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN39NJ00
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN39NJ00 port1 port2
C1 port1 port2 2.89e-14
L2 port1 1 4.46e-8
R2 1 port2 4.26e-1
R3 port1 port2 2.78e+4
L4 port1 2 1.51e-6
R4 2 port2 3.54e+3
L5 port1 3 6.52e-7
R5 3 port2 320
L6 port1 4 3.39e-7
R6 4 port2 34.2
L7 port1 5 4.27e-9
C7 5 6 4.57e-14
R7 6 port2 8.94
L8 port1 7 1.10e-9
C8 7 8 1.07e-13
R8 8 port2 1.90
L9 port1 9 2.66e-8
C9 9 10 2.43e-14
R9 10 port2 22.5
L10 port1 11 4.88e-9
C10 11 12 1.45e-14
R10 12 port2 18.0
L11 port1 13 1.32e-6
C11 13 14 1.11e-15
R11 14 port2 132
.ENDS LQG18HN39NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN3N3S00
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN3N3S00 port1 port2
C1 port1 port2 1.55e-14
L2 port1 1 3.13e-9
R2 1 port2 6.30e-2
R3 port1 port2 2.06e+4
L4 port1 2 1.15e-7
R4 2 port2 466
L5 port1 3 6.22e-8
R5 3 port2 29.9
L6 port1 4 5.13e-8
R6 4 port2 5.17
L7 port1 5 1.27e-9
C7 5 6 7.68e-14
R7 6 port2 2.53
.ENDS LQG18HN3N3S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN3N9S00
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN3N9S00 port1 port2
C1 port1 port2 2.58e-14
L2 port1 1 3.86e-9
R2 1 port2 7.40e-2
R3 port1 port2 2.06e+4
L4 port1 2 1.32e-7
R4 2 port2 488
L5 port1 3 6.98e-8
R5 3 port2 33.5
L6 port1 4 6.61e-8
R6 4 port2 6.66
L7 port1 5 1.72e-9
C7 5 6 4.12e-14
R7 6 port2 4.01
.ENDS LQG18HN3N9S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN47NJ00
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN47NJ00 port1 port2
C1 port1 port2 2.14e-14
L2 port1 1 5.25e-8
R2 1 port2 4.67e-1
R3 port1 port2 3.67e+4
L4 port1 2 1.86e-6
R4 2 port2 4.35e+3
L5 port1 3 8.39e-7
R5 3 port2 413
L6 port1 4 4.58e-7
R6 4 port2 46.1
L7 port1 5 6.17e-9
C7 5 6 3.80e-14
R7 6 port2 11.8
L8 port1 7 1.78e-9
C8 7 8 7.21e-14
R8 8 port2 1.02
L9 port1 9 3.12e-8
C9 9 10 2.37e-14
R9 10 port2 24.7
L10 port1 11 1.34e-9
C10 11 12 6.61e-14
R10 12 port2 4.42
L11 port1 13 7.44e-6
C11 13 14 2.49e-16
R11 14 port2 1.05e+3
.ENDS LQG18HN47NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN4N7S00
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN4N7S00 port1 port2
C1 port1 port2 2.35e-16
L2 port1 1 4.74e-9
R2 1 port2 8.12e-2
R3 port1 port2 2.21e+4
L4 port1 2 1.62e-7
R4 2 port2 601
L5 port1 3 8.02e-8
R5 3 port2 38.5
L6 port1 4 7.25e-8
R6 4 port2 7.30
L7 port1 5 1.11e-9
C7 5 6 9.67e-14
R7 6 port2 2.10
.ENDS LQG18HN4N7S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN56NJ00
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN56NJ00 port1 port2
C1 port1 port2 3.90e-14
L2 port1 1 6.39e-8
R2 1 port2 5.12e-1
R3 port1 port2 3.67e+4
L4 port1 2 2.04e-6
R4 2 port2 4.77e+3
L5 port1 3 1.03e-6
R5 3 port2 508
L6 port1 4 4.58e-7
R6 4 port2 46.1
L7 port1 5 1.20e-8
C7 5 6 2.46e-14
R7 6 port2 20.5
L8 port1 7 7.53e-9
C8 7 8 9.36e-15
R8 8 port2 17.6
L9 port1 9 2.14e-9
C9 9 10 6.88e-14
R9 10 port2 4.16
L10 port1 11 4.51e-8
C10 11 12 2.07e-14
R10 12 port2 40.1
L11 port1 13 1.47e-9
C11 13 14 7.25e-14
R11 14 port2 4.42
L12 port1 15 2.10e-5
C12 15 16 1.11e-16
R12 16 port2 6.18e+3
.ENDS LQG18HN56NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN5N6S00
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN5N6S00 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 5.70e-9
R2 1 port2 8.12e-2
R3 port1 port2 2.54e+4
L4 port1 2 1.78e-7
R4 2 port2 615
L5 port1 3 1.16e-7
R5 3 port2 55.7
L6 port1 4 7.25e-8
R6 4 port2 7.30
L7 port1 5 1.13e-9
C7 5 6 9.89e-14
R7 6 port2 2.10
.ENDS LQG18HN5N6S00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN68NJ00
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN68NJ00 port1 port2
C1 port1 port2 3.17e-14
L2 port1 1 7.71e-8
R2 1 port2 5.24e-1
R3 port1 port2 4.02e+4
L4 port1 2 2.69e-6
R4 2 port2 6.29e+3
L5 port1 3 1.30e-6
R5 3 port2 639
L6 port1 4 5.76e-7
R6 4 port2 58.0
L7 port1 5 2.19e-8
C7 5 6 1.55e-14
R7 6 port2 34.8
L8 port1 7 1.04e-8
C8 7 8 7.10e-15
R8 8 port2 23.8
L9 port1 9 4.91e-9
C9 9 10 3.45e-14
R9 10 port2 10.7
L10 port1 11 7.84e-8
C10 11 12 1.43e-14
R10 12 port2 49.3
L11 port1 13 8.28e-10
C11 13 14 1.35e-13
R11 14 port2 2.43
.ENDS LQG18HN68NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN6N8J00
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN6N8J00 port1 port2
C1 port1 port2 1.70e-14
L2 port1 1 7.18e-9
R2 1 port2 8.12e-2
R3 port1 port2 2.54e+4
L4 port1 2 2.09e-7
R4 2 port2 722
L5 port1 3 1.16e-7
R5 3 port2 55.7
L6 port1 4 7.25e-8
R6 4 port2 7.30
L7 port1 5 1.13e-9
C7 5 6 9.02e-14
R7 6 port2 2.20
.ENDS LQG18HN6N8J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN82NJ00
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN82NJ00 port1 port2
C1 port1 port2 3.72e-14
L2 port1 1 9.44e-8
R2 1 port2 6.75e-1
R3 port1 port2 4.02e+4
L4 port1 2 3.38e-6
R4 2 port2 7.92e+3
L5 port1 3 1.40e-6
R5 3 port2 685
L6 port1 4 6.92e-7
R6 4 port2 69.7
L7 port1 5 2.57e-8
C7 5 6 1.83e-14
R7 6 port2 55.1
L8 port1 7 2.67e-8
C8 7 8 2.65e-15
R8 8 port2 103
L9 port1 9 2.08e-9
C9 9 10 5.64e-14
R9 10 port2 2.49
L10 port1 11 5.64e-9
C10 11 12 3.96e-14
R10 12 port2 20.5
L11 port1 13 9.00e-8
C11 13 14 1.64e-14
R11 14 port2 55.3
L12 port1 15 1.85e-9
C12 15 16 7.59e-14
R12 16 port2 4.85
.ENDS LQG18HN82NJ00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HN8N2J00
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HN8N2J00 port1 port2
C1 port1 port2 2.64e-14
L2 port1 1 8.84e-9
R2 1 port2 1.07e-1
R3 port1 port2 2.54e+4
L4 port1 2 2.57e-7
R4 2 port2 868
L5 port1 3 1.43e-7
R5 3 port2 68.5
L6 port1 4 7.25e-8
R6 4 port2 7.30
L7 port1 5 1.13e-9
C7 5 6 1.19e-13
R7 6 port2 1.56
.ENDS LQG18HN8N2J00
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQG18HNR10J00
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQG18HNR10J00 port1 port2
C1 port1 port2 4.68e-14
L2 port1 1 1.12e-7
R2 1 port2 7.41e-1
R3 port1 port2 5.30e+4
L4 port1 2 3.54e-6
R4 2 port2 8.29e+3
L5 port1 3 1.89e-6
R5 3 port2 924
L6 port1 4 7.95e-7
R6 4 port2 80.0
L7 port1 5 3.24e-8
C7 5 6 1.83e-14
R7 6 port2 57.7
L8 port1 7 1.53e-9
C8 7 8 6.07e-14
R8 8 port2 5.29
L9 port1 9 2.23e-9
C9 9 10 5.77e-14
R9 10 port2 2.55
L10 port1 11 2.05e-8
C10 11 12 1.44e-14
R10 12 port2 24.6
L11 port1 13 9.43e-8
C11 13 14 1.88e-14
R11 14 port2 59.3
L12 port1 15 2.13e-9
C12 15 16 8.32e-14
R12 16 port2 5.83
L13 port1 17 6.44e-6
C13 17 18 6.91e-16
R13 18 port2 3.42e+3
.ENDS LQG18HNR10J00
*----------------------------------------------------------------------
