*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N6B02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N6B02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 3.24e-10
R2 1 port2 3.72e-3
R3 port1 port2 9.63e+3
L4 port1 2 3.79e-9
R4 2 port2 1.22e-2
L5 port1 3 9.21e-9
R5 3 port2 5.25
L6 port1 4 2.09e-7
R6 4 port2 436
.ENDS LQP03HQ0N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N6C02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N6C02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 3.24e-10
R2 1 port2 3.72e-3
R3 port1 port2 9.63e+3
L4 port1 2 3.79e-9
R4 2 port2 1.22e-2
L5 port1 3 9.21e-9
R5 3 port2 5.25
L6 port1 4 2.09e-7
R6 4 port2 436
.ENDS LQP03HQ0N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N6W02
* Property : L = 0.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N6W02 port1 port2
C1 port1 port2 4.53e-14
L2 port1 1 3.24e-10
R2 1 port2 3.72e-3
R3 port1 port2 9.63e+3
L4 port1 2 3.79e-9
R4 2 port2 1.22e-2
L5 port1 3 9.21e-9
R5 3 port2 5.25
L6 port1 4 2.09e-7
R6 4 port2 436
.ENDS LQP03HQ0N6W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N7B02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N7B02 port1 port2
C1 port1 port2 1.09e-14
L2 port1 1 5.25e-10
R2 1 port2 6.31e-3
R3 port1 port2 8.79e+3
L4 port1 2 2.88e-8
R4 2 port2 21.6
L5 port1 3 1.84e-9
R5 3 port2 1.66e-3
L6 port1 4 5.51e-8
R6 4 port2 174
.ENDS LQP03HQ0N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N7C02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N7C02 port1 port2
C1 port1 port2 1.09e-14
L2 port1 1 5.25e-10
R2 1 port2 6.31e-3
R3 port1 port2 8.79e+3
L4 port1 2 2.88e-8
R4 2 port2 21.6
L5 port1 3 1.84e-9
R5 3 port2 1.66e-3
L6 port1 4 5.51e-8
R6 4 port2 174
.ENDS LQP03HQ0N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N7W02
* Property : L = 0.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N7W02 port1 port2
C1 port1 port2 1.09e-14
L2 port1 1 5.25e-10
R2 1 port2 6.31e-3
R3 port1 port2 8.79e+3
L4 port1 2 2.88e-8
R4 2 port2 21.6
L5 port1 3 1.84e-9
R5 3 port2 1.66e-3
L6 port1 4 5.51e-8
R6 4 port2 174
.ENDS LQP03HQ0N7W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N8B02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N8B02 port1 port2
C1 port1 port2 2.07e-14
L2 port1 1 5.37e-10
R2 1 port2 8.51e-3
R3 port1 port2 8.79e+3
L4 port1 2 9.30e-9
R4 2 port2 7.86
L5 port1 3 2.16e-6
R5 3 port2 2.82e+3
L6 port1 4 1.07e-8
R6 4 port2 6.45e-1
.ENDS LQP03HQ0N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N8C02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N8C02 port1 port2
C1 port1 port2 2.07e-14
L2 port1 1 5.37e-10
R2 1 port2 8.51e-3
R3 port1 port2 8.79e+3
L4 port1 2 9.30e-9
R4 2 port2 7.86
L5 port1 3 2.16e-6
R5 3 port2 2.82e+3
L6 port1 4 1.07e-8
R6 4 port2 6.45e-1
.ENDS LQP03HQ0N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N8W02
* Property : L = 0.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N8W02 port1 port2
C1 port1 port2 2.07e-14
L2 port1 1 5.37e-10
R2 1 port2 8.51e-3
R3 port1 port2 8.79e+3
L4 port1 2 9.30e-9
R4 2 port2 7.86
L5 port1 3 2.16e-6
R5 3 port2 2.82e+3
L6 port1 4 1.07e-8
R6 4 port2 6.45e-1
.ENDS LQP03HQ0N8W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N9B02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N9B02 port1 port2
C1 port1 port2 2.38e-14
L2 port1 1 1.00e-9
R2 1 port2 3.24e-2
R3 port1 port2 5.94e+3
L4 port1 2 5.48e-8
R4 2 port2 212
L5 port1 3 5.06e-9
R5 3 port2 1.38
L6 port1 4 2.10e-9
R6 4 port2 8.48e-2
.ENDS LQP03HQ0N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N9C02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N9C02 port1 port2
C1 port1 port2 2.38e-14
L2 port1 1 1.00e-9
R2 1 port2 3.24e-2
R3 port1 port2 5.94e+3
L4 port1 2 5.48e-8
R4 2 port2 212
L5 port1 3 5.06e-9
R5 3 port2 1.38
L6 port1 4 2.10e-9
R6 4 port2 8.48e-2
.ENDS LQP03HQ0N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ0N9W02
* Property : L = 0.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ0N9W02 port1 port2
C1 port1 port2 2.38e-14
L2 port1 1 1.00e-9
R2 1 port2 3.24e-2
R3 port1 port2 5.94e+3
L4 port1 2 5.48e-8
R4 2 port2 212
L5 port1 3 5.06e-9
R5 3 port2 1.38
L6 port1 4 2.10e-9
R6 4 port2 8.48e-2
.ENDS LQP03HQ0N9W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ10NH02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ10NH02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 1.05e-8
R2 1 port2 2.70e-1
R3 port1 port2 2.00e+4
L4 port1 2 4.60e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ10NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ10NJ02
* Property : L = 10[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ10NJ02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 1.05e-8
R2 1 port2 2.70e-1
R3 port1 port2 2.00e+4
L4 port1 2 4.60e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ10NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ11NH02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ11NH02 port1 port2
C1 port1 port2 8.30e-14
L2 port1 1 1.16e-8
R2 1 port2 2.90e-1
R3 port1 port2 2.00e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.75e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 3.70e-15
R7 6 port2 60.0
.ENDS LQP03HQ11NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ11NJ02
* Property : L = 11[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ11NJ02 port1 port2
C1 port1 port2 8.30e-14
L2 port1 1 1.16e-8
R2 1 port2 2.90e-1
R3 port1 port2 2.00e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.75e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 3.70e-15
R7 6 port2 60.0
.ENDS LQP03HQ11NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ12NH02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ12NH02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 1.27e-8
R2 1 port2 2.70e-1
R3 port1 port2 2.00e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.80e-7
R6 4 port2 62.0
L7 port1 5 1.46e-8
C7 5 6 4.70e-15
R7 6 port2 60.0
.ENDS LQP03HQ12NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ12NJ02
* Property : L = 12[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ12NJ02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 1.27e-8
R2 1 port2 2.70e-1
R3 port1 port2 2.00e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.80e-7
R6 4 port2 62.0
L7 port1 5 1.46e-8
C7 5 6 4.70e-15
R7 6 port2 60.0
.ENDS LQP03HQ12NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ13NH02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ13NH02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 1.38e-8
R2 1 port2 3.20e-1
R3 port1 port2 2.40e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 2.30e-7
R6 4 port2 62.0
L7 port1 5 1.46e-8
C7 5 6 5.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ13NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ13NJ02
* Property : L = 13[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ13NJ02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 1.38e-8
R2 1 port2 3.20e-1
R3 port1 port2 2.40e+4
L4 port1 2 5.00e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 2.30e-7
R6 4 port2 62.0
L7 port1 5 1.46e-8
C7 5 6 5.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ13NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ15NH02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ15NH02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 1.58e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.35e+4
L4 port1 2 5.60e-7
R4 2 port2 2.00e+3
L5 port1 3 6.50e-7
R5 3 port2 900
L6 port1 4 3.00e-7
R6 4 port2 68.0
L7 port1 5 1.45e-8
C7 5 6 6.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ15NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ15NJ02
* Property : L = 15[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ15NJ02 port1 port2
C1 port1 port2 7.80e-14
L2 port1 1 1.58e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.35e+4
L4 port1 2 5.60e-7
R4 2 port2 2.00e+3
L5 port1 3 6.50e-7
R5 3 port2 900
L6 port1 4 3.00e-7
R6 4 port2 68.0
L7 port1 5 1.45e-8
C7 5 6 6.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ15NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ16NH02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ16NH02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 1.69e-8
R2 1 port2 4.00e-1
R3 port1 port2 2.20e+4
L4 port1 2 6.00e-7
R4 2 port2 2.00e+3
L5 port1 3 6.50e-7
R5 3 port2 900
L6 port1 4 3.00e-7
R6 4 port2 68.0
L7 port1 5 1.45e-8
C7 5 6 5.35e-15
R7 6 port2 50.0
.ENDS LQP03HQ16NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ16NJ02
* Property : L = 16[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ16NJ02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 1.69e-8
R2 1 port2 4.00e-1
R3 port1 port2 2.20e+4
L4 port1 2 6.00e-7
R4 2 port2 2.00e+3
L5 port1 3 6.50e-7
R5 3 port2 900
L6 port1 4 3.00e-7
R6 4 port2 68.0
L7 port1 5 1.45e-8
C7 5 6 5.35e-15
R7 6 port2 50.0
.ENDS LQP03HQ16NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ18NH02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ18NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.92e-8
R2 1 port2 4.80e-1
R3 port1 port2 2.75e+4
L4 port1 2 8.00e-7
R4 2 port2 3.00e+3
L5 port1 3 6.50e-7
R5 3 port2 1.30e+3
L6 port1 4 3.00e-7
R6 4 port2 70.0
L7 port1 5 1.45e-8
C7 5 6 6.00e-15
R7 6 port2 80.0
.ENDS LQP03HQ18NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ18NJ02
* Property : L = 18[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ18NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.92e-8
R2 1 port2 4.80e-1
R3 port1 port2 2.75e+4
L4 port1 2 8.00e-7
R4 2 port2 3.00e+3
L5 port1 3 6.50e-7
R5 3 port2 1.30e+3
L6 port1 4 3.00e-7
R6 4 port2 70.0
L7 port1 5 1.45e-8
C7 5 6 6.00e-15
R7 6 port2 80.0
.ENDS LQP03HQ18NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N0B02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N0B02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 8.32e-10
R2 1 port2 7.42e-3
R3 port1 port2 6.22e+3
L4 port1 2 4.35e-8
R4 2 port2 237
L5 port1 3 4.02e-9
R5 3 port2 7.76e-1
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N0C02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N0C02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 8.32e-10
R2 1 port2 7.42e-3
R3 port1 port2 6.22e+3
L4 port1 2 4.35e-8
R4 2 port2 237
L5 port1 3 4.02e-9
R5 3 port2 7.76e-1
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N0W02
* Property : L = 1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N0W02 port1 port2
C1 port1 port2 7.18e-14
L2 port1 1 8.32e-10
R2 1 port2 7.42e-3
R3 port1 port2 6.22e+3
L4 port1 2 4.35e-8
R4 2 port2 237
L5 port1 3 4.02e-9
R5 3 port2 7.76e-1
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N0W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N1B02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N1B02 port1 port2
C1 port1 port2 7.02e-14
L2 port1 1 9.34e-10
R2 1 port2 2.29e-2
R3 port1 port2 6.98e+3
L4 port1 2 6.59e-8
R4 2 port2 313
L5 port1 3 1.08e-8
R5 3 port2 1.86e-2
L6 port1 4 1.63e-8
R6 4 port2 5.49
.ENDS LQP03HQ1N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N1C02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N1C02 port1 port2
C1 port1 port2 7.02e-14
L2 port1 1 9.34e-10
R2 1 port2 2.29e-2
R3 port1 port2 6.98e+3
L4 port1 2 6.59e-8
R4 2 port2 313
L5 port1 3 1.08e-8
R5 3 port2 1.86e-2
L6 port1 4 1.63e-8
R6 4 port2 5.49
.ENDS LQP03HQ1N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N1W02
* Property : L = 1.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N1W02 port1 port2
C1 port1 port2 7.02e-14
L2 port1 1 9.34e-10
R2 1 port2 2.29e-2
R3 port1 port2 6.98e+3
L4 port1 2 6.59e-8
R4 2 port2 313
L5 port1 3 1.08e-8
R5 3 port2 1.86e-2
L6 port1 4 1.63e-8
R6 4 port2 5.49
.ENDS LQP03HQ1N1W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N2B02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N2B02 port1 port2
C1 port1 port2 8.44e-14
L2 port1 1 9.34e-10
R2 1 port2 1.82e-2
R3 port1 port2 6.98e+3
L4 port1 2 5.74e-8
R4 2 port2 227
L5 port1 3 6.08e-9
R5 3 port2 1.70
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N2C02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N2C02 port1 port2
C1 port1 port2 8.44e-14
L2 port1 1 9.34e-10
R2 1 port2 1.82e-2
R3 port1 port2 6.98e+3
L4 port1 2 5.74e-8
R4 2 port2 227
L5 port1 3 6.08e-9
R5 3 port2 1.70
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N2W02
* Property : L = 1.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N2W02 port1 port2
C1 port1 port2 8.44e-14
L2 port1 1 9.34e-10
R2 1 port2 1.82e-2
R3 port1 port2 6.98e+3
L4 port1 2 5.74e-8
R4 2 port2 227
L5 port1 3 6.08e-9
R5 3 port2 1.70
L6 port1 4 9.14e-5
R6 4 port2 10.2
.ENDS LQP03HQ1N2W02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N3B02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N3B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.03e-9
R2 1 port2 2.20e-2
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N3C02
* Property : L = 1.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N3C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.03e-9
R2 1 port2 2.20e-2
R3 port1 port2 5.00e+3
L4 port1 2 6.50e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N4B02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N4B02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 3.20e-2
R3 port1 port2 5.20e+3
L4 port1 2 6.50e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N4C02
* Property : L = 1.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N4C02 port1 port2
C1 port1 port2 5.00e-14
L2 port1 1 1.13e-9
R2 1 port2 3.20e-2
R3 port1 port2 5.20e+3
L4 port1 2 6.50e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N5B02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N5B02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 1.24e-9
R2 1 port2 2.50e-2
R3 port1 port2 5.20e+3
L4 port1 2 7.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N5C02
* Property : L = 1.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N5C02 port1 port2
C1 port1 port2 5.80e-14
L2 port1 1 1.24e-9
R2 1 port2 2.50e-2
R3 port1 port2 5.20e+3
L4 port1 2 7.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N6B02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N6B02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 1.34e-9
R2 1 port2 2.50e-2
R3 port1 port2 5.80e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N6C02
* Property : L = 1.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N6C02 port1 port2
C1 port1 port2 5.30e-14
L2 port1 1 1.34e-9
R2 1 port2 2.50e-2
R3 port1 port2 5.80e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N7B02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N7B02 port1 port2
C1 port1 port2 6.55e-14
L2 port1 1 1.45e-9
R2 1 port2 2.80e-2
R3 port1 port2 6.30e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.70e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N7C02
* Property : L = 1.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N7C02 port1 port2
C1 port1 port2 6.55e-14
L2 port1 1 1.45e-9
R2 1 port2 2.80e-2
R3 port1 port2 6.30e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 6.70e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N8B02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N8B02 port1 port2
C1 port1 port2 6.75e-14
L2 port1 1 1.55e-9
R2 1 port2 4.20e-2
R3 port1 port2 7.00e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N8C02
* Property : L = 1.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N8C02 port1 port2
C1 port1 port2 6.75e-14
L2 port1 1 1.55e-9
R2 1 port2 4.20e-2
R3 port1 port2 7.00e+3
L4 port1 2 7.20e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N9B02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N9B02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 1.66e-9
R2 1 port2 4.50e-2
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ1N9C02
* Property : L = 1.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ1N9C02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 1.66e-9
R2 1 port2 4.50e-2
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ1N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ20NH02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ20NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.16e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.40e+4
L4 port1 2 1.40e-6
R4 2 port2 2.20e+3
L5 port1 3 6.00e-7
R5 3 port2 1.70e+3
L6 port1 4 2.80e-7
R6 4 port2 75.0
L7 port1 5 1.50e-8
C7 5 6 8.00e-15
R7 6 port2 80.0
.ENDS LQP03HQ20NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ20NJ02
* Property : L = 20[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ20NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.16e-8
R2 1 port2 4.50e-1
R3 port1 port2 2.40e+4
L4 port1 2 1.40e-6
R4 2 port2 2.20e+3
L5 port1 3 6.00e-7
R5 3 port2 1.70e+3
L6 port1 4 2.80e-7
R6 4 port2 75.0
L7 port1 5 1.50e-8
C7 5 6 8.00e-15
R7 6 port2 80.0
.ENDS LQP03HQ20NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ22NH02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ22NH02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.40e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.70e+4
L4 port1 2 1.20e-6
R4 2 port2 1.50e+3
L5 port1 3 6.00e-7
R5 3 port2 1.70e+3
L6 port1 4 2.80e-7
R6 4 port2 50.0
L7 port1 5 1.50e-8
C7 5 6 8.00e-15
R7 6 port2 100
.ENDS LQP03HQ22NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ22NJ02
* Property : L = 22[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ22NJ02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 2.40e-8
R2 1 port2 5.20e-1
R3 port1 port2 2.70e+4
L4 port1 2 1.20e-6
R4 2 port2 1.50e+3
L5 port1 3 6.00e-7
R5 3 port2 1.70e+3
L6 port1 4 2.80e-7
R6 4 port2 50.0
L7 port1 5 1.50e-8
C7 5 6 8.00e-15
R7 6 port2 100
.ENDS LQP03HQ22NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ24NH02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ24NH02 port1 port2
C1 port1 port2 9.61e-14
L2 port1 1 2.35e-8
R2 1 port2 7.18e-1
R3 port1 port2 2.70e+4
L4 port1 2 7.93e-7
R4 2 port2 2.67e+3
L5 port1 3 4.77e-7
R5 3 port2 381
L6 port1 4 1.09e-4
R6 4 port2 2.13e+3
L7 port1 5 2.12e-8
C7 5 6 7.82e-15
R7 6 port2 120
.ENDS LQP03HQ24NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ24NJ02
* Property : L = 24[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ24NJ02 port1 port2
C1 port1 port2 9.61e-14
L2 port1 1 2.35e-8
R2 1 port2 7.18e-1
R3 port1 port2 2.70e+4
L4 port1 2 7.93e-7
R4 2 port2 2.67e+3
L5 port1 3 4.77e-7
R5 3 port2 381
L6 port1 4 1.09e-4
R6 4 port2 2.13e+3
L7 port1 5 2.12e-8
C7 5 6 7.82e-15
R7 6 port2 120
.ENDS LQP03HQ24NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ27NH02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ27NH02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 2.69e-8
R2 1 port2 1.14
R3 port1 port2 2.70e+4
L4 port1 2 2.13e-6
R4 2 port2 1.43e+4
L5 port1 3 6.73e-7
R5 3 port2 1.00e+3
L6 port1 4 1.37e-6
R6 4 port2 426
L7 port1 5 1.93e-8
C7 5 6 9.40e-15
R7 6 port2 105
.ENDS LQP03HQ27NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ27NJ02
* Property : L = 27[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ27NJ02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 2.69e-8
R2 1 port2 1.14
R3 port1 port2 2.70e+4
L4 port1 2 2.13e-6
R4 2 port2 1.43e+4
L5 port1 3 6.73e-7
R5 3 port2 1.00e+3
L6 port1 4 1.37e-6
R6 4 port2 426
L7 port1 5 1.93e-8
C7 5 6 9.40e-15
R7 6 port2 105
.ENDS LQP03HQ27NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N0B02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N0B02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 1.76e-9
R2 1 port2 5.80e-2
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ2N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N0C02
* Property : L = 2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N0C02 port1 port2
C1 port1 port2 6.00e-14
L2 port1 1 1.76e-9
R2 1 port2 5.80e-2
R3 port1 port2 7.00e+3
L4 port1 2 8.00e-8
R4 2 port2 160
L5 port1 3 2.70e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 60.0
.ENDS LQP03HQ2N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N1B02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N1B02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.89e-9
R2 1 port2 3.30e-2
R3 port1 port2 7.50e+3
L4 port1 2 6.80e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ2N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N1C02
* Property : L = 2.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N1C02 port1 port2
C1 port1 port2 6.30e-14
L2 port1 1 1.89e-9
R2 1 port2 3.30e-2
R3 port1 port2 7.50e+3
L4 port1 2 6.80e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ2N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N2B02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N2B02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.99e-9
R2 1 port2 3.30e-2
R3 port1 port2 7.50e+3
L4 port1 2 7.30e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ2N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N2C02
* Property : L = 2.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N2C02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 1.99e-9
R2 1 port2 3.30e-2
R3 port1 port2 7.50e+3
L4 port1 2 7.30e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ2N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N3B02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N3B02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.09e-9
R2 1 port2 3.80e-2
R3 port1 port2 8.00e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N3C02
* Property : L = 2.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N3C02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.09e-9
R2 1 port2 3.80e-2
R3 port1 port2 8.00e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N4B02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N4B02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.20e-9
R2 1 port2 3.20e-2
R3 port1 port2 8.00e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N4C02
* Property : L = 2.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N4C02 port1 port2
C1 port1 port2 6.80e-14
L2 port1 1 2.20e-9
R2 1 port2 3.20e-2
R3 port1 port2 8.00e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N5B02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N5B02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.30e-9
R2 1 port2 4.00e-2
R3 port1 port2 8.20e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N5C02
* Property : L = 2.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N5C02 port1 port2
C1 port1 port2 7.00e-14
L2 port1 1 2.30e-9
R2 1 port2 4.00e-2
R3 port1 port2 8.20e+3
L4 port1 2 7.70e-8
R4 2 port2 160
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N6B02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N6B02 port1 port2
C1 port1 port2 7.75e-14
L2 port1 1 2.43e-9
R2 1 port2 5.00e-2
R3 port1 port2 8.20e+3
L4 port1 2 1.00e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N6C02
* Property : L = 2.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N6C02 port1 port2
C1 port1 port2 7.75e-14
L2 port1 1 2.43e-9
R2 1 port2 5.00e-2
R3 port1 port2 8.20e+3
L4 port1 2 1.00e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.00e-8
R6 4 port2 50.0
.ENDS LQP03HQ2N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N7B02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N7B02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 2.54e-9
R2 1 port2 4.20e-2
R3 port1 port2 9.00e+3
L4 port1 2 9.00e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 45.0
.ENDS LQP03HQ2N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N7C02
* Property : L = 2.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N7C02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 2.54e-9
R2 1 port2 4.20e-2
R3 port1 port2 9.00e+3
L4 port1 2 9.00e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 45.0
.ENDS LQP03HQ2N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N8B02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N8B02 port1 port2
C1 port1 port2 9.10e-14
L2 port1 1 2.63e-9
R2 1 port2 4.50e-2
R3 port1 port2 9.00e+3
L4 port1 2 1.10e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 70.0
.ENDS LQP03HQ2N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N8C02
* Property : L = 2.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N8C02 port1 port2
C1 port1 port2 9.10e-14
L2 port1 1 2.63e-9
R2 1 port2 4.50e-2
R3 port1 port2 9.00e+3
L4 port1 2 1.10e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 70.0
.ENDS LQP03HQ2N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N9B02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N9B02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 2.75e-9
R2 1 port2 5.00e-2
R3 port1 port2 9.00e+3
L4 port1 2 9.00e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 45.0
.ENDS LQP03HQ2N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ2N9C02
* Property : L = 2.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ2N9C02 port1 port2
C1 port1 port2 9.00e-14
L2 port1 1 2.75e-9
R2 1 port2 5.00e-2
R3 port1 port2 9.00e+3
L4 port1 2 9.00e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 45.0
.ENDS LQP03HQ2N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ30NH02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ30NH02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 3.09e-8
R2 1 port2 7.01e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.97e-7
R4 2 port2 474
L5 port1 3 7.55e-7
R5 3 port2 155
L6 port1 4 2.08e-3
R6 4 port2 3.23e+4
L7 port1 5 2.27e-8
C7 5 6 8.00e-15
R7 6 port2 123
.ENDS LQP03HQ30NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ30NJ02
* Property : L = 30[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ30NJ02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 3.09e-8
R2 1 port2 7.01e-1
R3 port1 port2 1.52e+4
L4 port1 2 3.97e-7
R4 2 port2 474
L5 port1 3 7.55e-7
R5 3 port2 155
L6 port1 4 2.08e-3
R6 4 port2 3.23e+4
L7 port1 5 2.27e-8
C7 5 6 8.00e-15
R7 6 port2 123
.ENDS LQP03HQ30NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ33NH02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ33NH02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 3.39e-8
R2 1 port2 8.43e-1
R3 port1 port2 1.74e+4
L4 port1 2 5.36e-7
R4 2 port2 718
L5 port1 3 8.87e-7
R5 3 port2 257
L6 port1 4 2.08e-3
R6 4 port2 3.23e+4
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ33NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ33NJ02
* Property : L = 33[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ33NJ02 port1 port2
C1 port1 port2 9.18e-14
L2 port1 1 3.39e-8
R2 1 port2 8.43e-1
R3 port1 port2 1.74e+4
L4 port1 2 5.36e-7
R4 2 port2 718
L5 port1 3 8.87e-7
R5 3 port2 257
L6 port1 4 2.08e-3
R6 4 port2 3.23e+4
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ33NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ36NH02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ36NH02 port1 port2
C1 port1 port2 9.40e-14
L2 port1 1 3.98e-8
R2 1 port2 8.43e-1
R3 port1 port2 1.74e+4
L4 port1 2 6.15e-7
R4 2 port2 904
L5 port1 3 5.73e-7
R5 3 port2 135
L6 port1 4 2.08e-6
R6 4 port2 15.8
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ36NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ36NJ02
* Property : L = 36[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ36NJ02 port1 port2
C1 port1 port2 9.40e-14
L2 port1 1 3.98e-8
R2 1 port2 8.43e-1
R3 port1 port2 1.74e+4
L4 port1 2 6.15e-7
R4 2 port2 904
L5 port1 3 5.73e-7
R5 3 port2 135
L6 port1 4 2.08e-6
R6 4 port2 15.8
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ36NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ39NH02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ39NH02 port1 port2
C1 port1 port2 9.40e-14
L2 port1 1 4.27e-8
R2 1 port2 9.46e-1
R3 port1 port2 1.91e+4
L4 port1 2 6.91e-7
R4 2 port2 1.04e+3
L5 port1 3 6.58e-7
R5 3 port2 155
L6 port1 4 1.98e-6
R6 4 port2 15.8
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ39NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ39NJ02
* Property : L = 39[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ39NJ02 port1 port2
C1 port1 port2 9.40e-14
L2 port1 1 4.27e-8
R2 1 port2 9.46e-1
R3 port1 port2 1.91e+4
L4 port1 2 6.91e-7
R4 2 port2 1.04e+3
L5 port1 3 6.58e-7
R5 3 port2 155
L6 port1 4 1.98e-6
R6 4 port2 15.8
L7 port1 5 2.43e-8
C7 5 6 8.57e-15
R7 6 port2 123
.ENDS LQP03HQ39NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N0B02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N0B02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 2.86e-9
R2 1 port2 5.50e-2
R3 port1 port2 1.03e+4
L4 port1 2 9.20e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.50e-8
R6 4 port2 40.0
.ENDS LQP03HQ3N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N0C02
* Property : L = 3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N0C02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 2.86e-9
R2 1 port2 5.50e-2
R3 port1 port2 1.03e+4
L4 port1 2 9.20e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 7.50e-8
R6 4 port2 40.0
.ENDS LQP03HQ3N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N1B02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N1B02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 2.97e-9
R2 1 port2 6.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 9.20e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ3N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N1C02
* Property : L = 3.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N1C02 port1 port2
C1 port1 port2 7.50e-14
L2 port1 1 2.97e-9
R2 1 port2 6.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 9.20e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 40.0
.ENDS LQP03HQ3N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N2B02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N2B02 port1 port2
C1 port1 port2 8.10e-14
L2 port1 1 3.07e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 9.00e-8
R6 4 port2 35.0
.ENDS LQP03HQ3N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N2C02
* Property : L = 3.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N2C02 port1 port2
C1 port1 port2 8.10e-14
L2 port1 1 3.07e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 9.50e-8
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 9.00e-8
R6 4 port2 35.0
.ENDS LQP03HQ3N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N3B02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N3B02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.19e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 1.05e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 30.0
.ENDS LQP03HQ3N3B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N3C02
* Property : L = 3.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N3C02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.19e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.10e+4
L4 port1 2 1.05e-7
R4 2 port2 150
L5 port1 3 3.00e-7
R5 3 port2 2.00e+3
L6 port1 4 8.00e-8
R6 4 port2 30.0
.ENDS LQP03HQ3N3C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N4B02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N4B02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 3.40e-9
R2 1 port2 5.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 3.90e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N4B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N4C02
* Property : L = 3.4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N4C02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 3.40e-9
R2 1 port2 5.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 3.90e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N4C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N5B02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N5B02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.49e-9
R2 1 port2 7.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 4.30e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N5B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N5C02
* Property : L = 3.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N5C02 port1 port2
C1 port1 port2 8.20e-14
L2 port1 1 3.49e-9
R2 1 port2 7.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 4.30e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N5C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N6B02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N6B02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 9.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 3.00e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 4.50e-8
R6 4 port2 20.0
.ENDS LQP03HQ3N6B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N6C02
* Property : L = 3.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N6C02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 3.59e-9
R2 1 port2 9.50e-2
R3 port1 port2 1.00e+4
L4 port1 2 3.00e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 4.50e-8
R6 4 port2 20.0
.ENDS LQP03HQ3N6C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N7B02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N7B02 port1 port2
C1 port1 port2 7.75e-14
L2 port1 1 3.69e-9
R2 1 port2 9.50e-2
R3 port1 port2 1.05e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.00e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N7B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N7C02
* Property : L = 3.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N7C02 port1 port2
C1 port1 port2 7.75e-14
L2 port1 1 3.69e-9
R2 1 port2 9.50e-2
R3 port1 port2 1.05e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.00e-8
R6 4 port2 18.0
.ENDS LQP03HQ3N7C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N8B02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N8B02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 3.79e-9
R2 1 port2 6.40e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 28.0
.ENDS LQP03HQ3N8B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N8C02
* Property : L = 3.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N8C02 port1 port2
C1 port1 port2 7.30e-14
L2 port1 1 3.79e-9
R2 1 port2 6.40e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 28.0
.ENDS LQP03HQ3N8C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N9B02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N9B02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.90e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.20e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 28.0
.ENDS LQP03HQ3N9B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ3N9C02
* Property : L = 3.9[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ3N9C02 port1 port2
C1 port1 port2 7.40e-14
L2 port1 1 3.90e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.20e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 28.0
.ENDS LQP03HQ3N9C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ43NH02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ43NH02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 4.79e-8
R2 1 port2 1.01
R3 port1 port2 1.91e+4
L4 port1 2 6.59e-7
R4 2 port2 925
L5 port1 3 6.43e-7
R5 3 port2 115
L6 port1 4 1.98e-6
R6 4 port2 15.8
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.57e-8
C8 7 8 5.53e-15
R8 8 port2 123
.ENDS LQP03HQ43NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ43NJ02
* Property : L = 43[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ43NJ02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 4.79e-8
R2 1 port2 1.01
R3 port1 port2 1.91e+4
L4 port1 2 6.59e-7
R4 2 port2 925
L5 port1 3 6.43e-7
R5 3 port2 115
L6 port1 4 1.98e-6
R6 4 port2 15.8
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.57e-8
C8 7 8 5.53e-15
R8 8 port2 123
.ENDS LQP03HQ43NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ47NH02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ47NH02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 5.13e-8
R2 1 port2 1.16
R3 port1 port2 2.58e+4
L4 port1 2 9.10e-7
R4 2 port2 1.53e+3
L5 port1 3 6.00e-7
R5 3 port2 145
L6 port1 4 1.94e-6
R6 4 port2 62.9
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.57e-8
C8 7 8 5.53e-15
R8 8 port2 123
.ENDS LQP03HQ47NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ47NJ02
* Property : L = 47[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ47NJ02 port1 port2
C1 port1 port2 8.97e-14
L2 port1 1 5.13e-8
R2 1 port2 1.16
R3 port1 port2 2.58e+4
L4 port1 2 9.10e-7
R4 2 port2 1.53e+3
L5 port1 3 6.00e-7
R5 3 port2 145
L6 port1 4 1.94e-6
R6 4 port2 62.9
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.57e-8
C8 7 8 5.53e-15
R8 8 port2 123
.ENDS LQP03HQ47NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N0B02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N0B02 port1 port2
C1 port1 port2 7.65e-14
L2 port1 1 4.03e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N0B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N0C02
* Property : L = 4[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N0C02 port1 port2
C1 port1 port2 7.65e-14
L2 port1 1 4.03e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.40e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N0C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N1B02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N1B02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 4.14e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.60e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N1B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N1C02
* Property : L = 4.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N1C02 port1 port2
C1 port1 port2 7.20e-14
L2 port1 1 4.14e-9
R2 1 port2 6.50e-2
R3 port1 port2 1.15e+4
L4 port1 2 2.60e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N1C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N2B02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N2B02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.25e-9
R2 1 port2 7.50e-2
R3 port1 port2 1.25e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N2B02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N2C02
* Property : L = 4.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N2C02 port1 port2
C1 port1 port2 7.10e-14
L2 port1 1 4.25e-9
R2 1 port2 7.50e-2
R3 port1 port2 1.25e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 5.50e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N2C02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N3H02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N3H02 port1 port2
C1 port1 port2 6.90e-14
L2 port1 1 4.35e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.20e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.00e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N3H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N3J02
* Property : L = 4.3[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N3J02 port1 port2
C1 port1 port2 6.90e-14
L2 port1 1 4.35e-9
R2 1 port2 8.00e-2
R3 port1 port2 1.20e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.00e-8
R6 4 port2 23.0
.ENDS LQP03HQ4N3J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N7H02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N7H02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 4.80e-9
R2 1 port2 1.25e-1
R3 port1 port2 1.35e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 18.0
.ENDS LQP03HQ4N7H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ4N7J02
* Property : L = 4.7[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ4N7J02 port1 port2
C1 port1 port2 6.35e-14
L2 port1 1 4.80e-9
R2 1 port2 1.25e-1
R3 port1 port2 1.35e+4
L4 port1 2 2.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 18.0
.ENDS LQP03HQ4N7J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ51NH02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ51NH02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 5.25e-8
R2 1 port2 1.64
R3 port1 port2 2.83e+4
L4 port1 2 8.50e-7
R4 2 port2 863
L5 port1 3 3.79e-6
R5 3 port2 1.48e+4
L6 port1 4 2.44e-6
R6 4 port2 65.9
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.14e-8
C8 7 8 8.38e-15
R8 8 port2 85.1
.ENDS LQP03HQ51NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ51NJ02
* Property : L = 51[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ51NJ02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 5.25e-8
R2 1 port2 1.64
R3 port1 port2 2.83e+4
L4 port1 2 8.50e-7
R4 2 port2 863
L5 port1 3 3.79e-6
R5 3 port2 1.48e+4
L6 port1 4 2.44e-6
R6 4 port2 65.9
L7 port1 5 2.99e-8
C7 5 6 1.05e-14
R7 6 port2 123
L8 port1 7 1.14e-8
C8 7 8 8.38e-15
R8 8 port2 85.1
.ENDS LQP03HQ51NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ56NH02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ56NH02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 5.89e-8
R2 1 port2 2.17
R3 port1 port2 2.52e+4
L4 port1 2 1.02e-6
R4 2 port2 1.40e+3
L5 port1 3 3.37e-6
R5 3 port2 913
L6 port1 4 2.03e-6
R6 4 port2 65.9
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.14e-8
C8 7 8 8.38e-15
R8 8 port2 85.1
.ENDS LQP03HQ56NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ56NJ02
* Property : L = 56[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ56NJ02 port1 port2
C1 port1 port2 8.00e-14
L2 port1 1 5.89e-8
R2 1 port2 2.17
R3 port1 port2 2.52e+4
L4 port1 2 1.02e-6
R4 2 port2 1.40e+3
L5 port1 3 3.37e-6
R5 3 port2 913
L6 port1 4 2.03e-6
R6 4 port2 65.9
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.14e-8
C8 7 8 8.38e-15
R8 8 port2 85.1
.ENDS LQP03HQ56NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ5N1H02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ5N1H02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 5.24e-9
R2 1 port2 8.50e-2
R3 port1 port2 1.58e+4
L4 port1 2 3.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 27.0
.ENDS LQP03HQ5N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ5N1J02
* Property : L = 5.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ5N1J02 port1 port2
C1 port1 port2 8.90e-14
L2 port1 1 5.24e-9
R2 1 port2 8.50e-2
R3 port1 port2 1.58e+4
L4 port1 2 3.50e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 27.0
.ENDS LQP03HQ5N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ5N6H02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ5N6H02 port1 port2
C1 port1 port2 8.10e-14
L2 port1 1 5.84e-9
R2 1 port2 1.38e-1
R3 port1 port2 1.70e+4
L4 port1 2 5.00e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 21.0
.ENDS LQP03HQ5N6H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ5N6J02
* Property : L = 5.6[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ5N6J02 port1 port2
C1 port1 port2 8.10e-14
L2 port1 1 5.84e-9
R2 1 port2 1.38e-1
R3 port1 port2 1.70e+4
L4 port1 2 5.00e-7
R4 2 port2 600
L5 port1 3 2.50e-7
R5 3 port2 1.20e+3
L6 port1 4 6.50e-8
R6 4 port2 21.0
.ENDS LQP03HQ5N6J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ62NH02
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ62NH02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 6.31e-8
R2 1 port2 4.04
R3 port1 port2 3.64e+4
L4 port1 2 1.73e-6
R4 2 port2 3.60e+3
L5 port1 3 3.45e-4
R5 3 port2 3.72e+5
L6 port1 4 1.40e-6
R6 4 port2 323
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.25e-8
C8 7 8 9.19e-15
R8 8 port2 85.1
.ENDS LQP03HQ62NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ62NJ02
* Property : L = 62[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ62NJ02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 6.31e-8
R2 1 port2 4.04
R3 port1 port2 3.64e+4
L4 port1 2 1.73e-6
R4 2 port2 3.60e+3
L5 port1 3 3.45e-4
R5 3 port2 3.72e+5
L6 port1 4 1.40e-6
R6 4 port2 323
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.25e-8
C8 7 8 9.19e-15
R8 8 port2 85.1
.ENDS LQP03HQ62NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ68NH02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ68NH02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 7.08e-8
R2 1 port2 4.04
R3 port1 port2 4.59e+4
L4 port1 2 1.73e-6
R4 2 port2 4.13e+3
L5 port1 3 3.45e-4
R5 3 port2 3.72e+5
L6 port1 4 1.98e-6
R6 4 port2 308
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.25e-8
C8 7 8 9.19e-15
R8 8 port2 85.1
.ENDS LQP03HQ68NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ68NJ02
* Property : L = 68[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ68NJ02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 7.08e-8
R2 1 port2 4.04
R3 port1 port2 4.59e+4
L4 port1 2 1.73e-6
R4 2 port2 4.13e+3
L5 port1 3 3.45e-4
R5 3 port2 3.72e+5
L6 port1 4 1.98e-6
R6 4 port2 308
L7 port1 5 3.21e-8
C7 5 6 1.13e-14
R7 6 port2 123
L8 port1 7 1.25e-8
C8 7 8 9.19e-15
R8 8 port2 85.1
.ENDS LQP03HQ68NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ6N2H02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ6N2H02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 6.20e-9
R2 1 port2 1.40e-1
R3 port1 port2 1.70e+4
L4 port1 2 3.30e-7
R4 2 port2 1.60e+3
L5 port1 3 2.30e-7
R5 3 port2 160
L6 port1 4 2.20e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ6N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ6N2J02
* Property : L = 6.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ6N2J02 port1 port2
C1 port1 port2 5.40e-14
L2 port1 1 6.20e-9
R2 1 port2 1.40e-1
R3 port1 port2 1.70e+4
L4 port1 2 3.30e-7
R4 2 port2 1.60e+3
L5 port1 3 2.30e-7
R5 3 port2 160
L6 port1 4 2.20e-7
R6 4 port2 300
L7 port1 5 8.10e-9
C7 5 6 7.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ6N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ6N8H02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ6N8H02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 6.90e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.70e+4
L4 port1 2 3.50e-7
R4 2 port2 1.60e+3
L5 port1 3 2.30e-7
R5 3 port2 160
L6 port1 4 2.20e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ6N8H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ6N8J02
* Property : L = 6.8[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ6N8J02 port1 port2
C1 port1 port2 6.50e-14
L2 port1 1 6.90e-9
R2 1 port2 1.80e-1
R3 port1 port2 1.70e+4
L4 port1 2 3.50e-7
R4 2 port2 1.60e+3
L5 port1 3 2.30e-7
R5 3 port2 160
L6 port1 4 2.20e-7
R6 4 port2 280
L7 port1 5 8.10e-9
C7 5 6 7.30e-15
R7 6 port2 60.0
.ENDS LQP03HQ6N8J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ75NH02
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ75NH02 port1 port2
C1 port1 port2 7.46e-14
L2 port1 1 7.59e-8
R2 1 port2 4.04
R3 port1 port2 9.36e+4
L4 port1 2 2.29e-6
R4 2 port2 1.01e+4
L5 port1 3 3.87e-6
R5 3 port2 4.79e+3
L6 port1 4 2.12e-6
R6 4 port2 500
L7 port1 5 7.87e-8
C7 5 6 6.35e-15
R7 6 port2 257
L8 port1 7 1.98e-8
C8 7 8 6.97e-15
R8 8 port2 123
.ENDS LQP03HQ75NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ75NJ02
* Property : L = 75[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ75NJ02 port1 port2
C1 port1 port2 7.46e-14
L2 port1 1 7.59e-8
R2 1 port2 4.04
R3 port1 port2 9.36e+4
L4 port1 2 2.29e-6
R4 2 port2 1.01e+4
L5 port1 3 3.87e-6
R5 3 port2 4.79e+3
L6 port1 4 2.12e-6
R6 4 port2 500
L7 port1 5 7.87e-8
C7 5 6 6.35e-15
R7 6 port2 257
L8 port1 7 1.98e-8
C8 7 8 6.97e-15
R8 8 port2 123
.ENDS LQP03HQ75NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ7N5H02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ7N5H02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 7.70e-9
R2 1 port2 1.60e-1
R3 port1 port2 2.00e+4
L4 port1 2 3.50e-7
R4 2 port2 1.50e+3
L5 port1 3 4.00e-7
R5 3 port2 700
L6 port1 4 1.40e-7
R6 4 port2 50.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ7N5H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ7N5J02
* Property : L = 7.5[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ7N5J02 port1 port2
C1 port1 port2 8.50e-14
L2 port1 1 7.70e-9
R2 1 port2 1.60e-1
R3 port1 port2 2.00e+4
L4 port1 2 3.50e-7
R4 2 port2 1.50e+3
L5 port1 3 4.00e-7
R5 3 port2 700
L6 port1 4 1.40e-7
R6 4 port2 50.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ7N5J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ82NH02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ82NH02 port1 port2
C1 port1 port2 7.29e-14
L2 port1 1 8.32e-8
R2 1 port2 3.94
R3 port1 port2 1.00e+5
L4 port1 2 2.39e-6
R4 2 port2 1.50e+4
L5 port1 3 2.18e-6
R5 3 port2 2.69e+3
L6 port1 4 2.93e-6
R6 4 port2 690
L7 port1 5 8.24e-8
C7 5 6 6.65e-15
R7 6 port2 257
L8 port1 7 2.32e-8
C8 7 8 8.19e-15
R8 8 port2 123
L9 port1 9 7.35e-9
C9 9 10 1.13e-14
R9 10 port2 58.9
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQ82NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ82NJ02
* Property : L = 82[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ82NJ02 port1 port2
C1 port1 port2 7.29e-14
L2 port1 1 8.32e-8
R2 1 port2 3.94
R3 port1 port2 1.00e+5
L4 port1 2 2.39e-6
R4 2 port2 1.50e+4
L5 port1 3 2.18e-6
R5 3 port2 2.69e+3
L6 port1 4 2.93e-6
R6 4 port2 690
L7 port1 5 8.24e-8
C7 5 6 6.65e-15
R7 6 port2 257
L8 port1 7 2.32e-8
C8 7 8 8.19e-15
R8 8 port2 123
L9 port1 9 7.35e-9
C9 9 10 1.13e-14
R9 10 port2 58.9
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQ82NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ8N2H02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ8N2H02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 8.45e-9
R2 1 port2 2.20e-1
R3 port1 port2 2.00e+4
L4 port1 2 3.70e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 50.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ8N2H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ8N2J02
* Property : L = 8.2[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ8N2J02 port1 port2
C1 port1 port2 7.70e-14
L2 port1 1 8.45e-9
R2 1 port2 2.20e-1
R3 port1 port2 2.00e+4
L4 port1 2 3.70e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 50.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ8N2J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ91NH02
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ91NH02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 9.12e-8
R2 1 port2 3.94
R3 port1 port2 1.00e+5
L4 port1 2 2.57e-6
R4 2 port2 1.40e+4
L5 port1 3 2.08e-6
R5 3 port2 2.69e+3
L6 port1 4 4.44e-6
R6 4 port2 1.32e+3
L7 port1 5 5.97e-8
C7 5 6 1.01e-14
R7 6 port2 178
L8 port1 7 2.73e-8
C8 7 8 8.77e-15
R8 8 port2 129
L9 port1 9 9.68e-9
C9 9 10 8.98e-15
R9 10 port2 75.9
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQ91NH02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ91NJ02
* Property : L = 91[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ91NJ02 port1 port2
C1 port1 port2 6.96e-14
L2 port1 1 9.12e-8
R2 1 port2 3.94
R3 port1 port2 1.00e+5
L4 port1 2 2.57e-6
R4 2 port2 1.40e+4
L5 port1 3 2.08e-6
R5 3 port2 2.69e+3
L6 port1 4 4.44e-6
R6 4 port2 1.32e+3
L7 port1 5 5.97e-8
C7 5 6 1.01e-14
R7 6 port2 178
L8 port1 7 2.73e-8
C8 7 8 8.77e-15
R8 8 port2 129
L9 port1 9 9.68e-9
C9 9 10 8.98e-15
R9 10 port2 75.9
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQ91NJ02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ9N1H02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ9N1H02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 9.45e-9
R2 1 port2 2.40e-1
R3 port1 port2 2.20e+4
L4 port1 2 4.20e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ9N1H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQ9N1J02
* Property : L = 9.1[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQ9N1J02 port1 port2
C1 port1 port2 6.40e-14
L2 port1 1 9.45e-9
R2 1 port2 2.40e-1
R3 port1 port2 2.20e+4
L4 port1 2 4.20e-7
R4 2 port2 2.00e+3
L5 port1 3 5.00e-7
R5 3 port2 800
L6 port1 4 1.60e-7
R6 4 port2 60.0
L7 port1 5 1.46e-8
C7 5 6 4.00e-15
R7 6 port2 60.0
.ENDS LQP03HQ9N1J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR10H02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR10H02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.02e-7
R2 1 port2 3.28
R3 port1 port2 1.00e+5
L4 port1 2 2.63e-6
R4 2 port2 1.43e+4
L5 port1 3 1.85e-6
R5 3 port2 2.35e+3
L6 port1 4 4.65e-6
R6 4 port2 2.56e+3
L7 port1 5 9.91e-8
C7 5 6 7.64e-15
R7 6 port2 263
L8 port1 7 5.08e-8
C8 7 8 5.17e-15
R8 8 port2 229
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR10H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR10J02
* Property : L = 100[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR10J02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.02e-7
R2 1 port2 3.28
R3 port1 port2 1.00e+5
L4 port1 2 2.63e-6
R4 2 port2 1.43e+4
L5 port1 3 1.85e-6
R5 3 port2 2.35e+3
L6 port1 4 4.65e-6
R6 4 port2 2.56e+3
L7 port1 5 9.91e-8
C7 5 6 7.64e-15
R7 6 port2 263
L8 port1 7 5.08e-8
C8 7 8 5.17e-15
R8 8 port2 229
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR10J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR11H02
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR11H02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.10e-7
R2 1 port2 4.85
R3 port1 port2 5.39e+4
L4 port1 2 3.31e-6
R4 2 port2 1.01e+4
L5 port1 3 2.94e-6
R5 3 port2 2.69e+3
L6 port1 4 4.65e-5
R6 4 port2 2.56e+3
L7 port1 5 9.91e-8
C7 5 6 7.64e-15
R7 6 port2 263
L8 port1 7 5.08e-8
C8 7 8 5.17e-15
R8 8 port2 229
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR11H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR11J02
* Property : L = 110[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR11J02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.10e-7
R2 1 port2 4.85
R3 port1 port2 5.39e+4
L4 port1 2 3.31e-6
R4 2 port2 1.01e+4
L5 port1 3 2.94e-6
R5 3 port2 2.69e+3
L6 port1 4 4.65e-5
R6 4 port2 2.56e+3
L7 port1 5 9.91e-8
C7 5 6 7.64e-15
R7 6 port2 263
L8 port1 7 5.08e-8
C8 7 8 5.17e-15
R8 8 port2 229
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR11J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR12H02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR12H02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.20e-7
R2 1 port2 4.74
R3 port1 port2 6.63e+4
L4 port1 2 3.31e-6
R4 2 port2 1.04e+4
L5 port1 3 2.74e-6
R5 3 port2 2.51e+3
L6 port1 4 1.47e-5
R6 4 port2 1.55e+3
L7 port1 5 1.04e-7
C7 5 6 8.00e-15
R7 6 port2 263
L8 port1 7 6.55e-8
C8 7 8 4.40e-15
R8 8 port2 282
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR12H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR12J02
* Property : L = 120[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR12J02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.20e-7
R2 1 port2 4.74
R3 port1 port2 6.63e+4
L4 port1 2 3.31e-6
R4 2 port2 1.04e+4
L5 port1 3 2.74e-6
R5 3 port2 2.51e+3
L6 port1 4 1.47e-5
R6 4 port2 1.55e+3
L7 port1 5 1.04e-7
C7 5 6 8.00e-15
R7 6 port2 263
L8 port1 7 6.55e-8
C8 7 8 4.40e-15
R8 8 port2 282
L9 port1 9 1.22e-8
C9 9 10 7.82e-15
R9 10 port2 91.2
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR12J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR13H02
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR13H02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.35e-7
R2 1 port2 4.13
R3 port1 port2 3.17e+4
L4 port1 2 5.49e-6
R4 2 port2 1.43e+4
L5 port1 3 2.33e-6
R5 3 port2 2.76e+3
L6 port1 4 3.69e-6
R6 4 port2 830
L7 port1 5 8.24e-8
C7 5 6 1.16e-14
R7 6 port2 195
L8 port1 7 6.55e-8
C8 7 8 4.40e-15
R8 8 port2 282
L9 port1 9 3.77e-8
C9 9 10 3.66e-15
R9 10 port2 234
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR13H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR13J02
* Property : L = 130[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR13J02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.35e-7
R2 1 port2 4.13
R3 port1 port2 3.17e+4
L4 port1 2 5.49e-6
R4 2 port2 1.43e+4
L5 port1 3 2.33e-6
R5 3 port2 2.76e+3
L6 port1 4 3.69e-6
R6 4 port2 830
L7 port1 5 8.24e-8
C7 5 6 1.16e-14
R7 6 port2 195
L8 port1 7 6.55e-8
C8 7 8 4.40e-15
R8 8 port2 282
L9 port1 9 3.77e-8
C9 9 10 3.66e-15
R9 10 port2 234
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR13J02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR15H02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR15H02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.66e-7
R2 1 port2 6.11
R3 port1 port2 2.70e+4
L4 port1 2 2.63e-5
R4 2 port2 5.84e+4
L5 port1 3 2.81e-6
R5 3 port2 3.55e+3
L6 port1 4 1.47e-6
R6 4 port2 81.1
L7 port1 5 1.04e-7
C7 5 6 1.01e-14
R7 6 port2 234
L8 port1 7 6.25e-8
C8 7 8 5.05e-15
R8 8 port2 257
L9 port1 9 3.28e-8
C9 9 10 4.60e-15
R9 10 port2 195
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR15H02
*----------------------------------------------------------------------
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* MURATA P/N : LQP03HQR15J02
* Property : L = 150[nH]
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz - 20GHz
*   Temperature = 25 degC
*   DC Bias Current = 0 A
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LQP03HQR15J02 port1 port2
C1 port1 port2 7.64e-14
L2 port1 1 1.66e-7
R2 1 port2 6.11
R3 port1 port2 2.70e+4
L4 port1 2 2.63e-5
R4 2 port2 5.84e+4
L5 port1 3 2.81e-6
R5 3 port2 3.55e+3
L6 port1 4 1.47e-6
R6 4 port2 81.1
L7 port1 5 1.04e-7
C7 5 6 1.01e-14
R7 6 port2 234
L8 port1 7 6.25e-8
C8 7 8 5.05e-15
R8 8 port2 257
L9 port1 9 3.28e-8
C9 9 10 4.60e-15
R9 10 port2 195
L10 port1 11 6.55e-9
C10 11 12 1.01e-14
R10 12 port2 58.9
.ENDS LQP03HQR15J02
*----------------------------------------------------------------------
